Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcBuildingElementProxy: Tree Model Detailed 27 (19)
Name | Surfaces (All) | Renovation Status | Density in % | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | Status | Length (A) (m) = Width (m) = 502.AMB.Amplada (m) = Dimension 1 (m) = Dimension 2 (m) | Area (m2) = Top Surface Area (Net) (m2) | ArchiCADQuantities, Height (m) = 503.AMB.Altura (m) = AC_Equantity_Tree_Model_Detailed_27, Height (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Surface Area (m2) = Bottom Surface Area (Net) (m2) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Survey Coordinate X (m) | Survey Coordinate Y (m) | Half A (m) = Half B (m) | Trunk Height (m) | Trunk Diameter in 3D (m) | Colliding Zones
Object_1942 | Paint - Anthracite | Existing | 50 | Preexistències | EXISTING | 10 | 100 | 16 | 0.841926 | 0 | 9.34 | 277.116 | 15.9725 | 25.3125 | 426584 | 4579801 | 5 | 6 | 0.45 | Espai públic
Object_1942 | Pine - Furniture; Foliage - Leaves Tree Small | New | 50 | Obra | NEW | 6 | 36 | 10 | 0.247539 | 0.302197 | 9.6422 | 111.111 | 10.2191 | 19.5591 | 426584 | 4579809 | 3 | 3 | 0.3 | Espai públic
Object_1942 | Pine - Furniture; Foliage - Leaves Tree Small | New | 70 | Obra | NEW | 6 | 36 | 10 | 0.247539 | 0.947212 | 10.2872 | 203.434 | 10.7784 | 20.1184 | 426555 | 4579801 | 3 | 3 | 0.3 | Espai públic
Object_1942 | Pine - Furniture; Foliage - Leaves Tree Small | New | 50 | Obra | NEW | 6 | 36 | 10 | 0.247539 | 0.302197 | 9.6422 | 111.454 | 10.0672 | 19.4072 | 426583 | 4579812 | 3 | 3 | 0.3 | Espai públic
Object_1942 | Pine - Furniture; Foliage - Leaves Tree Small | New | 70 | Obra | NEW | 6 | 36 | 10 | 0.247539 | 0.947212 | 10.2872 | 203.086 | 10.6919 | 20.0319 | 426558 | 4579805 | 3 | 3 | 0.3 | Espai públic
Object_1942 | Pine - Furniture; Foliage - Leaves Tree Small | New | 70 | Obra | NEW | 6 | 36 | 10 | 0.247539 | 0.947212 | 10.2872 | 203.769 | 10.7055 | 20.0455 | 426562 | 4579803 | 3 | 3 | 0.3 | Espai públic
