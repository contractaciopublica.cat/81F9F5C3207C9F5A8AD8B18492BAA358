Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition [CoordinationView_V2.0, SurfaceGeometryAddOnView, QuantityTakeOffAddOnView], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Single Element], Option [Railing export mode: Single Element], Option [Stair export mode: Single Element], Option [Properties To Export: Current Scheme properties only], Option [Space containment: Off], Option [Geometry to type objects: Off], Option [Element Properties: All], Option [Building Material Properties: Off], Option [Element Parameters: All], Option [Component Parameters: All], Option [IFC Base Quantities: On], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: Z:\OneDrive - MIPMARI\Ilyass\BIM\Can Trinxet\4.EXP\ifc\ENTREGA\90523221_CanTrinxet_PE_URB_A27.ifc
Time: 2025-04-29T09:12:47
Author: Architect
Organization: self-office
Written by: DDS_IFC v3.0
Made in: IFC file generated by Graphisoft Archicad 27.0.0 INT FULL Windows version (IFC add-on version: 5003 INT FULL).
Authorization: The authorising person

# IfcSite, Site
RefLatitude: 41, 21, 46, 0; RefLongitude: 2, 4, 32, 0; RefElevation: 9.34 m
BaseQuantities - GrossPerimeter: 0 m; GrossArea: 0 m2

# IfcBuilding, Building
BaseQuantities - GrossFloorArea: 0 m2

# IfcBuildingStorey (2)
In: Building
BaseQuantities - GrossFloorArea: 0 m2
Name | Elevation (m) | NetHeight (m) = GrossHeight (m) = Height (m)
planta coberta | 4.5 | 5.5
planta baixa | 0 | 4.5

# IfcBuildingElementPart (5)
In: planta baixa
Component Properties - Component Type: Core
Name | Material | Embodied Carbon | Embodied Energy (MJ) | Mass (kg) | Component Cross Section Area (m2) | Component Volume (Net) (m3) = Component Volume (Gross) (m3)
Membrane - Vapor Barrier | Membrane - Vapor Barrier | 544.821 (kgCO₂) | 21651.7 | 282.291 | 0.0049559 | 0.288052
Concrete | Concrete | 45.6664 (kgCO₂) | 315.824 | 426.789 | 0.00414945 | 0.237105
Steel - Stainless | Steel - Stainless | 1141.04 (kgCO₂) | 10519.8 | 185.535 | 0.000411 | 0.0234854
Steel - Stainless | Steel - Stainless | 1141.02 (kgCO₂) | 10519.7 | 185.532 | 0.000411 | 0.0234851
Steel - Stainless | Steel - Stainless | 583.012 (kgCO₂) | 5375.09 | 94.7987 | 0.00021 | 0.0119998 | Component Quantities - Rectangular Component Height: 0.07 m; Rectangular Component Width: 0.003 m

# IfcBuildingElementProxy: Block - Finish 200 (2)
In: planta coberta
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Block - Finish
ArchiCADProperties - Geometry Method: Single-plane; Roof Level: 1; Trimming Body: Contours Down; Element ID: RT - 002; Hotlink and Element ID: RT - 002; Layer: 00_CALLE; Building Material / Composite / Profile / Fill: Block - Finish; Building Material: Block - Finish; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Roof; Structure Type: Basic; Parent ID: RT - 002; Building Materials (All): Block - Finish; Surfaces (All): Concrete - Architecture; Brick - Street; Cover Fill: Grid 25x25; Edge Surface: Concrete - Architecture; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: RT - 002_; 109.AMB.CodiTipus: RT - 002; 115.AMB.Nivell: planta coberta; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Vertical Thickness: 0.2 m
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
Name | Pitch (deg) | Surface Area of the Roof Bottom (Gross) (m2) = Surface Area of the Roof Top (Gross) (m2) = Surface Area of the Roof Bottom (Net) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Thickness (m) = Height (m) = Block - Finish, Component Thickness (m) = 503.AMB.Altura (m) = 504.AMB.Gruix (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Block - Finish, Mass (kg) | Block - Finish, Projected Component Area (Net) (m2) = Block - Finish, Projected Component Area (Gross) (m2) | Block - Finish, Component Volume (Net) (m3) = Block - Finish, Component Volume (Gross) (m3) | Block - Finish, Embodied Carbon | Block - Finish, Embodied Energy (MJ)
RT - 002 | 0.066476 | 220.717 | 30.1647 | 0.2 | -0.126073 | 9.21393 | -4.62607 | 0.0749615 | -4.42504 | 9.41496 | -0.210448 | -4.71045 | 9.12955 | 66215.1 | 220.717 | 44.1434 | 15891.6 (kgCO₂) | 198645
RT - 002 | -1.10859 | 226.069 | 13.7225 | 0.199963 | -0.0767138 | 9.26329 | -4.57671 | 0.567572 | -3.93243 | 9.90757 | -0.13197 | -4.63197 | 9.20803 | 67808 | 226.108 | 45.2053 | 16273.9 (kgCO₂) | 203424 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia

# IfcBuildingElementProxy: Block - Finish 66 (6)
In: planta coberta
Material: Block - Finish
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
1 AMB.Identificacio - 107.AMB.NomTipus: RT - 002_; 109.AMB.CodiTipus: RT - 002; 115.AMB.Nivell: planta coberta; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
ArchiCADProperties - Geometry Method: Single-plane; Roof Level: 1; Trimming Body: Contours Down; Element ID: RT - 002; Hotlink and Element ID: RT - 002; Building Material / Composite / Profile / Fill: Block - Finish; Building Material: Block - Finish; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Roof; Structure Type: Basic; Parent ID: RT - 002; Building Materials (All): Block - Finish; Cover Fill: Panel 160x160; Edge Surface: Concrete - Architecture; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Hips Length: 0 m; Hollow Connection Length: 0 m; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.0659383 m; Height: 0.0659383 m
5 AMB.Geometria - 503.AMB.Altura: 0.0659383 m; 504.AMB.Gruix: 0.0659383 m; 506.AMB.Profunditat: 0 m
Component Quantities - Block - Finish, Component Thickness: 0.0659383 m
Name | Classification | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | Pitch (deg) | Layer | Colliding Zones | Surfaces (All) | Surface Area of the Roof Bottom (Gross) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Surface Area of the Roof Top (Gross) (m2) | Holes Surface Area (m2) | Surface Area of the Roof Bottom (Net) (m2) | Number of Holes | Vertical Thickness (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Block - Finish, Mass (kg) | Block - Finish, Projected Component Area (Net) (m2) | Block - Finish, Projected Component Area (Gross) (m2) | Block - Finish, Component Volume (Net) (m3) | Block - Finish, Component Volume (Gross) (m3) | Block - Finish, Embodied Carbon | Block - Finish, Embodied Energy (MJ)
RT - 002 | 70.40 Instal·lacions i serveis (GuBIMclass CA) | 70.40 Instal·lacions i serveis | 70.40 | Instal·lacions i serveis | -3.33 | 00_TAPAS | Espai públic | Concrete - Architecture; Concrete - Rough Finish | 0.264046 | 0.14672 | 0.264046 | 0 | 0.264046 | 0 | 0.0660498 | 0.141346 | 9.48135 | -4.35865 | 1.08731 | -3.41269 | 10.4273 | 0.975498 | -3.5245 | 10.3155 | 26.1161 | 0.265541 | 0.265541 | 0.0174107 | 0.0174107 | 6.26787 (kgCO₂) | 78.3483
RT - 002 | 70.40 Instal·lacions i serveis (GuBIMclass CA) | 70.40 Instal·lacions i serveis | 70.40 | Instal·lacions i serveis | -3.33 | 00_TAPAS | Espai públic | Concrete - Architecture; Concrete - Rough Finish | 0.98249 | 0.273736 | 0.98249 | 0 | 0.98249 | 0 | 0.0660498 | 0.141346 | 9.48135 | -4.35865 | 1.08321 | -3.41679 | 10.4232 | 0.969906 | -3.53009 | 10.3099 | 97.1757 | 0.987795 | 0.987795 | 0.0647838 | 0.0647838 | 23.3222 (kgCO₂) | 291.527
RT - 002 | 70.30.20 Paviments peatonals (GuBIMclass CA) | 70.30.20 Paviments peatonals | 70.30.20 | Paviments peatonals | -1.10859 | 00_ADOQUIN | Espai públic; Nau Lateral | Concrete - Architecture; Concrete - Bush hammered | 72.0214 | 2.67751 | 72.0213 | 0 | 72.0214 | 0 | 0.0659507 | 1.14 | 10.48 | -3.36 | 1.51018 | -2.98982 | 10.8502 | 1.14 | -3.36 | 10.48 | 7123.45 | 72.0272 | 72.0272 | 4.74897 | 4.74897 | 1709.63 (kgCO₂) | 21370.4
RT - 002 | 70.30.20 Paviments peatonals (GuBIMclass CA) | 70.30.20 Paviments peatonals | 70.30.20 | Paviments peatonals | -3.33 | 00_ADOQUIN | Espai públic; Nau Annexa; Nau Lateral | Concrete - Architecture; Concrete - Bush hammered | 494.844 | 13.0561 | 494.844 | 5.28824 | 489.556 | 4 | 0.0660498 | 0.141346 | 9.48135 | -4.35865 | 1.25202 | -3.24798 | 10.592 | 0.141346 | -4.35865 | 9.48135 | 48420.7 | 489.831 | 495.101 | 32.2805 | 32.6292 | 11621 (kgCO₂) | 145262
RT - 002 | 70.40 Instal·lacions i serveis (GuBIMclass CA) | 70.40 Instal·lacions i serveis | 70.40 | Instal·lacions i serveis | -3.33 | 00_TAPAS | Espai públic | Concrete - Architecture; Concrete - Rough Finish | 0.268142 | 0.148292 | 0.268142 | 0 | 0.268142 | 0 | 0.0660498 | 0.141346 | 9.48135 | -4.35865 | 1.22055 | -3.27945 | 10.5606 | 1.10805 | -3.39195 | 10.448 | 26.5213 | 0.269641 | 0.269641 | 0.0176809 | 0.0176809 | 6.36511 (kgCO₂) | 79.5639
RT - 002 | 70.40 Instal·lacions i serveis (GuBIMclass CA) | 70.40 Instal·lacions i serveis | 70.40 | Instal·lacions i serveis | -3.33 | 00_TAPAS | Espai públic | Concrete - Architecture; Concrete - Rough Finish | 3.77838 | 0.523345 | 3.77838 | 0 | 3.77838 | 0 | 0.0660498 | 0.141346 | 9.48135 | -4.35865 | 1.19503 | -3.30497 | 10.535 | 1.02816 | -3.47184 | 10.3682 | 373.71 | 3.78783 | 3.78783 | 0.24914 | 0.24914 | 89.6903 (kgCO₂) | 1121.13

# IfcBuildingElementProxy: Block - Finish 67 (7)
In: planta coberta
Classification: 70.30.20 Paviments peatonals (GuBIMclass CA); Material: Block - Finish
Pset_BuildingElementProxyCommon - Status: NEW
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
1 AMB.Identificacio - 103.AMB.Classificacio: 70.30.20 Paviments peatonals; 104.AMB.ClassificacioCodi: 70.30.20; 105.AMB.ClassificacioDescripcio: Paviments peatonals; 107.AMB.NomTipus: RT - 002_; 109.AMB.CodiTipus: RT - 002; 115.AMB.Nivell: planta coberta; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Geometry Method: Single-plane; Roof Level: 1; Trimming Body: Contours Down; Element ID: RT - 002; Hotlink and Element ID: RT - 002; Layer: 00_ADOQUIN; Building Material / Composite / Profile / Fill: Block - Finish; Building Material: Block - Finish; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Roof; Structure Type: Basic; Parent ID: RT - 002; Building Materials (All): Block - Finish; Cover Fill: Panel 160x160; Edge Surface: Concrete - Architecture; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m
Name | Pitch (deg) | Colliding Zones | Surfaces (All) | 503.AMB.Altura (m) = 504.AMB.Gruix (m) = Block - Finish, Component Thickness (m) = Thickness (m) = Height (m) | Block - Finish, Embodied Carbon | Block - Finish, Embodied Energy (MJ) | Block - Finish, Mass (kg) | Block - Finish, Projected Component Area (Net) (m2) = Block - Finish, Projected Component Area (Gross) (m2) | Block - Finish, Component Volume (Net) (m3) = Block - Finish, Component Volume (Gross) (m3) | Surface Area of the Roof Bottom (Gross) (m2) = Surface Area of the Roof Bottom (Net) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Surface Area of the Roof Top (Gross) (m2) | Vertical Thickness (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m)
RT - 002 | -3.338 | Espai públic | Concrete - Architecture; Concrete - Bush hammered | 0.0666303 | 313.93 (kgCO₂) | 3924.12 | 1308.04 | 13.0982 | 0.872027 | 13.0876 | 1.0016 | 13.0875 | 0.0667435 | 1.13826 | 10.4783 | -3.36174 | 1.205 | -3.295 | 10.545 | 0.860619 | -3.63938 | 10.2006
RT - 002 | 1.42772 | Espai públic; Nau Santa Eulàlia | Concrete - Architecture; Concrete - Bush hammered | 0.0669792 | 776.416 (kgCO₂) | 9705.2 | 3235.07 | 32.2113 | 2.15671 | 32.1999 | 1.92111 | 32.1995 | 0.067 | 0.142234 | 9.48223 | -4.35777 | 0.209209 | -4.29079 | 9.54921 | -0.0653464 | -4.56535 | 9.27465
RT - 002 | 0.929863 | Espai públic | Concrete - Architecture; Concrete - Bush hammered | 0.0666303 | 379.411 (kgCO₂) | 4742.64 | 1580.88 | 15.8203 | 1.05392 | 15.8174 | 1.78214 | 15.8174 | 0.0666391 | 0.946134 | 10.2861 | -3.55387 | 1.20595 | -3.29405 | 10.546 | 0.946124 | -3.55388 | 10.2861
RT - 002 | 4.36765 | Espai públic | Concrete - Architecture; Concrete - Bush hammered | 0.0666303 | 1073.63 (kgCO₂) | 13420.4 | 4473.48 | 44.8235 | 2.98232 | 44.7592 | 2.40057 | 44.7592 | 0.0668244 | 0.259624 | 9.59962 | -4.24038 | 0.927362 | -3.57264 | 10.2674 | 0.259624 | -4.24038 | 9.59962
RT - 002 | 4.36765 |  | Concrete - Architecture; Brick - Stone | 0.0666303 | 0.210886 (kgCO₂) | 2.63607 | 0.878692 | 0.0116389 | 0.000585794 | 0.00879193 | 0.076926 | 0.00879149 | 0.0668244 | 0.259624 | 9.59962 | -4.24038 | 0.328842 | -4.17116 | 9.66884 | 0.259624 | -4.24038 | 9.59962
RT - 002 | 0.862692 | Espai públic; Nau Santa Eulàlia | Concrete - Architecture; Concrete - Bush hammered | 0.0669924 | 207.563 (kgCO₂) | 2594.53 | 864.845 | 8.61205 | 0.576563 | 8.6064 | 1.31244 | 8.6064 | 0.067 | 0.142308 | 9.48231 | -4.35769 | 0.276103 | -4.2239 | 9.6161 | 0.0960558 | -4.40394 | 9.43606
RT - 002 | -1.93585 | Espai públic; Nau Santa Eulàlia | Concrete - Architecture; Concrete - Bush hammered | 0.0669618 | 2287.43 (kgCO₂) | 28592.8 | 9530.94 | 95.0018 | 6.35396 | 94.8894 | 6.94546 | 94.8894 | 0.067 | 0.20149 | 9.54149 | -4.29851 | 0.323147 | -4.17685 | 9.66315 | 0.1422 | -4.3578 | 9.4822

# IfcBuildingElementProxy: Concrete - Structural 135 (4)
In: planta baixa
Classification: 70.30.20 Paviments peatonals (GuBIMclass CA); Material: Concrete - Structural
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 70.30.20 Paviments peatonals; 104.AMB.ClassificacioCodi: 70.30.20; 105.AMB.ClassificacioDescripcio: Paviments peatonals; 107.AMB.NomTipus: SLA - 007_; 109.AMB.CodiTipus: SLA - 007; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
ArchiCADProperties - Reference Plane Location: Top; Element ID: SLA - 007; Hotlink and Element ID: SLA - 007; Layer: 00_ADOQUIN; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Basic; Parent ID: SLA - 007; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Cover Fill: Panel 160x160; Number of Openings: 0; Top Surface: Concrete - Bush hammered; Edge Surface: Concrete - Bush hammered; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
ArchiCADQuantities - Holes Surface Area: 0 m2; Height: 0.135 m; Thickness: 0.135 m; Floor Plan Holes Perimeter: 0 m
Pset_BuildingElementProxyCommon - Status: NEW
5 AMB.Geometria - 503.AMB.Altura: 0.135 m; 504.AMB.Gruix: 0.135 m; 506.AMB.Profunditat: 0 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
Component Quantities - Concrete - Structural, Component Thickness: 0.135 m
Name | Concrete - Structural, Embodied Carbon | Concrete - Structural, Embodied Energy (MJ) | Elevation Bottom (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Surface Area of the Slab Top (Conditional) (m2) = Surface Area of the Slab Bottom (Gross) (m2) = Surface Area of the Slab Bottom (Gross, with holes) (m2) = Surface Area of the Slab Top (Gross) (m2) = Surface Area of the Slab Top (Gross, with holes) (m2) = Area (m2) = Surface Area (m2) = Top Surface Area (Net) (m2) = Top Surface Area (Conditional) (m2) = Bottom Surface Area (Net) (m2) = Bottom Surface Area (Conditional) (m2) = Bottom Surface Area (Gross) (m2) = Top Surface Area (Gross) (m2) = Concrete - Structural, Projected Component Area (Net) (m2) = Concrete - Structural, Projected Component Area (Gross) (m2) | Surface Area of the Slab Edges (Gross) (m2) = Surface Area of the Slab Edges (Gross, with holes) (m2) = Edge Surface Area (Net) (m2) = Edge Surface Area (Gross) (m2) | Elevation Top (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Volume (Net) (m3) = Volume (Conditional) (m3) = Volume (Gross) (m3) = Concrete - Structural, Component Volume (Net) (m3) = Concrete - Structural, Component Volume (Gross) (m3) | Elevation to Sea Level (m) = Top Elevation To Sea Level (m) | Floor Plan Perimeter (m) | Bottom Elevation To Sea Level (m) | Concrete - Structural, Mass (kg)
SLA - 007 | 630.002 (kgCO₂) | 6109.11 | 1.61 | 10.2474 | 1.75273 | 1.745 | 1.3834 | 11.085 | 12.9832 | 10.95 | 3181.83
SLA - 007 | 283.261 (kgCO₂) | 2746.77 | 1.475 | 4.60744 | 1.19136 | 1.61 | 0.622004 | 10.95 | 8.82491 | 10.815 | 1430.61
SLA - 007 | 283.237 (kgCO₂) | 2746.54 | 1.34 | 4.60705 | 1.19149 | 1.475 | 0.621952 | 10.815 | 8.82582 | 10.68 | 1430.49
SLA - 007 | 282.402 (kgCO₂) | 2738.44 | 1.205 | 4.59347 | 1.19014 | 1.34 | 0.620118 | 10.68 | 8.81582 | 10.545 | 1426.27

# IfcBuildingElementProxy: Concrete - Structural 200 x 743, BMR - 004
In: planta baixa
Classification: Beam (ARCHICAD Classification); Material: Concrete - Structural
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Concrete - Bush hammered; Left Side Surface: Concrete - Bush hammered; Right Side Surface: Concrete - Bush hammered; Beam Slant Angle: 3.2904 deg; Element ID: BMR - 004; Hotlink and Element ID: BMR - 004; Layer: 00_JARDINERA; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Parent ID: BMR - 004; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Cover Fill: Carpet; Slant Angle: 3.2904 deg; Number of Openings: 0; Top Surface: Concrete - Bush hammered; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 107.AMB.NomTipus: BMR - 004_; 109.AMB.CodiTipus: BMR - 004; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Concrete - Structural, Embodied Carbon: 278.485 (kgCO₂); Concrete - Structural, Embodied Energy: 2700.46 MJ; Concrete - Structural, Component Type: Core
ArchiCADQuantities - Surface Area of Both Beam Ends: 0.235107 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Surface Area of the Beam Left Side (Net): 3.05759 m2; Length Left: 5.21063 m; Length Right: 5.21063 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 3.05759 m2; Area: 1.04041 m2; Height: 0.743452 m; Volume (Net): 0.611517 m3; Width: 0.2 m; Elevation to Project Zero: 0.698634 m; Elevation to 1st Reference Level: 0.698634 m; Elevation to 2nd Reference Level: 0.698634 m; Elevation to Sea Level: 10.0386 m; Elevation to Linked/Home Story: 0.698634 m; Home Offset: 0.698634 m; Surface Area: 8.44013 m2; 3D Length: 5.25352 m; Volume (Conditional): 0.611517 m3; Volume (Gross): 0.611517 m3; Top Elevation To First Reference Level: 1.745 m; Top Elevation To Home Story: 1.745 m; Top Elevation To Project Zero: 1.745 m; Top Elevation To Sea Level: 11.085 m; Top Elevation To Second Reference Level: 1.745 m; Bottom Elevation To First Reference Level: 0.698634 m; Bottom Elevation To Home Story: 0.698634 m; Bottom Elevation To Project Zero: 0.698634 m; Bottom Elevation To Sea Level: 10.0386 m; Bottom Elevation To Second Reference Level: 0.698634 m; Cross Section Height at Top/End (perpendicular): 0.743452 m; Cross Section Height at Bottom/Start (perpendicular): 0.426033 m; Cross Section Width at Top/End (perpendicular): 0.2 m; Cross Section Width at Bottom/Start (perpendicular): 0.2 m; Cross Section Height at Top/End (cut): 0.744679 m; Cross Section Height at Bottom/Start (cut): 0.426737 m; Cross Section Width at Top/End (cut): 0.2 m; Cross Section Width at Bottom/Start (cut): 0.2 m; Cross Section Area at Bottom/Start: 0.0856473 m2; Cross Section Area at Top/End: 0.149459 m2; Number of Segments: 1; Top Surface Area (Net): 1.04773 m2; Bottom Surface Area (Net): 1.04213 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.2 m; 503.AMB.Altura: 0.743452 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete - Structural, Mass: 1406.49 kg; Concrete - Structural, Component Volume (Net): 0.611517 m3; Concrete - Structural, Component Volume (Gross): 0.611517 m3

# IfcBuildingElementProxy: Concrete - Structural 200 x 824, BMR - 004
In: planta baixa
Classification: Beam (ARCHICAD Classification); Material: Concrete - Structural
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Concrete - Bush hammered; Left Side Surface: Concrete - Bush hammered; Right Side Surface: Concrete - Bush hammered; Beam Slant Angle: 3.33954 deg; Element ID: BMR - 004; Hotlink and Element ID: BMR - 004; Layer: 00_JARDINERA; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Parent ID: BMR - 004; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Cover Fill: Carpet; Slant Angle: 3.33954 deg; Number of Openings: 0; Top Surface: Concrete - Bush hammered; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Pset_BuildingElementProxyCommon - Status: NEW
1 AMB.Identificacio - 107.AMB.NomTipus: BMR - 004_; 109.AMB.CodiTipus: BMR - 004; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
Component Quantities - Concrete - Structural, Mass: 1605.38 kg; Concrete - Structural, Component Volume (Net): 0.697992 m3; Concrete - Structural, Component Volume (Gross): 0.697992 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.2 m; 503.AMB.Altura: 0.823871 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Surface Area of Both Beam Ends: 0.268353 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Surface Area of the Beam Left Side (Net): 3.48996 m2; Length Left: 5.21089 m; Length Right: 5.21089 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 3.48996 m2; Area: 1.04041 m2; Height: 0.823871 m; Volume (Net): 0.697992 m3; Width: 0.2 m; Elevation to Project Zero: 0.613279 m; Elevation to 1st Reference Level: 0.613279 m; Elevation to 2nd Reference Level: 0.613279 m; Elevation to Sea Level: 9.95328 m; Elevation to Linked/Home Story: 0.613279 m; Home Offset: 0.613279 m; Surface Area: 9.33818 m2; 3D Length: 5.25913 m; Volume (Conditional): 0.697992 m3; Volume (Gross): 0.697992 m3; Top Elevation To First Reference Level: 1.745 m; Top Elevation To Home Story: 1.745 m; Top Elevation To Project Zero: 1.745 m; Top Elevation To Sea Level: 11.085 m; Top Elevation To Second Reference Level: 1.745 m; Bottom Elevation To First Reference Level: 0.613279 m; Bottom Elevation To Home Story: 0.613279 m; Bottom Elevation To Project Zero: 0.613279 m; Bottom Elevation To Sea Level: 9.95328 m; Bottom Elevation To Second Reference Level: 0.613279 m; Cross Section Height at Top/End (perpendicular): 0.823871 m; Cross Section Height at Bottom/Start (perpendicular): 0.510923 m; Cross Section Width at Top/End (perpendicular): 0.2 m; Cross Section Width at Bottom/Start (perpendicular): 0.2 m; Cross Section Height at Top/End (cut): 0.825272 m; Cross Section Height at Bottom/Start (cut): 0.511792 m; Cross Section Width at Top/End (cut): 0.2 m; Cross Section Width at Bottom/Start (cut): 0.2 m; Cross Section Area at Bottom/Start: 0.102718 m2; Cross Section Area at Top/End: 0.165635 m2; Number of Segments: 1; Top Surface Area (Net): 1.04773 m2; Bottom Surface Area (Net): 1.04218 m2
Component Properties - Concrete - Structural, Embodied Carbon: 317.866 (kgCO₂); Concrete - Structural, Embodied Energy: 3082.33 MJ; Concrete - Structural, Component Type: Core
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Concrete - Structural 200 x 828, BMR - 004
In: planta baixa
Classification: Beam (ARCHICAD Classification); Material: Concrete - Structural
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Concrete - Bush hammered; Left Side Surface: Concrete - Bush hammered; Right Side Surface: Concrete - Bush hammered; Beam Slant Angle: 0 deg; Element ID: BMR - 004; Hotlink and Element ID: BMR - 004; Layer: 00_JARDINERA; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Parent ID: BMR - 004; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Cover Fill: Carpet; Slant Angle: 0 deg; Number of Openings: 0; Top Surface: Concrete - Bush hammered; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 107.AMB.NomTipus: BMR - 004_; 109.AMB.CodiTipus: BMR - 004; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
ArchiCADQuantities - Surface Area of Both Beam Ends: 0.328456 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 19.6937 m2; Length Left: 24.16 m; Length Right: 24.16 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 20.0087 m2; Area: 4.832 m2; Height: 0.828175 m; Volume (Net): 4.00118 m3; Width: 0.2 m; Elevation to Project Zero: 1.745 m; Elevation to 1st Reference Level: 1.745 m; Elevation to 2nd Reference Level: 1.745 m; Elevation to Sea Level: 11.085 m; Elevation to Linked/Home Story: 1.745 m; Home Offset: 1.745 m; Surface Area: 50.0135 m2; 3D Length: 24.16 m; Volume (Conditional): 4.00118 m3; Volume (Gross): 4.00174 m3; Top Elevation To First Reference Level: 1.745 m; Top Elevation To Home Story: 1.745 m; Top Elevation To Project Zero: 1.745 m; Top Elevation To Sea Level: 11.085 m; Top Elevation To Second Reference Level: 1.745 m; Bottom Elevation To First Reference Level: 0.916828 m; Bottom Elevation To Home Story: 0.916828 m; Bottom Elevation To Project Zero: 0.916828 m; Bottom Elevation To Sea Level: 10.2568 m; Bottom Elevation To Second Reference Level: 0.916828 m; Cross Section Height at Top/End (perpendicular): 0.828175 m; Cross Section Height at Bottom/Start (perpendicular): 0.828175 m; Cross Section Width at Top/End (perpendicular): 0.2 m; Cross Section Width at Bottom/Start (perpendicular): 0.2 m; Cross Section Height at Top/End (cut): 0.828175 m; Cross Section Height at Bottom/Start (cut): 0.828175 m; Cross Section Width at Top/End (cut): 0.2 m; Cross Section Width at Bottom/Start (cut): 0.2 m; Cross Section Area at Bottom/Start: 0.164156 m2; Cross Section Area at Top/End: 0.1643 m2; Number of Segments: 1; Top Surface Area (Net): 4.832 m2; Bottom Surface Area (Net): 4.83164 m2
Component Properties - Concrete - Structural, Embodied Carbon: 1822.14 (kgCO₂); Concrete - Structural, Embodied Energy: 17669.2 MJ; Concrete - Structural, Component Type: Core
Pset_BuildingElementProxyCommon - Status: NEW
Component Quantities - Concrete - Structural, Mass: 9202.71 kg; Concrete - Structural, Projected Component Area (Net): 20.0087 m2; Concrete - Structural, Projected Component Area (Gross): 20.0087 m2; Concrete - Structural, Component Thickness: 0.2 m; Concrete - Structural, Rectangular Component Height: 0.828175 m; Concrete - Structural, Rectangular Component Width: 0.2 m; Concrete - Structural, Component Cross Section Area: 0.165635 m2; Concrete - Structural, Component Volume (Net): 4.00118 m3; Concrete - Structural, Component Volume (Gross): 4.00118 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.2 m; 503.AMB.Altura: 0.828175 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Concrete - Structural 40 x 80 (2)
In: planta baixa
Classification: Beam (ARCHICAD Classification); Material: Concrete - Structural
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Paint - Anthracite; Left Side Surface: Paint - Anthracite; Right Side Surface: Paint - Anthracite; Beam Slant Angle: 0 deg; Element ID: BMR - 005; Hotlink and Element ID: BMR - 005; Layer: 00_PERIMETRO; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Parent ID: BMR - 005; Building Materials (All): Concrete - Structural; Cover Fill: Background; Slant Angle: 0 deg; Number of Openings: 0; Top Surface: Paint - Anthracite; Bottom Surface: Paint - Anthracite; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 107.AMB.NomTipus: BMR - 005_; 109.AMB.CodiTipus: BMR - 005; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Concrete - Structural, Component Type: Core
5 AMB.Geometria - 502.AMB.Amplada: 0.04 m; 503.AMB.Altura: 0.08 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete - Structural, Component Thickness: 0.04 m; Concrete - Structural, Rectangular Component Height: 0.08 m; Concrete - Structural, Rectangular Component Width: 0.04 m; Concrete - Structural, Component Cross Section Area: 0.0032 m2
ArchiCADQuantities - Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Length Left: 4.56157 m; Length Right: 4.56157 m; Offset: 0 m; Height: 0.08 m; Width: 0.04 m; Volume (Gross): 0.014597 m3; Cross Section Height at Top/End (perpendicular): 0.08 m; Cross Section Height at Bottom/Start (perpendicular): 0.08 m; Cross Section Width at Top/End (perpendicular): 0.04 m; Cross Section Width at Bottom/Start (perpendicular): 0.04 m; Cross Section Height at Top/End (cut): 0.08 m; Cross Section Height at Bottom/Start (cut): 0.08 m; Cross Section Width at Top/End (cut): 0.04 m; Cross Section Width at Bottom/Start (cut): 0.04 m; Number of Segments: 1
Name | Surfaces (All) | Concrete - Structural, Embodied Carbon | Concrete - Structural, Embodied Energy (MJ) | Concrete - Structural, Mass (kg) | Concrete - Structural, Projected Component Area (Net) (m2) = Concrete - Structural, Projected Component Area (Gross) (m2) = Surface Area of the Beam Left Side (Net) (m2) = Surface Area of the Beam Right Side (Net) (m2) | Concrete - Structural, Component Volume (Net) (m3) = Concrete - Structural, Component Volume (Gross) (m3) = Volume (Net) (m3) = Volume (Conditional) (m3) | Surface Area of Both Beam Ends (m2) | Area (m2) = Top Surface Area (Net) (m2) = Bottom Surface Area (Net) (m2) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Top Elevation To Sea Level (m) | Surface Area (m2) | 3D Length (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Cross Section Area at Bottom/Start (m2) = Cross Section Area at Top/End (m2)
BMR - 005 | Paint - Anthracite | 6.64749 (kgCO₂) | 64.4605 | 33.5732 | 0.364926 | 0.014597 | 0.0064 | 0.182463 | 0.478301 | 9.8183 | 1.10118 | 4.56157 | 0.398301 | 9.7383 | 0.0032
BMR - 005 | Paint - Anthracite; Concrete - Bush hammered | 5.59096 (kgCO₂) | 54.2154 | 28.2372 | 0.339326 | 0.012277 | 0 | 0.153463 | 2.2783 | 11.6183 | 1.17727 | 4.24157 | 2.1983 | 11.5383 | 0

# IfcBuildingElementProxy: Concrete - Structural 600 x 550, BMR - 004
In: planta baixa
Classification: Beam (ARCHICAD Classification); Material: Concrete - Structural
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Concrete - Bush hammered; Left Side Surface: Concrete - Bush hammered; Right Side Surface: Concrete - Bush hammered; Beam Slant Angle: 0 deg; Element ID: BMR - 004; Hotlink and Element ID: BMR - 004; Layer: 00_JARDINERA; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Parent ID: BMR - 004; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Cover Fill: Carpet; Slant Angle: 0 deg; Number of Openings: 0; Top Surface: Concrete - Bush hammered; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 107.AMB.NomTipus: BMR - 004_; 109.AMB.CodiTipus: BMR - 004; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Concrete - Structural, Embodied Carbon: 3220.55 (kgCO₂); Concrete - Structural, Embodied Energy: 31229.6 MJ; Concrete - Structural, Component Type: Core
ArchiCADQuantities - Surface Area of Both Beam Ends: 0.585424 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 12.2075 m2; Length Left: 24.16 m; Length Right: 24.16 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 11.3656 m2; Area: 14.496 m2; Height: 0.550001 m; Volume (Net): 7.07192 m3; Width: 0.6 m; Elevation to Project Zero: 0.576868 m; Elevation to 1st Reference Level: 0.576868 m; Elevation to 2nd Reference Level: 0.576868 m; Elevation to Sea Level: 9.91687 m; Elevation to Linked/Home Story: 0.576868 m; Home Offset: 0.576868 m; Surface Area: 53.175 m2; 3D Length: 24.16 m; Volume (Conditional): 7.07192 m3; Volume (Gross): 7.07192 m3; Top Elevation To First Reference Level: 1.12687 m; Top Elevation To Home Story: 1.12687 m; Top Elevation To Project Zero: 1.12687 m; Top Elevation To Sea Level: 10.4669 m; Top Elevation To Second Reference Level: 1.12687 m; Bottom Elevation To First Reference Level: 0.578883 m; Bottom Elevation To Home Story: 0.578883 m; Bottom Elevation To Project Zero: 0.578883 m; Bottom Elevation To Sea Level: 9.91888 m; Bottom Elevation To Second Reference Level: 0.578883 m; Cross Section Height at Top/End (perpendicular): 0.550001 m; Cross Section Height at Bottom/Start (perpendicular): 0.550001 m; Cross Section Width at Top/End (perpendicular): 0.6 m; Cross Section Width at Bottom/Start (perpendicular): 0.6 m; Cross Section Height at Top/End (cut): 0.550001 m; Cross Section Height at Bottom/Start (cut): 0.550001 m; Cross Section Width at Top/End (cut): 0.6 m; Cross Section Width at Bottom/Start (cut): 0.6 m; Cross Section Area at Bottom/Start: 0.318338 m2; Cross Section Area at Top/End: 0.267085 m2; Number of Segments: 1; Top Surface Area (Net): 14.496 m2; Bottom Surface Area (Net): 0 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.6 m; 503.AMB.Altura: 0.550001 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete - Structural, Mass: 16265.4 kg; Concrete - Structural, Projected Component Area (Net): 12.2075 m2; Concrete - Structural, Projected Component Area (Gross): 12.2075 m2; Concrete - Structural, Component Thickness: 0.6 m; Concrete - Structural, Rectangular Component Height: 0.550001 m; Concrete - Structural, Rectangular Component Width: 0.6 m; Concrete - Structural, Component Cross Section Area: 0.330001 m2; Concrete - Structural, Component Volume (Net): 7.07192 m3; Concrete - Structural, Component Volume (Gross): 7.07192 m3

# IfcBuildingElementProxy: Concrete - Structural 67, RT - 002
In: planta coberta
Classification: 70.30.20 Paviments peatonals (GuBIMclass CA); Material: Concrete - Structural
Component Properties - Concrete - Structural, Embodied Carbon: 745.478 (kgCO₂); Concrete - Structural, Embodied Energy: 7228.88 MJ
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Surface Area of the Roof Bottom (Gross): 24.5679 m2; Surface Area of the Roof Edges (Gross): 1.57937 m2; Surface Area of the Roof Top (Gross): 24.5681 m2; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Surface Area of the Roof Bottom (Net): 24.5679 m2; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.0666303 m; Vertical Thickness: 0.0668442 m; Height: 0.0666303 m; Elevation to Project Zero: 1.67817 m; Elevation to 1st Reference Level: 1.67817 m; Elevation to 2nd Reference Level: 1.67817 m; Elevation to Sea Level: 11.0182 m; Elevation to Linked/Home Story: -2.82183 m; Home Offset: -2.82183 m; Top Elevation To First Reference Level: 1.74506 m; Top Elevation To Home Story: -2.75494 m; Top Elevation To Project Zero: 1.74506 m; Top Elevation To Sea Level: 11.0851 m; Top Elevation To Second Reference Level: 1.74506 m; Bottom Elevation To First Reference Level: 0.945889 m; Bottom Elevation To Home Story: -3.55411 m; Bottom Elevation To Project Zero: 0.945889 m; Bottom Elevation To Sea Level: 10.2859 m; Bottom Elevation To Second Reference Level: 0.945889 m
Pset_BuildingElementProxyCommon - Status: NEW
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
1 AMB.Identificacio - 103.AMB.Classificacio: 70.30.20 Paviments peatonals; 104.AMB.ClassificacioCodi: 70.30.20; 105.AMB.ClassificacioDescripcio: Paviments peatonals; 107.AMB.NomTipus: RT - 002_; 109.AMB.CodiTipus: RT - 002; 115.AMB.Nivell: planta coberta; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Geometry Method: Single-plane; Pitch: -4.58467 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: RT - 002; Hotlink and Element ID: RT - 002; Layer: 00_ADOQUIN; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Roof; Structure Type: Basic; Parent ID: RT - 002; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Cover Fill: Panel 160x160; Edge Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Concrete - Structural, Mass: 3765.04 kg; Concrete - Structural, Projected Component Area (Net): 24.5823 m2; Concrete - Structural, Projected Component Area (Gross): 24.5823 m2; Concrete - Structural, Component Thickness: 0.0666303 m; Concrete - Structural, Component Volume (Net): 1.63697 m3; Concrete - Structural, Component Volume (Gross): 1.63697 m3
5 AMB.Geometria - 503.AMB.Altura: 0.0666303 m; 504.AMB.Gruix: 0.0666303 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Concrete - Structural D40 (2)
In: planta baixa
Classification: Beam (ARCHICAD Classification); Material: Concrete - Structural
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Beam Cross Section: Circular; End Surface: Paint - Anthracite; Beam Slant Angle: 0 deg; Extrusion Surface: Paint - Anthracite; Element ID: BMR - 005; Hotlink and Element ID: BMR - 005; Layer: 00_PERIMETRO; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Parent ID: BMR - 005; Building Materials (All): Concrete - Structural; Surfaces (All): Paint - Anthracite; Concrete - Bush hammered; Cover Fill: Background; Slant Angle: 0 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 107.AMB.NomTipus: BMR - 005_; 109.AMB.CodiTipus: BMR - 005; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Concrete - Structural, Component Type: Core
ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0024 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Offset: 0 m; Height: 0.04 m; Width: 0.04 m; Elevation to Project Zero: 2.1783 m; Elevation to 1st Reference Level: 2.1783 m; Elevation to 2nd Reference Level: 2.1783 m; Elevation to Sea Level: 11.5183 m; Elevation to Linked/Home Story: 2.1783 m; Home Offset: 2.1783 m; Top Elevation To First Reference Level: 2.1783 m; Top Elevation To Home Story: 2.1783 m; Top Elevation To Project Zero: 2.1783 m; Top Elevation To Sea Level: 11.5183 m; Top Elevation To Second Reference Level: 2.1783 m; Bottom Elevation To First Reference Level: 2.1383 m; Bottom Elevation To Home Story: 2.1383 m; Bottom Elevation To Project Zero: 2.1383 m; Bottom Elevation To Sea Level: 11.4783 m; Bottom Elevation To Second Reference Level: 2.1383 m; Cross Section Height at Top/End (perpendicular): 0.04 m; Cross Section Height at Bottom/Start (perpendicular): 0.04 m; Cross Section Width at Top/End (perpendicular): 0.04 m; Cross Section Width at Bottom/Start (perpendicular): 0.04 m; Cross Section Height at Top/End (cut): 0.04 m; Cross Section Height at Bottom/Start (cut): 0.04 m; Cross Section Width at Top/End (cut): 0.04 m; Cross Section Width at Bottom/Start (cut): 0.04 m; Cross Section Area at Bottom/Start: 0.0012 m2; Cross Section Area at Top/End: 0.0012 m2; Number of Segments: 1; Top Surface Area (Net): 0 m2; Bottom Surface Area (Net): 0 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.04 m; 503.AMB.Altura: 0.04 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete - Structural, Component Thickness: 0.04 m; Concrete - Structural, Component Cross Section Area: 0.00125664 m2
Name | Concrete - Structural, Embodied Carbon | Concrete - Structural, Embodied Energy (MJ) | Surface Area of the Beam Left Side (Net) (m2) = Surface Area of the Beam Right Side (Net) (m2) | Length Left (m) = Length Right (m) | Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Concrete - Structural, Component Volume (Net) (m3) = Concrete - Structural, Component Volume (Gross) (m3) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Concrete - Structural, Mass (kg) | Concrete - Structural, Projected Component Area (Net) (m2) = Concrete - Structural, Projected Component Area (Gross) (m2)
BMR - 005 | 4.02252 (kgCO₂) | 39.0063 | 0.481719 | 8.77847 | 0.301017 | 0.00883294 | 1.11667 | 8.33542 | 0.0105342 | 20.3158 | 0.319895
BMR - 005 | 1.6432 (kgCO₂) | 15.9341 | 0.196472 | 3.39267 | 0.122882 | 0.00360825 | 0.45315 | 3.39267 | 0.00407121 | 8.29899 | 0.130355 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia

# IfcBuildingElementProxy: REJILLA RANURADA DOBLE ULMA 167 x 227, BMR - 008
In: planta baixa
Classification: 50.20.20.10 Canalitzacions d'aigües pluvials (GuBIMclass CA)
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: 0 deg; Element ID: BMR - 008; Hotlink and Element ID: BMR - 008; Layer: 00_CANAL PLUVIALS; Building Material / Composite / Profile / Fill: REJILLA RANURADA DOBLE ULMA; Complex Profile: REJILLA RANURADA DOBLE ULMA; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Complex Profile; Profile Category: REJILLA RANURADA DOBLE ULMA; Parent ID: BMR - 008; Building Materials (All): Membrane - Vapor Barrier; Steel - Stainless; Steel - Stainless; Concrete; Steel - Stainless; Surfaces (All): Paint - Anthracite; Metal - Stainless Steel; Glass - Blue; Concrete - Bush hammered; Cover Fill: Background; Slant Angle: 0 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 50.20.20.10 Canalitzacions d'aigües pluvials; 104.AMB.ClassificacioCodi: 50.20.20.10; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües pluvials; 107.AMB.NomTipus: BMR - 008_; 109.AMB.CodiTipus: BMR - 008; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
Pset_BuildingElementProxyCommon - Status: NEW
5 AMB.Geometria - 502.AMB.Amplada: 0.167 m; 503.AMB.Altura: 0.227235 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0162475 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 26.1686 m2; Length Left: 57.1421 m; Length Right: 57.1421 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 26.1683 m2; Area: 9.54262 m2; Height: 0.227235 m; Volume (Net): 0.584127 m3; Width: 0.167 m; Elevation to Project Zero: 0.209234 m; Elevation to 1st Reference Level: 0.209234 m; Elevation to 2nd Reference Level: 0.209234 m; Elevation to Sea Level: 9.54923 m; Elevation to Linked/Home Story: 0.209234 m; Home Offset: 0.209234 m; Surface Area: 121.299 m2; 3D Length: 57.1421 m; Volume (Conditional): 0.584127 m3; Volume (Gross): 0.584134 m3; Top Elevation To First Reference Level: 0.209234 m; Top Elevation To Home Story: 0.209234 m; Top Elevation To Project Zero: 0.209234 m; Top Elevation To Sea Level: 9.54923 m; Top Elevation To Second Reference Level: 0.209234 m; Bottom Elevation To First Reference Level: -0.0180012 m; Bottom Elevation To Home Story: -0.0180012 m; Bottom Elevation To Project Zero: -0.0180012 m; Bottom Elevation To Sea Level: 9.322 m; Bottom Elevation To Second Reference Level: -0.0180012 m; Cross Section Height at Top/End (perpendicular): 0.227235 m; Cross Section Height at Bottom/Start (perpendicular): 0.227235 m; Cross Section Width at Top/End (perpendicular): 0.167 m; Cross Section Width at Bottom/Start (perpendicular): 0.167 m; Cross Section Height at Top/End (cut): 0.227235 m; Cross Section Height at Bottom/Start (cut): 0.227235 m; Cross Section Width at Top/End (cut): 0.167 m; Cross Section Width at Bottom/Start (cut): 0.167 m; Cross Section Area at Bottom/Start: 0.0102225 m2; Cross Section Area at Top/End: 0.00602504 m2; Number of Segments: 1; Top Surface Area (Net): 16.3345 m2; Bottom Surface Area (Net): 13.328 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 50

# IfcBuildingElementProxy: Rhino_Object_1914, Object_1914
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.8522 deg; Surface: Paint - Anthracite; Element ID: Object_1914; Hotlink and Element ID: Object_1914; Layer: 00_PERIMETRO; Library Part Name: Rhino_Object_1914; Building Material / Composite / Profile / Fill: Common Brick; Fill Type: Common Brick; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1914; Surfaces (All): Paint - Anthracite; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1914 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 2; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 004; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 5; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
