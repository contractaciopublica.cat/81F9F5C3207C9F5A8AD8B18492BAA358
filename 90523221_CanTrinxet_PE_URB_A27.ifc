Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcBuildingElementProxy: Rhino_Object_1914, Object_1914
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1914_; 109.AMB.CodiTipus: Object_1914; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 40.3196 m; Area: 22.1758 m2; Height: 9.39903 m; Volume (Net): 114.287 m3; Width: 0.55 m; Elevation to Project Zero: 1.03439 m; Elevation to 1st Reference Level: 1.03439 m; Elevation to 2nd Reference Level: 1.03439 m; Elevation to Sea Level: 10.3744 m; Elevation to Linked/Home Story: 1.03439 m; Home Offset: 1.03439 m; Surface Area: 479.154 m2; Top Elevation To First Reference Level: 10.4334 m; Top Elevation To Home Story: 10.4334 m; Top Elevation To Project Zero: 10.4334 m; Top Elevation To Sea Level: 19.7734 m; Top Elevation To Second Reference Level: 10.4334 m; Bottom Elevation To First Reference Level: 1.03439 m; Bottom Elevation To Home Story: 1.03439 m; Bottom Elevation To Project Zero: 1.03439 m; Bottom Elevation To Sea Level: 10.3744 m; Bottom Elevation To Second Reference Level: 1.03439 m; Survey Coordinate X: 426575 m; Survey Coordinate Y: 4579814 m; Survey Coordinate Z: 10.3744 m; Top Surface Area (Net): 22.1758 m2; Bottom Surface Area (Net): 479.154 m2
AC_Equantity_Rhino_Object_1914 - Dimension 1: 40.3196 m; Dimension 2: 0.55 m; Height: 9.39903 m; Bottom Level: 0 m; Top Level: 9.39903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.55 m; 503.AMB.Altura: 9.39903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 114.287 m3; Component, Component Volume (Gross): 114.287 m3

# IfcBuildingElementProxy: Sand 23760 x 642, BMR - 004
In: planta baixa
Classification: 70.50 Jardineria (GuBIMclass CA); Material: Sand
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Earth - Brown; Left Side Surface: Earth - Brown; Right Side Surface: Earth - Brown; Beam Slant Angle: 3.2904 deg; Element ID: BMR - 004; Hotlink and Element ID: BMR - 004; Layer: 00_JARDINERA; Building Material / Composite / Profile / Fill: Sand; Building Material: Sand; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Parent ID: BMR - 004; Building Materials (All): Sand; Surfaces (All): Earth - Brown; Grass - Brown; Cover Fill: CROSS; Slant Angle: 3.2904 deg; Number of Openings: 0; Top Surface: Grass - Brown; Bottom Surface: Earth - Brown; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 70.50 Jardineria; 104.AMB.ClassificacioCodi: 70.50; 105.AMB.ClassificacioDescripcio: Jardineria; 107.AMB.NomTipus: BMR - 004_; 109.AMB.CodiTipus: BMR - 004; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Sand, Embodied Carbon: 627.994 (kgCO₂); Sand, Embodied Energy: 10173.5 MJ; Sand, Component Type: Core
ArchiCADQuantities - Surface Area of Both Beam Ends: 6.61885 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Surface Area of the Beam Left Side (Net): 2.40279 m2; Length Left: 5.21063 m; Length Right: 5.21063 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 2.40279 m2; Area: 123.558 m2; Height: 0.642 m; Volume (Net): 57.0903 m3; Width: 23.76 m; Elevation to Project Zero: 0.698634 m; Elevation to 1st Reference Level: 0.698634 m; Elevation to 2nd Reference Level: 0.698634 m; Elevation to Sea Level: 10.0386 m; Elevation to Linked/Home Story: 0.698634 m; Home Offset: 0.698634 m; Surface Area: 275.091 m2; 3D Length: 5.24589 m; Volume (Conditional): 57.0903 m3; Volume (Gross): 57.1177 m3; Top Elevation To First Reference Level: 1.64314 m; Top Elevation To Home Story: 1.64314 m; Top Elevation To Project Zero: 1.64314 m; Top Elevation To Sea Level: 10.9831 m; Top Elevation To Second Reference Level: 1.64314 m; Bottom Elevation To First Reference Level: 0.698634 m; Bottom Elevation To Home Story: 0.698634 m; Bottom Elevation To Project Zero: 0.698634 m; Bottom Elevation To Sea Level: 10.0386 m; Bottom Elevation To Second Reference Level: 0.698634 m; Cross Section Height at Top/End (perpendicular): 0.642 m; Cross Section Height at Bottom/Start (perpendicular): 0.276992 m; Cross Section Width at Top/End (perpendicular): 23.76 m; Cross Section Width at Bottom/Start (perpendicular): 23.76 m; Cross Section Height at Top/End (cut): 0.64306 m; Cross Section Height at Bottom/Start (cut): 0.277449 m; Cross Section Width at Top/End (cut): 23.76 m; Cross Section Width at Bottom/Start (cut): 23.76 m; Cross Section Area at Bottom/Start: 6.61885 m2; Cross Section Area at Top/End: 0 m2; Number of Segments: 1; Top Surface Area (Net): 124.567 m2; Bottom Surface Area (Net): 123.762 m2
5 AMB.Geometria - 502.AMB.Amplada: 23.76 m; 503.AMB.Altura: 0.642 m; 506.AMB.Profunditat: 0 m
Component Quantities - Sand, Mass: 125599 kg; Sand, Component Volume (Net): 57.0903 m3; Sand, Component Volume (Gross): 57.0903 m3

# IfcBuildingElementProxy: Sand 50 (6)
In: planta coberta
Classification: 70.50 Jardineria (GuBIMclass CA); Material: Sand
ArchiCADProperties - Geometry Method: Single-plane; Roof Level: 1; Trimming Body: Contours Down; Element ID: RT - 002; Hotlink and Element ID: RT - 002; Layer: 00_JARDINERA; Building Material / Composite / Profile / Fill: Sand; Building Material: Sand; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Roof; Structure Type: Basic; Parent ID: RT - 002; Building Materials (All): Sand; Surfaces (All): Earth - Brown; Grass - Brown; Cover Fill: CROSS; Edge Surface: Earth - Brown; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 70.50 Jardineria; 104.AMB.ClassificacioCodi: 70.50; 105.AMB.ClassificacioDescripcio: Jardineria; 107.AMB.NomTipus: RT - 002_; 109.AMB.CodiTipus: RT - 002; 115.AMB.Nivell: planta coberta; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Vertical Thickness: 0.05 m
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
Name | Pitch (deg) | Colliding Zones | Sand, Embodied Carbon | Sand, Embodied Energy (MJ) | Surface Area of the Roof Bottom (Gross) (m2) = Surface Area of the Roof Top (Gross) (m2) = Surface Area of the Roof Bottom (Net) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Thickness (m) = Height (m) = 503.AMB.Altura (m) = 504.AMB.Gruix (m) = Sand, Component Thickness (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Sand, Mass (kg) | Sand, Projected Component Area (Net) (m2) = Sand, Projected Component Area (Gross) (m2) | Sand, Component Volume (Net) (m3) = Sand, Component Volume (Gross) (m3)
RT - 002 | -3.33 | Espai públic | 21.0626 (kgCO₂) | 341.213 | 38.3603 | 1.67304 | 0.0499156 | 0.141346 | 9.48135 | -4.35865 | 0.375206 | -4.12479 | 9.71521 | 0.143208 | -4.35679 | 9.48321 | 4212.51 | 38.4014 | 1.91478
RT - 002 | -3.33 | Espai públic | 6.77789 (kgCO₂) | 109.802 | 12.3443 | 0.761641 | 0.0499156 | 0.141346 | 9.48135 | -4.35865 | 0.337284 | -4.16272 | 9.67728 | 0.143208 | -4.35679 | 9.48321 | 1355.58 | 12.3599 | 0.616172
RT - 002 | -3.33 | Espai públic | 22.6527 (kgCO₂) | 366.974 | 41.2565 | 1.68068 | 0.0499156 | 0.141346 | 9.48135 | -4.35865 | 0.389007 | -4.11099 | 9.72901 | 0.143208 | -4.35679 | 9.48321 | 4530.55 | 41.2971 | 2.05934
RT - 002 | -3.33 | Espai públic; Nau Annexa | 7.14464 (kgCO₂) | 115.743 | 13.0122 | 0.915936 | 0.0499156 | 0.141346 | 9.48135 | -4.35865 | 1.17958 | -3.32042 | 10.5196 | 0.849349 | -3.65065 | 10.1893 | 1428.93 | 13.026 | 0.649513
RT - 002 | 4.36765 | Espai públic | 8.79664 (kgCO₂) | 142.506 | 16.0405 | 0.911956 | 0.0498548 | 0.259624 | 9.59962 | -4.24038 | 0.491211 | -4.00879 | 9.83121 | 0.259624 | -4.24038 | 9.59962 | 1759.33 | 16.0662 | 0.799694
RT - 002 | -3.33 | Espai públic; Nau Annexa | 8.30248 (kgCO₂) | 134.5 | 15.1209 | 1.58188 | 0.0499156 | 0.141346 | 9.48135 | -4.35865 | 0.812738 | -3.68726 | 10.1527 | 0.143208 | -4.35679 | 9.48321 | 1660.5 | 15.1374 | 0.754771

# IfcBuildingElementProxy: Sand 66, RT - 002
In: planta coberta
Classification: 70.50 Jardineria (GuBIMclass CA); Material: Sand
ArchiCADProperties - Geometry Method: Single-plane; Pitch: -3.33 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: RT - 002; Hotlink and Element ID: RT - 002; Layer: 00_JARDINERA; Building Material / Composite / Profile / Fill: Sand; Building Material: Sand; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Roof; Structure Type: Basic; Parent ID: RT - 002; Building Materials (All): Sand; Surfaces (All): Earth - Brown; Grass - Brown; Cover Fill: CROSS; Edge Surface: Earth - Brown; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 70.50 Jardineria; 104.AMB.ClassificacioCodi: 70.50; 105.AMB.ClassificacioDescripcio: Jardineria; 107.AMB.NomTipus: RT - 002_; 109.AMB.CodiTipus: RT - 002; 115.AMB.Nivell: planta coberta; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Surface Area of the Roof Bottom (Gross): 31.6173 m2; Surface Area of the Roof Edges (Gross): 1.65471 m2; Surface Area of the Roof Top (Gross): 31.6173 m2; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Surface Area of the Roof Bottom (Net): 31.6173 m2; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.0659383 m; Vertical Thickness: 0.0660498 m; Height: 0.0659383 m; Elevation to Project Zero: 0.141346 m; Elevation to 1st Reference Level: 0.141346 m; Elevation to 2nd Reference Level: 0.141346 m; Elevation to Sea Level: 9.48135 m; Elevation to Linked/Home Story: -4.35865 m; Home Offset: -4.35865 m; Top Elevation To First Reference Level: 0.427313 m; Top Elevation To Home Story: -4.07269 m; Top Elevation To Project Zero: 0.427313 m; Top Elevation To Sea Level: 9.76731 m; Top Elevation To Second Reference Level: 0.427313 m; Bottom Elevation To First Reference Level: 0.143208 m; Bottom Elevation To Home Story: -4.35679 m; Bottom Elevation To Project Zero: 0.143208 m; Bottom Elevation To Sea Level: 9.48321 m; Bottom Elevation To Second Reference Level: 0.143208 m
Component Properties - Sand, Embodied Carbon: 22.9327 (kgCO₂); Sand, Embodied Energy: 371.509 MJ
Component Quantities - Sand, Mass: 4586.54 kg; Sand, Projected Component Area (Net): 31.6526 m2; Sand, Projected Component Area (Gross): 31.6526 m2; Sand, Component Thickness: 0.0659383 m; Sand, Component Volume (Net): 2.08479 m3; Sand, Component Volume (Gross): 2.08479 m3
5 AMB.Geometria - 503.AMB.Altura: 0.0659383 m; 504.AMB.Gruix: 0.0659383 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Sand 67, RT - 002
In: planta coberta
Classification: 70.50 Jardineria (GuBIMclass CA); Material: Sand
ArchiCADProperties - Geometry Method: Single-plane; Pitch: 1.42772 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: RT - 002; Hotlink and Element ID: RT - 002; Layer: 00_JARDINERA; Building Material / Composite / Profile / Fill: Sand; Building Material: Sand; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Roof; Structure Type: Basic; Parent ID: RT - 002; Building Materials (All): Sand; Surfaces (All): Earth - Brown; Grass - Brown; Cover Fill: CROSS; Edge Surface: Earth - Brown; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 70.50 Jardineria; 104.AMB.ClassificacioCodi: 70.50; 105.AMB.ClassificacioDescripcio: Jardineria; 107.AMB.NomTipus: RT - 002_; 109.AMB.CodiTipus: RT - 002; 115.AMB.Nivell: planta coberta; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
Component Properties - Sand, Embodied Carbon: 4.55205 (kgCO₂); Sand, Embodied Energy: 73.7432 MJ
Pset_BuildingElementProxyCommon - Status: NEW
5 AMB.Geometria - 503.AMB.Altura: 0.0669792 m; 504.AMB.Gruix: 0.0669792 m; 506.AMB.Profunditat: 0 m
Component Quantities - Sand, Mass: 910.41 kg; Sand, Projected Component Area (Net): 6.17962 m2; Sand, Projected Component Area (Gross): 6.17962 m2; Sand, Component Thickness: 0.0669792 m; Sand, Component Volume (Net): 0.413823 m3; Sand, Component Volume (Gross): 0.413823 m3
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Surface Area of the Roof Bottom (Gross): 6.17836 m2; Surface Area of the Roof Edges (Gross): 1.21751 m2; Surface Area of the Roof Top (Gross): 6.1784 m2; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Surface Area of the Roof Bottom (Net): 6.17836 m2; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.0669792 m; Vertical Thickness: 0.067 m; Height: 0.0669792 m; Elevation to Project Zero: 0.142234 m; Elevation to 1st Reference Level: 0.142234 m; Elevation to 2nd Reference Level: 0.142234 m; Elevation to Sea Level: 9.48223 m; Elevation to Linked/Home Story: -4.35777 m; Home Offset: -4.35777 m; Top Elevation To First Reference Level: 0.209209 m; Top Elevation To Home Story: -4.29079 m; Top Elevation To Project Zero: 0.209209 m; Top Elevation To Sea Level: 9.54921 m; Top Elevation To Second Reference Level: 0.209209 m; Bottom Elevation To First Reference Level: -0.065387 m; Bottom Elevation To Home Story: -4.56539 m; Bottom Elevation To Project Zero: -0.065387 m; Bottom Elevation To Sea Level: 9.27461 m; Bottom Elevation To Second Reference Level: -0.065387 m

# IfcBuildingElementProxy: Stone - Structural 202, SLA - 007
In: planta baixa
Classification: 70.30.20 Paviments peatonals (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Reference Plane Location: Top; Element ID: SLA - 007; Hotlink and Element ID: SLA - 007; Layer: 00_ADOQUIN; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Basic; Parent ID: SLA - 007; Building Materials (All): Stone - Structural; Surfaces (All): Color RGB 221-221-221; Cover Fill: Carpet; Number of Openings: 0; Top Surface: Color RGB 221-221-221; Edge Surface: Color RGB 221-221-221; Bottom Surface: Color RGB 221-221-221; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 70.30.20 Paviments peatonals; 104.AMB.ClassificacioCodi: 70.30.20; 105.AMB.ClassificacioDescripcio: Paviments peatonals; 107.AMB.NomTipus: SLA - 007_; 109.AMB.CodiTipus: SLA - 007; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Stone - Structural, Embodied Carbon: 38.5387 (kgCO₂); Stone - Structural, Embodied Energy: 642.311 MJ
ArchiCADQuantities - Elevation Bottom: 1.13826 m; Surface Area of the Slab Top (Conditional): 0.964788 m2; Surface Area of the Slab Bottom (Gross): 0.964788 m2; Surface Area of the Slab Bottom (Gross, with holes): 0.964788 m2; Surface Area of the Slab Edges (Gross): 1.2398 m2; Surface Area of the Slab Edges (Gross, with holes): 1.2398 m2; Surface Area of the Slab Top (Gross): 0.964788 m2; Surface Area of the Slab Top (Gross, with holes): 0.964788 m2; Holes Surface Area: 0 m2; Elevation Top: 1.34 m; Area: 0.964788 m2; Height: 0.201744 m; Volume (Net): 0.19464 m3; Elevation to Project Zero: 1.34 m; Elevation to 1st Reference Level: 1.34 m; Elevation to 2nd Reference Level: 1.34 m; Elevation to Sea Level: 10.68 m; Elevation to Linked/Home Story: 1.34 m; Home Offset: 1.34 m; Surface Area: 0.964788 m2; Thickness: 0.201744 m; Volume (Conditional): 0.19464 m3; Volume (Gross): 0.19464 m3; Floor Plan Perimeter: 6.14542 m; Floor Plan Holes Perimeter: 0 m; Top Elevation To First Reference Level: 1.34 m; Top Elevation To Home Story: 1.34 m; Top Elevation To Project Zero: 1.34 m; Top Elevation To Sea Level: 10.68 m; Top Elevation To Second Reference Level: 1.34 m; Bottom Elevation To First Reference Level: 1.13826 m; Bottom Elevation To Home Story: 1.13826 m; Bottom Elevation To Project Zero: 1.13826 m; Bottom Elevation To Sea Level: 10.4783 m; Bottom Elevation To Second Reference Level: 1.13826 m; Top Surface Area (Net): 0.964788 m2; Top Surface Area (Conditional): 0.964788 m2; Edge Surface Area (Net): 1.2398 m2; Bottom Surface Area (Net): 0.964788 m2; Bottom Surface Area (Conditional): 0.964788 m2; Bottom Surface Area (Gross): 0.964788 m2; Edge Surface Area (Gross): 1.2398 m2; Top Surface Area (Gross): 0.964788 m2
Component Quantities - Stone - Structural, Mass: 428.207 kg; Stone - Structural, Projected Component Area (Net): 0.964788 m2; Stone - Structural, Projected Component Area (Gross): 0.964788 m2; Stone - Structural, Component Thickness: 0.201744 m; Stone - Structural, Component Volume (Net): 0.19464 m3; Stone - Structural, Component Volume (Gross): 0.19464 m3
5 AMB.Geometria - 503.AMB.Altura: 0.201744 m; 504.AMB.Gruix: 0.201744 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Stone - Structural 270 (3)
In: planta baixa
Classification: 70.30.20 Paviments peatonals (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Reference Plane Location: Top; Element ID: SLA - 007; Hotlink and Element ID: SLA - 007; Layer: 00_ADOQUIN; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Basic; Parent ID: SLA - 007; Building Materials (All): Stone - Structural; Surfaces (All): Color RGB 221-221-221; Cover Fill: Carpet; Number of Openings: 0; Top Surface: Color RGB 221-221-221; Edge Surface: Color RGB 221-221-221; Bottom Surface: Color RGB 221-221-221; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 70.30.20 Paviments peatonals; 104.AMB.ClassificacioCodi: 70.30.20; 105.AMB.ClassificacioDescripcio: Paviments peatonals; 107.AMB.NomTipus: SLA - 007_; 109.AMB.CodiTipus: SLA - 007; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Holes Surface Area: 0 m2; Height: 0.27 m; Thickness: 0.27 m; Floor Plan Holes Perimeter: 0 m
Component Quantities - Stone - Structural, Component Thickness: 0.27 m
5 AMB.Geometria - 503.AMB.Altura: 0.27 m; 504.AMB.Gruix: 0.27 m; 506.AMB.Profunditat: 0 m
Name | Stone - Structural, Embodied Carbon | Stone - Structural, Embodied Energy (MJ) | Elevation Bottom (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Surface Area of the Slab Top (Conditional) (m2) = Surface Area of the Slab Bottom (Gross) (m2) = Surface Area of the Slab Bottom (Gross, with holes) (m2) = Surface Area of the Slab Top (Gross) (m2) = Surface Area of the Slab Top (Gross, with holes) (m2) = Area (m2) = Surface Area (m2) = Top Surface Area (Net) (m2) = Top Surface Area (Conditional) (m2) = Bottom Surface Area (Net) (m2) = Bottom Surface Area (Conditional) (m2) = Bottom Surface Area (Gross) (m2) = Top Surface Area (Gross) (m2) = Stone - Structural, Projected Component Area (Net) (m2) = Stone - Structural, Projected Component Area (Gross) (m2) | Surface Area of the Slab Edges (Gross) (m2) = Surface Area of the Slab Edges (Gross, with holes) (m2) = Edge Surface Area (Net) (m2) = Edge Surface Area (Gross) (m2) | Elevation Top (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Volume (Net) (m3) = Volume (Conditional) (m3) = Volume (Gross) (m3) = Stone - Structural, Component Volume (Net) (m3) = Stone - Structural, Component Volume (Gross) (m3) | Elevation to Sea Level (m) = Top Elevation To Sea Level (m) | Floor Plan Perimeter (m) | Bottom Elevation To Sea Level (m) | Stone - Structural, Mass (kg)
SLA - 007 | 50.8511 (kgCO₂) | 847.518 | 1.34 | 0.951199 | 1.65656 | 1.61 | 0.256824 | 10.95 | 6.13542 | 10.68 | 565.012
SLA - 007 | 50.8477 (kgCO₂) | 847.462 | 1.475 | 0.951135 | 1.65723 | 1.745 | 0.256807 | 11.085 | 6.13791 | 10.815 | 564.974
SLA - 007 | 50.8511 (kgCO₂) | 847.518 | 1.205 | 0.951199 | 1.65656 | 1.475 | 0.256824 | 10.815 | 6.13542 | 10.545 | 565.012

# IfcBuildingElementProxy: Stone - Structural 300 (2)
In: planta baixa
Classification: Wall (ARCHICAD Classification); Material: Stone - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Paint - Anthracite; Outside Face Surface: Paint - Anthracite; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: SW - 052; Hotlink and Element ID: SW - 052; Layer: 00_PERIMETRO; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: SW - 052; Building Materials (All): Stone - Structural; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Paint - Anthracite; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 107.AMB.NomTipus: SW - 052_; 109.AMB.CodiTipus: SW - 052; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall: 0.280588 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.3 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.3 m; Elevation to Project Zero: 0.247168 m; Elevation to 1st Reference Level: 0.247168 m; Elevation to 2nd Reference Level: 0.247168 m; Elevation to Sea Level: 9.58717 m; Elevation to Linked/Home Story: 0.247168 m; Home Offset: 0.247168 m; Top Offset: 0 m; Thickness: 0.3 m; Insulation Skin Thickness: 0 m; Bottom Elevation To First Reference Level: 0.247168 m; Bottom Elevation To Home Story: 0.247168 m; Bottom Elevation To Project Zero: 0.247168 m; Bottom Elevation To Sea Level: 9.58717 m; Bottom Elevation To Second Reference Level: 0.247168 m
5 AMB.Geometria - 502.AMB.Amplada: 0.3 m; 504.AMB.Gruix: 0.3 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Component Thickness: 0.3 m; Stone - Structural, Rectangular Component Width: 0.3 m
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Name | Surfaces (All) | Stone - Structural, Embodied Carbon | Stone - Structural, Embodied Energy (MJ) | Number of Columns | Maximum Height of the Wall (m) = Height (m) = 503.AMB.Altura (m) = Stone - Structural, Rectangular Component Height (m) | Average length of the Wall (m) = Length of Reference Line (m) = Length of the Wall Inside Face (Conditional) (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall at the Center (m) = Length of the Wall on the Inside Face (m) = Length of the Wall on the Outside Face (m) = 3D Length (m) = 501.AMB.Longitud (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area of the Wall Inside Face (Gross) (m2) = Surface Area of the Wall Outside Face (Gross) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) = Stone - Structural, Projected Component Area (Net) (m2) = Stone - Structural, Projected Component Area (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Stone - Structural, Component Volume (Net) (m3) = Stone - Structural, Component Volume (Gross) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Stone - Structural, Mass (kg) | Stone - Structural, Component Cross Section Area (m2)
SW - 052 | Paint - Anthracite; Stone - Wall | 234.896 (kgCO₂) | 3914.93 | 49 | 0.430588 | 9.22153 | 3.97067 | 2.76646 | 1.18634 | 1.1912 | 19.0431 | 0.677755 | 10.0178 | 5.75887 | 2609.95 | 0.129176
SW - 052 | Paint - Anthracite | 63.9296 (kgCO₂) | 1065.49 | 1 | 0.280588 | 3.83573 | 1.07626 | 1.15072 | 0.322877 | 0.322877 | 8.27145 | 0.527755 | 9.86776 | 2.46979 | 710.329 | 0.0841763 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia

# IfcBuildingElementProxy: Stone - Structural 300 x 222 (6)
In: planta baixa
Classification: Column (ARCHICAD Classification); Material: Stone - Structural
ArchiCADProperties - Column Cross Section: Rectangular; Column Slant Angle: 90 deg; Extrusion Surface: Paint - Anthracite; End Surface: Paint - Anthracite; Element ID: CRE - 005; Hotlink and Element ID: CRE - 005; Layer: 00_PERIMETRO; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Column; Absolute Top Link Story: planta coberta; Relative Top Link Story: Home + 1; Top Link Story: Home + 1 (planta coberta); Structure Type: Basic; Parent ID: CRE - 005; Building Materials (All): Stone - Structural; Surfaces (All): Paint - Anthracite; Cover Fill: Background; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 107.AMB.NomTipus: CRE - 005_; 109.AMB.CodiTipus: CRE - 005; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Stone - Structural, Component Type: Core
ArchiCADQuantities - Core Height / Diameter: 0.221526 m; Core Width: 0.3 m; Surface Area of the Column Core Top (Gross): 0.0664579 m2; Surface Area of the Column Core Bottom (Gross): 0.0664579 m2; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Surface Area of the Column Core Bottom (Net): 0.0664579 m2; Surface Area of the Column Core Top (Net): 0.0664579 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.04305 m; Volume of the Column Veneer (Net): 0 m3; Area: 0.0664579 m2; Width: 0.3 m; Top Offset: -2.1217 m; Top Elevation To First Reference Level: 2.3783 m; Top Elevation To Home Story: 2.3783 m; Top Elevation To Project Zero: 2.3783 m; Top Elevation To Sea Level: 11.7183 m; Top Elevation To Second Reference Level: 2.3783 m; Cross Section Height at Top/End (perpendicular): 0.221526 m; Cross Section Height at Bottom/Start (perpendicular): 0.221526 m; Cross Section Width at Top/End (perpendicular): 0.3 m; Cross Section Width at Bottom/Start (perpendicular): 0.3 m; Cross Section Height at Top/End (cut): 0.221526 m; Cross Section Height at Bottom/Start (cut): 0.221526 m; Cross Section Width at Top/End (cut): 0.3 m; Cross Section Width at Bottom/Start (cut): 0.3 m; Cross Section Area at Bottom/Start: 0.0664579 m2; Cross Section Area at Top/End: 0.0664579 m2; Number of Segments: 1; Top Surface Area (Net): 0.0664579 m2; Top Surface Area (Gross): 0.0664579 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.3 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Component Thickness: 0.3 m; Stone - Structural, Rectangular Component Height: 0.221526 m; Stone - Structural, Rectangular Component Width: 0.3 m; Stone - Structural, Component Cross Section Area: 0.0664579 m2
Name | Stone - Structural, Embodied Carbon | Stone - Structural, Embodied Energy (MJ) | Volume of the Column Core (Net) (m3) = Volume of the Column Core (Gross) (m3) = Volume (Net) (m3) = Volume (Gross) (m3) = Stone - Structural, Component Volume (Net) (m3) = Stone - Structural, Component Volume (Gross) (m3) | Surface Area of the Column Core (Gross, without Top/Bottom) (m2) = Surface Area of the Column Core (Net, without Top/Bottom) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Maximum Height of the Column (m) = Minimum Height of the Column (m) = Height (m) = 3D Length (m) = 503.AMB.Altura (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Stone - Structural, Mass (kg)
CRE - 005 | 24.3507 (kgCO₂) | 405.845 | 0.122983 | 1.93022 | 1.85055 | 0.527755 | 9.86776 | 270.563
CRE - 005 | 24.3507 (kgCO₂) | 405.845 | 0.122983 | 1.93022 | 1.85055 | 0.527755 | 9.86776 | 270.563 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
4 x CRE - 005 | 22.3769 (kgCO₂) | 372.948 | 0.113015 | 1.77376 | 1.70055 | 0.677755 | 10.0178 | 248.632

# IfcBuildingElementProxy: Stone - Structural 40 x 80 (4)
In: planta baixa
Classification: Column (ARCHICAD Classification); Material: Stone - Structural
ArchiCADProperties - Column Cross Section: Rectangular; Column Slant Angle: 90 deg; Extrusion Surface: Paint - Anthracite; End Surface: Paint - Anthracite; Element ID: CRE - 005; Hotlink and Element ID: CRE - 005; Layer: 00_PERIMETRO; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Column; Absolute Top Link Story: planta coberta; Relative Top Link Story: Home + 1; Top Link Story: Home + 1 (planta coberta); Structure Type: Basic; Parent ID: CRE - 005; Building Materials (All): Stone - Structural; Surfaces (All): Paint - Anthracite; Cover Fill: Background; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 107.AMB.NomTipus: CRE - 005_; 109.AMB.CodiTipus: CRE - 005; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Stone - Structural, Embodied Carbon: 1.14048 (kgCO₂); Stone - Structural, Embodied Energy: 19.008 MJ; Stone - Structural, Component Type: Core
5 AMB.Geometria - 502.AMB.Amplada: 0.04 m; 503.AMB.Altura: 1.8 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Core Height / Diameter: 0.08 m; Volume of the Column Core (Net): 0.00576 m3; Core Width: 0.04 m; Surface Area of the Column Core (Gross, without Top/Bottom): 0.432 m2; Surface Area of the Column Core Top (Gross): 0.0032 m2; Surface Area of the Column Core Bottom (Gross): 0.0032 m2; Volume of the Column Core (Gross): 0.00576 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 1.8 m; Minimum Height of the Column: 1.8 m; Surface Area of the Column Core Bottom (Net): 0.0032 m2; Surface Area of the Column Core (Net, without Top/Bottom): 0.432 m2; Surface Area of the Column Core Top (Net): 0.0032 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 0.24 m; Volume of the Column Veneer (Net): 0 m3; Area: 0.0032 m2; Height: 1.8 m; Volume (Net): 0.00576 m3; Width: 0.04 m; Elevation to Project Zero: 0.478301 m; Elevation to 1st Reference Level: 0.478301 m; Elevation to 2nd Reference Level: 0.478301 m; Elevation to Sea Level: 9.8183 m; Elevation to Linked/Home Story: 0.478301 m; Home Offset: 0.478301 m; Top Offset: -2.2217 m; Surface Area: 0.432 m2; 3D Length: 1.8 m; Volume (Gross): 0.00576 m3; Top Elevation To First Reference Level: 2.2783 m; Top Elevation To Home Story: 2.2783 m; Top Elevation To Project Zero: 2.2783 m; Top Elevation To Sea Level: 11.6183 m; Top Elevation To Second Reference Level: 2.2783 m; Bottom Elevation To First Reference Level: 0.478301 m; Bottom Elevation To Home Story: 0.478301 m; Bottom Elevation To Project Zero: 0.478301 m; Bottom Elevation To Sea Level: 9.8183 m; Bottom Elevation To Second Reference Level: 0.478301 m; Cross Section Height at Top/End (perpendicular): 0.08 m; Cross Section Height at Bottom/Start (perpendicular): 0.08 m; Cross Section Width at Top/End (perpendicular): 0.04 m; Cross Section Width at Bottom/Start (perpendicular): 0.04 m; Cross Section Height at Top/End (cut): 0.08 m; Cross Section Height at Bottom/Start (cut): 0.08 m; Cross Section Width at Top/End (cut): 0.04 m; Cross Section Width at Bottom/Start (cut): 0.04 m; Cross Section Area at Bottom/Start: 0.0032 m2; Cross Section Area at Top/End: 0.0032 m2; Number of Segments: 1; Top Surface Area (Net): 0.0032 m2; Bottom Surface Area (Net): 0.432 m2; Top Surface Area (Gross): 0.0032 m2
Component Quantities - Stone - Structural, Mass: 12.672 kg; Stone - Structural, Component Thickness: 0.04 m; Stone - Structural, Rectangular Component Height: 0.08 m; Stone - Structural, Rectangular Component Width: 0.04 m; Stone - Structural, Component Cross Section Area: 0.0032 m2; Stone - Structural, Component Volume (Net): 0.00576 m3; Stone - Structural, Component Volume (Gross): 0.00576 m3

# IfcBuildingElementProxy: Stone - Structural 400 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: SW - 052; Hotlink and Element ID: SW - 052; Layer: 00_PERIMETRO; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: SW - 052; Building Materials (All): Stone - Structural; Slant Angle: 90 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SW - 052_; 109.AMB.CodiTipus: SW - 052; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 5.5898 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; End Thickness of the Wall: 0.4 m; Surface Area of Empty Openings in the Wall: 0 m2; Height: 5.5898 m; Width: 0.4 m; Elevation to Project Zero: -0.150135 m; Elevation to 1st Reference Level: -0.150135 m; Elevation to 2nd Reference Level: -0.150135 m; Elevation to Sea Level: 9.18987 m; Elevation to Linked/Home Story: -0.150135 m; Home Offset: -0.150135 m; Top Offset: 0 m; Thickness: 0.4 m; Insulation Skin Thickness: 0 m; Top Elevation To First Reference Level: 5.43966 m; Top Elevation To Home Story: 5.43966 m; Top Elevation To Project Zero: 5.43966 m; Top Elevation To Sea Level: 14.7797 m; Top Elevation To Second Reference Level: 5.43966 m; Bottom Elevation To First Reference Level: -0.150135 m; Bottom Elevation To Home Story: -0.150135 m; Bottom Elevation To Project Zero: -0.150135 m; Bottom Elevation To Sea Level: 9.18987 m; Bottom Elevation To Second Reference Level: -0.150135 m
5 AMB.Geometria - 502.AMB.Amplada: 0.4 m; 503.AMB.Altura: 5.5898 m; 504.AMB.Gruix: 0.4 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Component Thickness: 0.4 m; Stone - Structural, Rectangular Component Height: 5.5898 m; Stone - Structural, Rectangular Component Width: 0.4 m; Stone - Structural, Component Cross Section Area: 2.23592 m2
Name | Inside Face Surface = Outside Face Surface = Surfaces (All) = Edge Surface | Colliding Zones | Stone - Structural, Embodied Carbon | Stone - Structural, Embodied Energy (MJ) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) = Stone - Structural, Projected Component Area (Net) (m2) = Stone - Structural, Projected Component Area (Gross) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) = Length of the Wall on the Inside Face (m) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Stone - Structural, Component Volume (Net) (m3) = Stone - Structural, Component Volume (Gross) (m3) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Edge Surface Area (Net) (m2) | Stone - Structural, Mass (kg)
SW - 052 | Paint - Anthracite | Nau Santa Eulàlia | 2955.37 (kgCO₂) | 49256.2 | 6.47525 | 37.3828 | 37.2479 | 0 | 6.66354 | 6.28696 | 37.3828 | 37.2479 | 2.67025 | 14.9261 | 6.68768 | 14.9261 | 13.8999 | 7.57641 | 32837.5
SW - 052 | Stone - Wall | Espai públic; Nau Annexa | 11464.5 (kgCO₂) | 191075 | 26.0875 | 147.007 | 144.637 | 3.55271e-14 | 26.2759 | 25.8992 | 149.247 | 149.113 | 10.3584 | 57.9016 | 26.2992 | 59.672 | 53.1245 | 20.7169 | 127384

# IfcBuildingElementProxy: Stone - Structural D30 (91)
In: planta baixa
Classification: Column (ARCHICAD Classification); Material: Stone - Structural
ArchiCADProperties - Column Cross Section: Circular; Column Slant Angle: 90 deg; Extrusion Surface: Paint - Anthracite; End Surface: Paint - Anthracite; Element ID: CRE - 005; Hotlink and Element ID: CRE - 005; Layer: 00_PERIMETRO; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Column; Absolute Top Link Story: planta coberta; Relative Top Link Story: Home + 1; Top Link Story: Home + 1 (planta coberta); Structure Type: Basic; Parent ID: CRE - 005; Building Materials (All): Stone - Structural; Surfaces (All): Paint - Anthracite; Cover Fill: Background; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 107.AMB.NomTipus: CRE - 005_; 109.AMB.CodiTipus: CRE - 005; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Component Properties - Stone - Structural, Component Type: Core
ArchiCADQuantities - Core Height / Diameter: 0.03 m; Core Width: 0.03 m; Surface Area of the Column Core Top (Gross): 0.000675 m2; Surface Area of the Column Core Bottom (Gross): 0.000675 m2; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Surface Area of the Column Core Bottom (Net): 0.000675 m2; Surface Area of the Column Core Top (Net): 0.000675 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 0.0942478 m; Volume of the Column Veneer (Net): 0 m3; Area: 0.000675 m2; Width: 0.03 m; Top Offset: -1.77224 m; Top Elevation To First Reference Level: 2.72776 m; Top Elevation To Home Story: 2.72776 m; Top Elevation To Project Zero: 2.72776 m; Top Elevation To Sea Level: 12.0678 m; Top Elevation To Second Reference Level: 2.72776 m; Cross Section Height at Top/End (perpendicular): 0.03 m; Cross Section Height at Bottom/Start (perpendicular): 0.03 m; Cross Section Width at Top/End (perpendicular): 0.03 m; Cross Section Width at Bottom/Start (perpendicular): 0.03 m; Cross Section Height at Top/End (cut): 0.03 m; Cross Section Height at Bottom/Start (cut): 0.03 m; Cross Section Width at Top/End (cut): 0.03 m; Cross Section Width at Bottom/Start (cut): 0.03 m; Cross Section Area at Bottom/Start: 0.000675 m2; Cross Section Area at Top/End: 0.000675 m2; Number of Segments: 1; Top Surface Area (Net): 0.000675 m2; Top Surface Area (Gross): 0.000675 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.03 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Component Thickness: 0.03 m; Stone - Structural, Component Cross Section Area: 0.000706858 m2
Name | Stone - Structural, Embodied Carbon | Stone - Structural, Embodied Energy (MJ) | Volume of the Column Core (Net) (m3) = Volume of the Column Core (Gross) (m3) = Volume (Net) (m3) = Volume (Gross) (m3) = Stone - Structural, Component Volume (Net) (m3) = Stone - Structural, Component Volume (Gross) (m3) | Surface Area of the Column Core (Gross, without Top/Bottom) (m2) = Surface Area of the Column Core (Net, without Top/Bottom) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Maximum Height of the Column (m) = Minimum Height of the Column (m) = Height (m) = 3D Length (m) = 503.AMB.Altura (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Stone - Structural, Mass (kg)
24 x CRE - 005 | 0.30064 (kgCO₂) | 5.01066 | 0.00151838 | 0.209593 | 2.24945 | 0.478301 | 9.8183 | 3.34044
2 x CRE - 005 | 0.29403 (kgCO₂) | 4.9005 | 0.001485 | 0.204985 | 2.2 | 0.527755 | 9.86776 | 3.267 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
65 x CRE - 005 | 0.29403 (kgCO₂) | 4.9005 | 0.001485 | 0.204985 | 2.2 | 0.527755 | 9.86776 | 3.267

# IfcBuildingElementProxy: Tree Model Detailed 27 (19)
In: planta baixa
Classification: 70.50.10.10 Arbrats (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Paint - Anthracite; Element ID: Object_1942; Hotlink and Element ID: Object_1942; Layer: 00_ARBRATS 3D; Library Part Name: Tree Model Detailed 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1942; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Tree_Model_Detailed_27 - Show 2D Hotspots in 3D: yes; 3D Detail Level: 3; Shadow: yes; Default Tree Form: 6; Show Branches: yes; General Resolution of Trunk: 3; Crown Type: 1; Resolution of Crown: 6; Resolution of Leaves: 3; Crown Type Automatically: no; Trunk and Branches (trmat): Pine - Furniture; Leaves - Detailed Crown: Foliage - Leaves Tree Small; Simplified Crown: Foliage - Leaves Tree Small; Crown as Ellipsoid: Foliage - Leaves Tree Small; Symbol Type: 27; Use Custom Picture: no; Contour Pen: Objects - General; Fill Type: Background; Fill Pen: Transparent; Fill Background Pen: Transparent; Show Tree Name: no; Text Pen: Objects - General; Font Type: Arial; Font Size (mm): 7.8; Font Size (point): 221.102; Bold: no; Italic: no; Underline: no; Text Orientation on Symbol: 1; Cost: 0; Type (FM_Type): Others; Type (iFMType): 25
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 70.50.10.10 Arbrats; 104.AMB.ClassificacioCodi: 70.50.10.10; 105.AMB.ClassificacioDescripcio: Arbrats; 107.AMB.NomTipus: Object_1942_; 109.AMB.CodiTipus: Object_1942; 115.AMB.Nivell: planta baixa
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
AC_Equantity_Tree_Model_Detailed_27 - Bottom Level: 1 m; Top Level: 0 m; Diameter of Crown Sphere Parts: 1 m; Diameter of Leaves: 0.4 m; Range of Detailed Crown: 30 m; Range of Simplified Crown: 70 m; Text Position X: 0 m; Text Position Y: 0 m
Name | Surfaces (All) | Renovation Status | Density in % | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | Status | Length (A) (m) = Width (m) = 502.AMB.Amplada (m) = Dimension 1 (m) = Dimension 2 (m) | Area (m2) = Top Surface Area (Net) (m2) | ArchiCADQuantities, Height (m) = 503.AMB.Altura (m) = AC_Equantity_Tree_Model_Detailed_27, Height (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Surface Area (m2) = Bottom Surface Area (Net) (m2) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Survey Coordinate X (m) | Survey Coordinate Y (m) | Half A (m) = Half B (m) | Trunk Height (m) | Trunk Diameter in 3D (m) | Colliding Zones
Object_1942 | Paint - Anthracite | Existing | 65 | Preexistències | EXISTING | 5 | 25 | 10 | 0.226709 | 0 | 9.34 | 123.734 | 9.81532 | 19.1553 | 426533 | 4579774 | 2.5 | 4 | 0.3
Object_1942 | Paint - Anthracite | Existing | 65 | Preexistències | EXISTING | 5 | 25 | 10 | 0.226709 | 0 | 9.34 | 123.531 | 10.0219 | 19.3619 | 426567 | 4579784 | 2.5 | 4 | 0.3
Object_1942 | Paint - Anthracite | Existing | 65 | Preexistències | EXISTING | 5 | 25 | 10 | 0.226709 | 0 | 9.34 | 123.672 | 10.0486 | 19.3886 | 426550 | 4579779 | 2.5 | 4 | 0.3
Object_1942 | Paint - Anthracite | Existing | 50 | Preexistències | EXISTING | 10 | 100 | 16 | 0.841926 | 0 | 9.34 | 276.766 | 15.7947 | 25.1347 | 426541 | 4579788 | 5 | 6 | 0.45 | Espai públic
Object_1942 | Paint - Anthracite | Existing | 50 | Preexistències | EXISTING | 10 | 100 | 16 | 0.841926 | 0 | 9.34 | 277.644 | 16.0041 | 25.3441 | 426548 | 4579790 | 5 | 6 | 0.45 | Espai públic
Object_1942 | Paint - Anthracite | Existing | 50 | Preexistències | EXISTING | 10 | 100 | 16 | 0.841926 | 0 | 9.34 | 277.152 | 15.5892 | 24.9292 | 426555 | 4579793 | 5 | 6 | 0.45 | Espai públic
Object_1942 | Paint - Anthracite | Existing | 50 | Preexistències | EXISTING | 10 | 100 | 16 | 0.841926 | 0 | 9.34 | 277.135 | 15.8446 | 25.1846 | 426570 | 4579797 | 5 | 6 | 0.45 | Espai públic
Object_1942 | Paint - Anthracite | Existing | 50 | Preexistències | EXISTING | 10 | 100 | 16 | 0.841926 | 0 | 9.34 | 276.965 | 15.7438 | 25.0838 | 426568 | 4579805 | 5 | 6 | 0.45 | Espai públic
Object_1942 | Paint - Anthracite | Existing | 50 | Preexistències | EXISTING | 10 | 100 | 16 | 0.841926 | 0 | 9.34 | 277.459 | 15.978 | 25.318 | 426573 | 4579806 | 5 | 6 | 0.45 | Espai públic
Object_1942 | Paint - Anthracite | Existing | 65 | Preexistències | EXISTING | 5 | 25 | 10 | 0.226709 | 0 | 9.34 | 123.31 | 9.94862 | 19.2886 | 426585 | 4579789 | 2.5 | 4 | 0.3
Object_1942 | Paint - Anthracite | Existing | 65 | Preexistències | EXISTING | 5 | 25 | 10 | 0.226709 | 0 | 9.34 | 123.594 | 9.80681 | 19.1468 | 426579 | 4579787 | 2.5 | 4 | 0.3
Object_1942 | Paint - Anthracite | Existing | 50 | Preexistències | EXISTING | 10 | 100 | 16 | 0.841926 | 0 | 9.34 | 277.474 | 15.9147 | 25.2547 | 426577 | 4579799 | 5 | 6 | 0.45 | Espai públic
Object_1942 | Paint - Anthracite | Existing | 65 | Preexistències | EXISTING | 5 | 25 | 10 | 0.226709 | 0 | 9.34 | 124.11 | 9.7448 | 19.0848 | 426573 | 4579786 | 2.5 | 4 | 0.3
