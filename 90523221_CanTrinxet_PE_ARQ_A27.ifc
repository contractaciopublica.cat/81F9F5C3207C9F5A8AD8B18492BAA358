Properties of the parts of a building model (IFC2X3), part 90 of 99

# IfcBuildingElementProxy: Rhino_Object_95, Object_95
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_95 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_96, Object_96
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_96_; 109.AMB.CodiTipus: Object_96; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_96 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_96; Hotlink and Element ID: Object_96; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_96; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_96; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_96 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m

# IfcBuildingElementProxy: Rhino_Object_97, Object_97
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_97; Hotlink and Element ID: Object_97; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_97; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_97; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_97 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_97_; 109.AMB.CodiTipus: Object_97; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_97 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_98, Object_98
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_98; Hotlink and Element ID: Object_98; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_98; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_98; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_98 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_98_; 109.AMB.CodiTipus: Object_98; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_98 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_99, Object_99
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_99_; 109.AMB.CodiTipus: Object_99; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_99 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
AC_Pset_Rhino_Object_99 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_99; Hotlink and Element ID: Object_99; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_99; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_99; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Ridge Tile 27 (333)
In: planta baixa
ArchiCADProperties - Surface: Roof Tiles - Dutch; Layer: 00_TEJAS; Library Part Name: Ridge Tile 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Surfaces (All): Roof Tiles - Dutch; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Ridge_Tile_27 - 3D Detail Level: 3; Show 2D Hotspots in 3D: no; Shadow: yes; Resolution: 18; Contour Pen: Objects - General; Fill Type: Background; Fill Pen: Backgrounds - color 1; Fill Background Pen: Backgrounds - color 1; Tile: Brick - Surface Colour; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 115.AMB.Nivell: planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30
ArchiCADQuantities - Width: 0.179 m
AC_Equantity_Ridge_Tile_27 - Tile Length: 0.2 m; Inner Radius: 0.0495 m; Bottom Level: 1 m; Top Level: 0 m
5 AMB.Geometria - 502.AMB.Amplada: 0.179 m; 506.AMB.Profunditat: 0 m
Name | Classification | Rotation Angle (deg) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Renovation Status | Inclination (deg) | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | AUX_107.NomTipus | Status | Length (A) (m) | Area (m2) = Top Surface Area (Net) (m2) | ArchiCADQuantities, Height (m) = AC_Equantity_Ridge_Tile_27, Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Surface Area (m2) = Bottom Surface Area (Net) (m2) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Survey Coordinate X (m) | Survey Coordinate Y (m) | Ridge Height (m) | Full Length (m)
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426552 | 4579789 | 1.69756 | 6.826
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426582 | 4579799 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426555 | 4579790 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426554 | 4579790 | 1.69756 | 6.826
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426556 | 4579791 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426571 | 4579795 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426572 | 4579795 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426585 | 4579799 | 1.69756 | 6.826
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 4.84292 | 0.866882 | 1.29139 | 0.0213934 | 5.18934 | 14.5293 | 2.60725 | 6.51816 | 15.8582 | 426537 | 4579783 | 1.24345 | 5
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426575 | 4579796 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426547 | 4579788 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426541 | 4579786 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426544 | 4579787 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426584 | 4579799 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426573 | 4579796 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426545 | 4579787 | 1.69756 | 6.826
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426579 | 4579797 | 1.69756 | 6.826
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426569 | 4579795 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426586 | 4579800 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426549 | 4579788 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426540 | 4579785 | 1.69756 | 6.826
3 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426582 | 4579798 | 1.69756 | 6.826
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426543 | 4579787 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426551 | 4579789 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426548 | 4579788 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426580 | 4579798 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426587 | 4579800 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426542 | 4579786 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426539 | 4579785 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426553 | 4579789 | 1.69756 | 6.826
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426543 | 4579786 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426583 | 4579799 | 1.69756 | 6.826
3 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426569 | 4579794 | 1.69756 | 6.826
3 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426556 | 4579790 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426557 | 4579791 | 1.69756 | 6.826
3 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426579 | 4579798 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426581 | 4579798 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426570 | 4579795 | 1.69756 | 6.826
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426546 | 4579787 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14271 | 13.4827 | 0.683348 | 4.6189 | 13.9589 | 426534 | 4579778 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14272 | 13.4827 | 0.683348 | 4.6189 | 13.9589 | 426535 | 4579778 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426578 | 4579797 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426585 | 4579800 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14272 | 13.4827 | 0.683348 | 4.61891 | 13.9589 | 426535 | 4579778 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426577 | 4579797 | 1.69756 | 6.826
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426574 | 4579796 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14273 | 13.4827 | 0.683348 | 4.61891 | 13.9589 | 426535 | 4579778 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426576 | 4579797 | 1.69756 | 6.826
3 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426540 | 4579786 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14273 | 13.4827 | 0.683348 | 4.61891 | 13.9589 | 426536 | 4579778 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14274 | 13.4827 | 0.683348 | 4.61892 | 13.9589 | 426536 | 4579778 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14274 | 13.4827 | 0.683348 | 4.61892 | 13.9589 | 426536 | 4579779 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14275 | 13.4827 | 0.683348 | 4.61893 | 13.9589 | 426537 | 4579779 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14275 | 13.4828 | 0.683348 | 4.61894 | 13.9589 | 426537 | 4579779 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14276 | 13.4828 | 0.683348 | 4.61894 | 13.9589 | 426537 | 4579779 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14271 | 13.4827 | 0.683348 | 4.61889 | 13.9589 | 426534 | 4579778 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.1427 | 13.4827 | 0.683348 | 4.61889 | 13.9589 | 426534 | 4579775 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14271 | 13.4827 | 0.683348 | 4.61889 | 13.9589 | 426535 | 4579775 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14271 | 13.4827 | 0.683348 | 4.61889 | 13.9589 | 426535 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426550 | 4579789 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14271 | 13.4827 | 0.683348 | 4.6189 | 13.9589 | 426535 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
4 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426553 | 4579790 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14272 | 13.4827 | 0.683348 | 4.6189 | 13.9589 | 426535 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426568 | 4579794 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426546 | 4579788 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14272 | 13.4827 | 0.683348 | 4.6189 | 13.9589 | 426536 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14272 | 13.4827 | 0.683348 | 4.61891 | 13.9589 | 426536 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14273 | 13.4827 | 0.683348 | 4.61891 | 13.9589 | 426536 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
3 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14274 | 13.4827 | 0.683348 | 4.61892 | 13.9589 | 426537 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
3 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426535 | 4579812 | 2.91362 | 9.7
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14275 | 13.4827 | 0.683348 | 4.61893 | 13.9589 | 426537 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14275 | 13.4827 | 0.683348 | 4.61893 | 13.9589 | 426538 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14275 | 13.4828 | 0.683348 | 4.61894 | 13.9589 | 426538 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
5 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426538 | 4579785 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.14276 | 13.4828 | 0.683348 | 4.61894 | 13.9589 | 426538 | 4579776 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 17.0812 | Cu1 | New | 0 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.84796 | 0.688785 | 0.0495 | 0.0164864 | 4.555 | 13.895 | 2.0087 | 4.64314 | 13.9831 | 426534 | 4579777 | 0 | 3.84796 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426572 | 4579796 | 1.69756 | 6.826
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.7401 | 14.0801 | 3.55599 | 6.52049 | 15.8605 | 426558 | 4579791 | 1.69756 | 6.826
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.048 | Cu1 | New | 18 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 1.23637 | 0.221311 | 0.448799 | 0.00559278 | 4.1427 | 13.4827 | 0.683348 | 4.61889 | 13.9589 | 426534 | 4579778 | 0.401722 | 1.3 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 5.03663 | 0.901557 | 1.34113 | 0.0222491 | 5.13525 | 14.4752 | 2.71115 | 6.51381 | 15.8538 | 426537 | 4579783 | 1.29319 | 5.2
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 5.61778 | 1.00558 | 1.49035 | 0.0248163 | 4.9877 | 14.3277 | 3.02284 | 6.51547 | 15.8555 | 426537 | 4579784 | 1.4424 | 5.8
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 5.61778 | 1.00558 | 1.49035 | 0.0248163 | 4.9877 | 14.3277 | 3.02284 | 6.51547 | 15.8555 | 426538 | 4579784 | 1.4424 | 5.8
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 5.42407 | 0.970908 | 1.44061 | 0.0239606 | 5.0391 | 14.3791 | 2.91894 | 6.51714 | 15.8571 | 426558 | 4579790 | 1.39266 | 5.6
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 5.42407 | 0.970908 | 1.44061 | 0.0239606 | 5.0391 | 14.3791 | 2.91894 | 6.51714 | 15.8571 | 426559 | 4579790 | 1.39266 | 5.6
