Properties of the parts of a building model (IFC2X3), part 49 of 99

# IfcBuildingElementProxy: Rhino_Object_1489, Object_1489
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426570 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1489 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_149, Object_149
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_149; Hotlink and Element ID: Object_149; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_149; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_149; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_149 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_149_; 109.AMB.CodiTipus: Object_149; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426570 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_149 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1490, Object_1490
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1490; Hotlink and Element ID: Object_1490; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1490; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1490; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1490 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1490_; 109.AMB.CodiTipus: Object_1490; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426571 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1490 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1491, Object_1491
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1491; Hotlink and Element ID: Object_1491; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1491; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1491; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1491 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1491_; 109.AMB.CodiTipus: Object_1491; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426572 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1491 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Rhino_Object_1492, Object_1492
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1492; Hotlink and Element ID: Object_1492; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1492; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1492; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1492 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1492_; 109.AMB.CodiTipus: Object_1492; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426572 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1492 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1493, Object_1493
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1493; Hotlink and Element ID: Object_1493; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1493; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1493; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1493 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1493_; 109.AMB.CodiTipus: Object_1493; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
AC_Equantity_Rhino_Object_1493 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m

# IfcBuildingElementProxy: Rhino_Object_1494, Object_1494
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1494 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1494; Hotlink and Element ID: Object_1494; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1494; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1494; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1494_; 109.AMB.CodiTipus: Object_1494; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1494 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1495, Object_1495
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1495; Hotlink and Element ID: Object_1495; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1495; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1495; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1495 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1495_; 109.AMB.CodiTipus: Object_1495; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1495 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1496, Object_1496
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1496; Hotlink and Element ID: Object_1496; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1496; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1496; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1496 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1496_; 109.AMB.CodiTipus: Object_1496; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426575 m; Survey Coordinate Y: 4579796 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1496 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1497, Object_1497
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1497; Hotlink and Element ID: Object_1497; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1497; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1497; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1497 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1497_; 109.AMB.CodiTipus: Object_1497; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426576 m; Survey Coordinate Y: 4579796 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1497 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1498, Object_1498
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1498; Hotlink and Element ID: Object_1498; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1498; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1498; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1498 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1498_; 109.AMB.CodiTipus: Object_1498; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426576 m; Survey Coordinate Y: 4579796 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1498 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1499, Object_1499
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1499; Hotlink and Element ID: Object_1499; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1499; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1499; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1499 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579796 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1499 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1499_; 109.AMB.CodiTipus: Object_1499; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_150, Object_150
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_150; Hotlink and Element ID: Object_150; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_150; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_150; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_150_; 109.AMB.CodiTipus: Object_150; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_150 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426570 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_150 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1500, Object_1500
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1500; Hotlink and Element ID: Object_1500; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1500; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1500; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1500 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1500_; 109.AMB.CodiTipus: Object_1500; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579796 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1500 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1501, Object_1501
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1501; Hotlink and Element ID: Object_1501; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1501; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1501; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1501 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426578 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1501 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1501_; 109.AMB.CodiTipus: Object_1501; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Rhino_Object_1502, Object_1502
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1502; Hotlink and Element ID: Object_1502; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1502; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1502; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1502 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1502_; 109.AMB.CodiTipus: Object_1502; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
