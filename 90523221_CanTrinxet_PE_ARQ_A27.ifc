Properties of the parts of a building model (IFC2X3), part 80 of 99

# IfcBuildingElementProxy: Rhino_Object_3527, Object_3527
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3527; Hotlink and Element ID: Object_3527; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_3527; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3527; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3527_; 109.AMB.CodiTipus: Object_3527; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.290002 m; Area: 0.0199253 m2; Height: 0.290151 m; Volume (Net): 0.004616 m3; Width: 0.0687073 m; Elevation to Project Zero: 5.12427 m; Elevation to 1st Reference Level: 5.12427 m; Elevation to 2nd Reference Level: 5.12427 m; Elevation to Sea Level: 14.4643 m; Elevation to Linked/Home Story: 5.12427 m; Home Offset: 5.12427 m; Surface Area: 0.239072 m2; Top Elevation To First Reference Level: 5.41443 m; Top Elevation To Home Story: 5.41443 m; Top Elevation To Project Zero: 5.41443 m; Top Elevation To Sea Level: 14.7544 m; Top Elevation To Second Reference Level: 5.41443 m; Bottom Elevation To First Reference Level: 5.12427 m; Bottom Elevation To Home Story: 5.12427 m; Bottom Elevation To Project Zero: 5.12427 m; Bottom Elevation To Sea Level: 14.4643 m; Bottom Elevation To Second Reference Level: 5.12427 m; Survey Coordinate X: 426532 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 14.4643 m; Top Surface Area (Net): 0.0199253 m2; Bottom Surface Area (Net): 0.239072 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.0687073 m; 503.AMB.Altura: 0.290151 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_3527 - Dimension 1: 0.290002 m; Dimension 2: 0.0687073 m; Height: 0.290151 m; Bottom Level: -1.95377e-10 m; Top Level: 0.290151 m
Component Quantities - Component, Component Volume (Net): 0.004616 m3; Component, Component Volume (Gross): 0.004616 m3

# IfcBuildingElementProxy: Rhino_Object_3528, Object_3528
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3528; Hotlink and Element ID: Object_3528; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_3528; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3528; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3528 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3528_; 109.AMB.CodiTipus: Object_3528; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.096756 m; Area: 0.00942898 m2; Height: 0.0490955 m; Volume (Net): 0.000457726 m3; Width: 0.0974511 m; Elevation to Project Zero: 5.46564 m; Elevation to 1st Reference Level: 5.46564 m; Elevation to 2nd Reference Level: 5.46564 m; Elevation to Sea Level: 14.8056 m; Elevation to Linked/Home Story: 5.46564 m; Home Offset: 5.46564 m; Surface Area: 0.0376683 m2; Top Elevation To First Reference Level: 5.51474 m; Top Elevation To Home Story: 5.51474 m; Top Elevation To Project Zero: 5.51474 m; Top Elevation To Sea Level: 14.8547 m; Top Elevation To Second Reference Level: 5.51474 m; Bottom Elevation To First Reference Level: 5.46564 m; Bottom Elevation To Home Story: 5.46564 m; Bottom Elevation To Project Zero: 5.46564 m; Bottom Elevation To Sea Level: 14.8056 m; Bottom Elevation To Second Reference Level: 5.46564 m; Survey Coordinate X: 426532 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 14.8056 m; Top Surface Area (Net): 0.00942898 m2; Bottom Surface Area (Net): 0.0376683 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_3528 - Dimension 1: 0.096756 m; Dimension 2: 0.0974511 m; Height: 0.0490955 m; Bottom Level: 0 m; Top Level: 0.0490955 m
Component Quantities - Component, Component Volume (Net): 0.000457726 m3; Component, Component Volume (Gross): 0.000457726 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0974511 m; 503.AMB.Altura: 0.0490955 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_3529 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3529; Hotlink and Element ID: Object_3529; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_3529; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3529; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3529 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3529_; 109.AMB.CodiTipus: Object_3529; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.77406 m; Area: 0.388369 m2; Height: 0.949315 m; Volume (Net): 0.368226 m3; Width: 0.14 m; Surface Area: 6.30817 m2; Survey Coordinate X: 426530 m; Survey Coordinate Y: 4579794 m; Top Surface Area (Net): 0.388369 m2; Bottom Surface Area (Net): 6.30817 m2
AC_Equantity_Rhino_Object_3529 - Dimension 1: 2.77406 m; Dimension 2: 0.14 m; Height: 0.949315 m; Bottom Level: 0 m; Top Level: 0.949315 m
5 AMB.Geometria - 502.AMB.Amplada: 0.14 m; 503.AMB.Altura: 0.949315 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.368226 m3; Component, Component Volume (Gross): 0.368226 m3
Name | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m)
Object_3529 | 1.04973 | 10.3897 | 1.99905 | 11.339
Object_3529 | 0.101684 | 9.44168 | 1.051 | 10.391

# IfcBuildingElementProxy: Rhino_Object_3575, Object_3575
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3575; Hotlink and Element ID: Object_3575; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_3575; Building Material / Composite / Profile / Fill: Common Brick; Fill Type: Common Brick; Colliding Zones: Espai públic; Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3575; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3575 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3575_; 109.AMB.CodiTipus: Object_3575; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.157072 m; Area: 0.0219901 m2; Height: 3.74696 m; Volume (Net): 0.0823882 m3; Width: 0.14 m; Elevation to Project Zero: 1.04973 m; Elevation to 1st Reference Level: 1.04973 m; Elevation to 2nd Reference Level: 1.04973 m; Elevation to Sea Level: 10.3897 m; Elevation to Linked/Home Story: 1.04973 m; Home Offset: 1.04973 m; Surface Area: 2.27011 m2; Top Elevation To First Reference Level: 4.79669 m; Top Elevation To Home Story: 4.79669 m; Top Elevation To Project Zero: 4.79669 m; Top Elevation To Sea Level: 14.1367 m; Top Elevation To Second Reference Level: 4.79669 m; Bottom Elevation To First Reference Level: 1.04973 m; Bottom Elevation To Home Story: 1.04973 m; Bottom Elevation To Project Zero: 1.04973 m; Bottom Elevation To Sea Level: 10.3897 m; Bottom Elevation To Second Reference Level: 1.04973 m; Survey Coordinate X: 426530 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 10.3897 m; Top Surface Area (Net): 0.0219901 m2; Bottom Surface Area (Net): 2.27011 m2
AC_Equantity_Rhino_Object_3575 - Dimension 1: 0.157072 m; Dimension 2: 0.14 m; Height: 3.74696 m; Bottom Level: 0 m; Top Level: 3.74696 m
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.14 m; 503.AMB.Altura: 3.74696 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0823882 m3; Component, Component Volume (Gross): 0.0823882 m3

# IfcBuildingElementProxy: Rhino_Object_3578 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Library Part Name: Rhino_Object_3578; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3578 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.77406 m; Area: 0.388369 m2; Height: 0.949315 m; Volume (Net): 0.368226 m3; Width: 0.14 m; Surface Area: 6.30817 m2; Survey Coordinate X: 426529 m; Survey Coordinate Y: 4579798 m; Top Surface Area (Net): 0.388369 m2; Bottom Surface Area (Net): 6.30817 m2
AC_Equantity_Rhino_Object_3578 - Dimension 1: 2.77406 m; Dimension 2: 0.14 m; Height: 0.949315 m; Bottom Level: 0 m; Top Level: 0.949315 m
5 AMB.Geometria - 502.AMB.Amplada: 0.14 m; 503.AMB.Altura: 0.949315 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.368226 m3; Component, Component Volume (Gross): 0.368226 m3
Name | Rotation Angle (deg) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Layer | 107.AMB.NomTipus | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m)
F3 | 13.5621 | F3 | 00_ORNAMENTOS PLANTA | F3_ | 1.04973 | 10.3897 | 1.99905 | 11.339
Object_3578 | 13.5006 | Object_3578 | 00_ORNAMENTOS | Object_3578_ | 0.101684 | 9.44168 | 1.051 | 10.391

# IfcBuildingElementProxy: Rhino_Object_3579, Object_3579
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3579; Hotlink and Element ID: Object_3579; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_3579; Building Material / Composite / Profile / Fill: Common Brick; Fill Type: Common Brick; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3579; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3579 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3579_; 109.AMB.CodiTipus: Object_3579; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.157072 m; Area: 0.0219901 m2; Height: 3.74696 m; Volume (Net): 0.0823882 m3; Width: 0.14 m; Elevation to Project Zero: 1.04973 m; Elevation to 1st Reference Level: 1.04973 m; Elevation to 2nd Reference Level: 1.04973 m; Elevation to Sea Level: 10.3897 m; Elevation to Linked/Home Story: 1.04973 m; Home Offset: 1.04973 m; Surface Area: 2.27011 m2; Top Elevation To First Reference Level: 4.79669 m; Top Elevation To Home Story: 4.79669 m; Top Elevation To Project Zero: 4.79669 m; Top Elevation To Sea Level: 14.1367 m; Top Elevation To Second Reference Level: 4.79669 m; Bottom Elevation To First Reference Level: 1.04973 m; Bottom Elevation To Home Story: 1.04973 m; Bottom Elevation To Project Zero: 1.04973 m; Bottom Elevation To Sea Level: 10.3897 m; Bottom Elevation To Second Reference Level: 1.04973 m; Survey Coordinate X: 426529 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 10.3897 m; Top Surface Area (Net): 0.0219901 m2; Bottom Surface Area (Net): 2.27011 m2
AC_Equantity_Rhino_Object_3579 - Dimension 1: 0.157072 m; Dimension 2: 0.14 m; Height: 3.74696 m; Bottom Level: 0 m; Top Level: 3.74696 m
5 AMB.Geometria - 502.AMB.Amplada: 0.14 m; 503.AMB.Altura: 3.74696 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0823882 m3; Component, Component Volume (Gross): 0.0823882 m3

# IfcBuildingElementProxy: Rhino_Object_3583, Object_3583
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_3583 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3583; Hotlink and Element ID: Object_3583; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_3583; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3583; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.29 m; Area: 1.07949 m2; Height: 1.95781 m; Volume (Net): 0.660978 m3; Width: 3.72238 m; Elevation to Project Zero: 4.54399 m; Elevation to 1st Reference Level: 4.54399 m; Elevation to 2nd Reference Level: 4.54399 m; Elevation to Sea Level: 13.884 m; Elevation to Linked/Home Story: 4.54399 m; Home Offset: 4.54399 m; Surface Area: 8.2811 m2; Top Elevation To First Reference Level: 6.5018 m; Top Elevation To Home Story: 6.5018 m; Top Elevation To Project Zero: 6.5018 m; Top Elevation To Sea Level: 15.8418 m; Top Elevation To Second Reference Level: 6.5018 m; Bottom Elevation To First Reference Level: 4.54399 m; Bottom Elevation To Home Story: 4.54399 m; Bottom Elevation To Project Zero: 4.54399 m; Bottom Elevation To Sea Level: 13.884 m; Bottom Elevation To Second Reference Level: 4.54399 m; Survey Coordinate X: 426532 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.884 m; Top Surface Area (Net): 1.07949 m2; Bottom Surface Area (Net): 8.2811 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 3.72238 m; 503.AMB.Altura: 1.95781 m; 506.AMB.Profunditat: 0 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3583_; 109.AMB.CodiTipus: Object_3583; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Component Quantities - Component, Component Volume (Net): 0.660978 m3; Component, Component Volume (Gross): 0.660978 m3
AC_Equantity_Rhino_Object_3583 - Dimension 1: 0.29 m; Dimension 2: 3.72238 m; Height: 1.95781 m; Bottom Level: -1.93322e-08 m; Top Level: 1.95781 m

# IfcBuildingElementProxy: Rhino_Object_3587 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3587; Hotlink and Element ID: Object_3587; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_3587; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3587; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3587 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Equantity_Rhino_Object_3587 - Dimension 1: 2 m; Dimension 2: 3.722 m; Height: 2.6358 m; Bottom Level: -2.28382e-09 m; Top Level: 2.6358 m
ArchiCADQuantities - Length (A): 2 m; Area: 7.444 m2; Height: 2.6358 m; Volume (Net): 0.334921 m3; Width: 3.722 m; Surface Area: 3.62951 m2; Survey Coordinate X: 426532 m; Survey Coordinate Y: 4579796 m; Top Surface Area (Net): 7.444 m2; Bottom Surface Area (Net): 3.62951 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3587_; 109.AMB.CodiTipus: Object_3587; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Component Quantities - Component, Component Volume (Net): 0.334921 m3; Component, Component Volume (Gross): 0.334921 m3
5 AMB.Geometria - 502.AMB.Amplada: 3.722 m; 503.AMB.Altura: 2.6358 m; 506.AMB.Profunditat: 0 m
Name | Building Material / Composite / Profile / Fill = Fill Type | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m)
Object_3587 | Background | 1.04973 | 10.3897 | 1.99905 | 11.339
Object_3587 | Common Brick | 0.101684 | 9.44168 | 1.051 | 10.391

# IfcBuildingElementProxy: Rhino_Object_3588 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3588; Hotlink and Element ID: Object_3588; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_3588; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3588; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3588 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3588_; 109.AMB.CodiTipus: Object_3588; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2 m; Area: 7.444 m2; Height: 2.6358 m; Volume (Net): 0.335448 m3; Width: 3.722 m; Surface Area: 3.63439 m2; Survey Coordinate X: 426532 m; Survey Coordinate Y: 4579797 m; Top Surface Area (Net): 7.444 m2; Bottom Surface Area (Net): 3.63439 m2
AC_Equantity_Rhino_Object_3588 - Dimension 1: 2 m; Dimension 2: 3.722 m; Height: 2.6358 m; Bottom Level: -2.28382e-09 m; Top Level: 2.6358 m
5 AMB.Geometria - 502.AMB.Amplada: 3.722 m; 503.AMB.Altura: 2.6358 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.335448 m3; Component, Component Volume (Gross): 0.335448 m3
Name | Building Material / Composite / Profile / Fill = Fill Type | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m)
Object_3588 | Background | 1.04973 | 10.3897 | 1.99905 | 11.339
Object_3588 | Common Brick | 0.101684 | 9.44168 | 1.051 | 10.391

# IfcBuildingElementProxy: Rhino_Object_373, Object_373
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_373 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 1; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 5; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 12.6171 deg; Surface: Brick - Aged Natural; Element ID: Object_373; Hotlink and Element ID: Object_373; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_373; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_373; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_373_; 109.AMB.CodiTipus: Object_373; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 1.36749 m; Area: 1.58691 m2; Height: 0.317224 m; Volume (Net): 0.137076 m3; Width: 1.16045 m; Elevation to Project Zero: 5.25703 m; Elevation to 1st Reference Level: 5.25703 m; Elevation to 2nd Reference Level: 5.25703 m; Elevation to Sea Level: 14.597 m; Elevation to Linked/Home Story: 5.25703 m; Home Offset: 5.25703 m; Surface Area: 2.08125 m2; Top Elevation To First Reference Level: 5.57402 m; Top Elevation To Home Story: 5.57402 m; Top Elevation To Project Zero: 5.57402 m; Top Elevation To Sea Level: 14.914 m; Top Elevation To Second Reference Level: 5.57402 m; Bottom Elevation To First Reference Level: 5.25703 m; Bottom Elevation To Home Story: 5.25703 m; Bottom Elevation To Project Zero: 5.25703 m; Bottom Elevation To Sea Level: 14.597 m; Bottom Elevation To Second Reference Level: 5.25703 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 14.597 m; Top Surface Area (Net): 1.58691 m2; Bottom Surface Area (Net): 2.08125 m2
AC_Equantity_Rhino_Object_373 - Dimension 1: 1.36749 m; Dimension 2: 1.16045 m; Height: 0.317224 m; Bottom Level: -0.000167479 m; Top Level: 0.317056 m
5 AMB.Geometria - 502.AMB.Amplada: 1.16045 m; 503.AMB.Altura: 0.317224 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.137076 m3; Component, Component Volume (Gross): 0.137076 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_374, Object_374
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 11.7201 deg; Surface: Brick - Aged Natural; Element ID: Object_374; Hotlink and Element ID: Object_374; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_374; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_374; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.103939 m3; Component, Component Volume (Gross): 0.103939 m3
5 AMB.Geometria - 502.AMB.Amplada: 2.11632 m; 503.AMB.Altura: 3.84526 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_374 - Dimension 1: 0.126337 m; Dimension 2: 2.11632 m; Height: 3.84526 m; Bottom Level: -2.82885e-13 m; Top Level: 3.84526 m
ArchiCADQuantities - Length (A): 0.126337 m; Area: 0.26737 m2; Height: 3.84526 m; Volume (Net): 0.103939 m3; Width: 2.11632 m; Elevation to Project Zero: 0.237328 m; Elevation to 1st Reference Level: 0.237328 m; Elevation to 2nd Reference Level: 0.237328 m; Elevation to Sea Level: 9.57733 m; Elevation to Linked/Home Story: 0.237328 m; Home Offset: 0.237328 m; Surface Area: 4.62008 m2; Top Elevation To First Reference Level: 3.90536 m; Top Elevation To Home Story: 3.90536 m; Top Elevation To Project Zero: 3.90536 m; Top Elevation To Sea Level: 13.2454 m; Top Elevation To Second Reference Level: 3.90536 m; Bottom Elevation To First Reference Level: 0.237328 m; Bottom Elevation To Home Story: 0.237328 m; Bottom Elevation To Project Zero: 0.237328 m; Bottom Elevation To Sea Level: 9.57733 m; Bottom Elevation To Second Reference Level: 0.237328 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 9.57733 m; Top Surface Area (Net): 0.26737 m2; Bottom Surface Area (Net): 4.62008 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_374_; 109.AMB.CodiTipus: Object_374; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_374 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg

# IfcBuildingElementProxy: Rhino_Object_379, Object_379
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.3153 deg; Surface: Brick - Aged Natural; Element ID: Object_379; Hotlink and Element ID: Object_379; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_379; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_379; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_379 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_379_; 109.AMB.CodiTipus: Object_379; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Equantity_Rhino_Object_379 - Dimension 1: 0.192254 m; Dimension 2: 2.30763 m; Height: 0.370731 m; Bottom Level: 0 m; Top Level: 0.370731 m
5 AMB.Geometria - 502.AMB.Amplada: 2.30763 m; 503.AMB.Altura: 0.370731 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 0.192254 m; Area: 0.443651 m2; Height: 0.370731 m; Volume (Net): 0.00845994 m3; Width: 2.30763 m; Elevation to Project Zero: 3.80622 m; Elevation to 1st Reference Level: 3.80622 m; Elevation to 2nd Reference Level: 3.80622 m; Elevation to Sea Level: 13.1462 m; Elevation to Linked/Home Story: 3.80622 m; Home Offset: 3.80622 m; Surface Area: 0.711295 m2; Top Elevation To First Reference Level: 4.00036 m; Top Elevation To Home Story: 4.00036 m; Top Elevation To Project Zero: 4.00036 m; Top Elevation To Sea Level: 13.3404 m; Top Elevation To Second Reference Level: 4.00036 m; Bottom Elevation To First Reference Level: 3.80622 m; Bottom Elevation To Home Story: 3.80622 m; Bottom Elevation To Project Zero: 3.80622 m; Bottom Elevation To Sea Level: 13.1462 m; Bottom Elevation To Second Reference Level: 3.80622 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.1462 m; Top Surface Area (Net): 0.443651 m2; Bottom Surface Area (Net): 0.711295 m2
Component Quantities - Component, Component Volume (Net): 0.00845994 m3; Component, Component Volume (Gross): 0.00845994 m3

# IfcBuildingElementProxy: Rhino_Object_41, Object_41
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_41 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_41_; 109.AMB.CodiTipus: Object_41; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.97209 m; Area: 0.854729 m2; Height: 0.516507 m; Volume (Net): 0.00795521 m3; Width: 0.287585 m; Elevation to Project Zero: 3.73569 m; Elevation to 1st Reference Level: 3.73569 m; Elevation to 2nd Reference Level: 3.73569 m; Elevation to Sea Level: 13.0757 m; Elevation to Linked/Home Story: 3.73569 m; Home Offset: 3.73569 m; Surface Area: 0.864871 m2; Top Elevation To First Reference Level: 3.99592 m; Top Elevation To Home Story: 3.99592 m; Top Elevation To Project Zero: 3.99592 m; Top Elevation To Sea Level: 13.3359 m; Top Elevation To Second Reference Level: 3.99592 m; Bottom Elevation To First Reference Level: 3.73569 m; Bottom Elevation To Home Story: 3.73569 m; Bottom Elevation To Project Zero: 3.73569 m; Bottom Elevation To Sea Level: 13.0757 m; Bottom Elevation To Second Reference Level: 3.73569 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 13.0757 m; Top Surface Area (Net): 0.854729 m2; Bottom Surface Area (Net): 0.864871 m2
AC_Equantity_Rhino_Object_41 - Dimension 1: 2.97209 m; Dimension 2: 0.287585 m; Height: 0.516507 m; Bottom Level: -2.30926e-14 m; Top Level: 0.516507 m
5 AMB.Geometria - 502.AMB.Amplada: 0.287585 m; 503.AMB.Altura: 0.516507 m; 506.AMB.Profunditat: 0 m
ArchiCADProperties - Rotation Angle: 13.7074 deg; Surface: Brick - Aged Natural; Element ID: Object_41; Hotlink and Element ID: Object_41; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_41; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_41; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.00795521 m3; Component, Component Volume (Gross): 0.00795521 m3

# IfcBuildingElementProxy: Rhino_Object_413, Object_413
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.3161 deg; Surface: Brick - Aged Natural; Element ID: Object_413; Hotlink and Element ID: Object_413; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_413; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_413; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_413 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_413_; 109.AMB.CodiTipus: Object_413; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.160386 m; Area: 0.360344 m2; Height: 0.405923 m; Volume (Net): 0.0133998 m3; Width: 2.24673 m; Elevation to Project Zero: 3.74122 m; Elevation to 1st Reference Level: 3.74122 m; Elevation to 2nd Reference Level: 3.74122 m; Elevation to Sea Level: 13.0812 m; Elevation to Linked/Home Story: 3.74122 m; Home Offset: 3.74122 m; Surface Area: 0.721084 m2; Top Elevation To First Reference Level: 3.97036 m; Top Elevation To Home Story: 3.97036 m; Top Elevation To Project Zero: 3.97036 m; Top Elevation To Sea Level: 13.3104 m; Top Elevation To Second Reference Level: 3.97036 m; Bottom Elevation To First Reference Level: 3.74122 m; Bottom Elevation To Home Story: 3.74122 m; Bottom Elevation To Project Zero: 3.74122 m; Bottom Elevation To Sea Level: 13.0812 m; Bottom Elevation To Second Reference Level: 3.74122 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.0812 m; Top Surface Area (Net): 0.360344 m2; Bottom Surface Area (Net): 0.721084 m2
AC_Equantity_Rhino_Object_413 - Dimension 1: 0.160386 m; Dimension 2: 2.24673 m; Height: 0.405923 m; Bottom Level: 0 m; Top Level: 0.405923 m
5 AMB.Geometria - 502.AMB.Amplada: 2.24673 m; 503.AMB.Altura: 0.405923 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0133998 m3; Component, Component Volume (Gross): 0.0133998 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_415, Object_415
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.632 deg; Surface: Brick - Aged Natural; Element ID: Object_415; Hotlink and Element ID: Object_415; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_415; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_415; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_415 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 7; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_415_; 109.AMB.CodiTipus: Object_415; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_415 - Dimension 1: 0.0919285 m; Dimension 2: 2.11614 m; Height: 3.84526 m; Bottom Level: -2.82885e-13 m; Top Level: 3.84526 m
5 AMB.Geometria - 502.AMB.Amplada: 2.11614 m; 503.AMB.Altura: 3.84526 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.103949 m3; Component, Component Volume (Gross): 0.103949 m3
ArchiCADQuantities - Length (A): 0.0919285 m; Area: 0.194534 m2; Height: 3.84526 m; Volume (Net): 0.103949 m3; Width: 2.11614 m; Elevation to Project Zero: 0.109876 m; Elevation to 1st Reference Level: 0.109876 m; Elevation to 2nd Reference Level: 0.109876 m; Elevation to Sea Level: 9.44988 m; Elevation to Linked/Home Story: 0.109876 m; Home Offset: 0.109876 m; Surface Area: 4.62048 m2; Top Elevation To First Reference Level: 3.7779 m; Top Elevation To Home Story: 3.7779 m; Top Elevation To Project Zero: 3.7779 m; Top Elevation To Sea Level: 13.1179 m; Top Elevation To Second Reference Level: 3.7779 m; Bottom Elevation To First Reference Level: 0.109876 m; Bottom Elevation To Home Story: 0.109876 m; Bottom Elevation To Project Zero: 0.109876 m; Bottom Elevation To Sea Level: 9.44988 m; Bottom Elevation To Second Reference Level: 0.109876 m; Survey Coordinate X: 426568 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 9.44988 m; Top Surface Area (Net): 0.194534 m2; Bottom Surface Area (Net): 4.62048 m2

# IfcBuildingElementProxy: Rhino_Object_417, Object_417
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.6339 deg; Surface: Brick - Aged Natural; Element ID: Object_417; Hotlink and Element ID: Object_417; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_417; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_417; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_417 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 7; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_417_; 109.AMB.CodiTipus: Object_417; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
