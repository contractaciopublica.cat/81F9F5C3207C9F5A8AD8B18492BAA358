Properties of the parts of a building model (IFC2X3), part 85 of 99

# IfcBuildingElementProxy: Rhino_Object_563, Object_563
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Component Quantities - Component, Component Volume (Net): 0.0130788 m3; Component, Component Volume (Gross): 0.0130788 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0810007 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_564, Object_564
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_564; Hotlink and Element ID: Object_564; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_564; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_564; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_564 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_564_; 109.AMB.CodiTipus: Object_564; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.348867 m; Area: 0.0282585 m2; Height: 1.11675 m; Volume (Net): 0.0130788 m3; Width: 0.0810007 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.605393 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426548 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.0282585 m2; Bottom Surface Area (Net): 0.605393 m2
AC_Equantity_Rhino_Object_564 - Dimension 1: 0.348867 m; Dimension 2: 0.0810007 m; Height: 1.11675 m; Bottom Level: -1.86073e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0810007 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0130788 m3; Component, Component Volume (Gross): 0.0130788 m3

# IfcBuildingElementProxy: Rhino_Object_565, Object_565
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_565; Hotlink and Element ID: Object_565; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_565; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_565; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_565 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_565_; 109.AMB.CodiTipus: Object_565; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.348867 m; Area: 0.0282585 m2; Height: 1.11675 m; Volume (Net): 0.0130788 m3; Width: 0.0810007 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.605393 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426546 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.0282585 m2; Bottom Surface Area (Net): 0.605393 m2
AC_Equantity_Rhino_Object_565 - Dimension 1: 0.348867 m; Dimension 2: 0.0810007 m; Height: 1.11675 m; Bottom Level: -1.85985e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0810007 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0130788 m3; Component, Component Volume (Gross): 0.0130788 m3

# IfcBuildingElementProxy: Rhino_Object_566, Object_566
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_566; Hotlink and Element ID: Object_566; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_566; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_566; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_566 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_566_; 109.AMB.CodiTipus: Object_566; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.348867 m; Area: 0.0282585 m2; Height: 1.11675 m; Volume (Net): 0.0130788 m3; Width: 0.0810007 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.605393 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.0282585 m2; Bottom Surface Area (Net): 0.605393 m2
AC_Equantity_Rhino_Object_566 - Dimension 1: 0.348867 m; Dimension 2: 0.0810007 m; Height: 1.11675 m; Bottom Level: -1.86073e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0810007 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0130788 m3; Component, Component Volume (Gross): 0.0130788 m3

# IfcBuildingElementProxy: Rhino_Object_567, Object_567
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_567; Hotlink and Element ID: Object_567; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_567; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_567; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_567 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_567_; 109.AMB.CodiTipus: Object_567; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.015273 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.693152 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693152 m2
AC_Equantity_Rhino_Object_567 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: 0 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.015273 m3; Component, Component Volume (Gross): 0.015273 m3

# IfcBuildingElementProxy: Rhino_Object_568, Object_568
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_568; Hotlink and Element ID: Object_568; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_568; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_568; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_568 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_568_; 109.AMB.CodiTipus: Object_568; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.330848 m; Area: 0.0264343 m2; Height: 1.11675 m; Volume (Net): 0.0113577 m3; Width: 0.0798986 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.542875 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.0264343 m2; Bottom Surface Area (Net): 0.542875 m2
AC_Equantity_Rhino_Object_568 - Dimension 1: 0.330848 m; Dimension 2: 0.0798986 m; Height: 1.11675 m; Bottom Level: -4.03855e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0798986 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0113577 m3; Component, Component Volume (Gross): 0.0113577 m3

# IfcBuildingElementProxy: Rhino_Object_569, Object_569
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_569 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_569_; 109.AMB.CodiTipus: Object_569; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.330848 m; Area: 0.0264343 m2; Height: 1.11675 m; Volume (Net): 0.0113535 m3; Width: 0.0798986 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.5429 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.0264343 m2; Bottom Surface Area (Net): 0.5429 m2
AC_Equantity_Rhino_Object_569 - Dimension 1: 0.330848 m; Dimension 2: 0.0798986 m; Height: 1.11675 m; Bottom Level: -1.99396e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0798986 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_569; Hotlink and Element ID: Object_569; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_569; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_569; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.0113535 m3; Component, Component Volume (Gross): 0.0113535 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_57, Object_57
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_57 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_57_; 109.AMB.CodiTipus: Object_57; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_57 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_57; Hotlink and Element ID: Object_57; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_57; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_57; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_570, Object_570
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_570; Hotlink and Element ID: Object_570; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_570; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_570; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_570 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_570_; 109.AMB.CodiTipus: Object_570; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152724 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.693129 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693129 m2
AC_Equantity_Rhino_Object_570 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -1.811e-12 m; Top Level: 1.11675 m
Component Quantities - Component, Component Volume (Net): 0.0152724 m3; Component, Component Volume (Gross): 0.0152724 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_571, Object_571
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_571; Hotlink and Element ID: Object_571; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_571; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_571; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_571 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_571_; 109.AMB.CodiTipus: Object_571; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152724 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.693129 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693129 m2
AC_Equantity_Rhino_Object_571 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -1.81188e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0152724 m3; Component, Component Volume (Gross): 0.0152724 m3

# IfcBuildingElementProxy: Rhino_Object_572, Object_572
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_572; Hotlink and Element ID: Object_572; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_572; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_572; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_572 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_572_; 109.AMB.CodiTipus: Object_572; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152724 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.693129 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426547 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693129 m2
AC_Equantity_Rhino_Object_572 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -1.81188e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0152724 m3; Component, Component Volume (Gross): 0.0152724 m3

# IfcBuildingElementProxy: Rhino_Object_573, Object_573
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_573; Hotlink and Element ID: Object_573; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_573; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_573; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_573 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_573_; 109.AMB.CodiTipus: Object_573; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152724 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.693129 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426545 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693129 m2
AC_Equantity_Rhino_Object_573 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -1.811e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0152724 m3; Component, Component Volume (Gross): 0.0152724 m3

# IfcBuildingElementProxy: Rhino_Object_574, Object_574
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_574; Hotlink and Element ID: Object_574; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_574; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_574; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_574 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.015273 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.693152 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426556 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693152 m2
AC_Equantity_Rhino_Object_574 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -6.1311e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.015273 m3; Component, Component Volume (Gross): 0.015273 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_574_; 109.AMB.CodiTipus: Object_574; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_575, Object_575
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_575; Hotlink and Element ID: Object_575; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_575; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_575; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_575 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_575_; 109.AMB.CodiTipus: Object_575; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.015273 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.693152 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693152 m2
AC_Equantity_Rhino_Object_575 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -6.1311e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.015273 m3; Component, Component Volume (Gross): 0.015273 m3

# IfcBuildingElementProxy: Rhino_Object_576, Object_576
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_576; Hotlink and Element ID: Object_576; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_576; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_576; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_576 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_576_; 109.AMB.CodiTipus: Object_576; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152722 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.69311 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426554 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.69311 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_576 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -4.3201e-12 m; Top Level: 1.11675 m
Component Quantities - Component, Component Volume (Net): 0.0152722 m3; Component, Component Volume (Gross): 0.0152722 m3

# IfcBuildingElementProxy: Rhino_Object_577, Object_577
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_577; Hotlink and Element ID: Object_577; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_577; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_577; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_577 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_577_; 109.AMB.CodiTipus: Object_577; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152722 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.69311 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.69311 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_577 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -4.3201e-12 m; Top Level: 1.11675 m
Component Quantities - Component, Component Volume (Net): 0.0152722 m3; Component, Component Volume (Gross): 0.0152722 m3

# IfcBuildingElementProxy: Rhino_Object_578, Object_578
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
