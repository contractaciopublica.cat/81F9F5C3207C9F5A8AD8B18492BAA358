Properties of the parts of a building model (IFC2X3), part 13 of 99

# IfcBuildingElementProxy: Gypsum Plasterboard 30 (373)
Name | Reference Line Location | Inside Face Surface = Edge Surface | Outside Face Surface | Element ID = Hotlink and Element ID = Parent ID | Colliding Zones | Surfaces (All) | Number of Openings | 107.AMB.NomTipus | 109.AMB.CodiTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_107.NomTipus | Gypsum Plasterboard, Embodied Carbon | Gypsum Plasterboard, Embodied Energy (MJ) | Number of Windows | Maximum Height of the Wall (m) | Minimum Height of the Wall (m) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Surface Area of the Wall Inside Face (Conditional) (m2) | Length of the Wall Outside Face (Conditional) (m) | Surface Area of the Wall Outside Face (Conditional) (m2) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = Gypsum Plasterboard, Rectangular Component Height (m) | Volume (Net) (m3) = Gypsum Plasterboard, Component Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | 3D Length (m) | Volume (Conditional) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | 503.AMB.Altura (m) | Gypsum Plasterboard, Mass (kg) | Gypsum Plasterboard, Projected Component Area (Net) (m2) | Gypsum Plasterboard, Projected Component Area (Gross) (m2) | Gypsum Plasterboard, Component Cross Section Area (m2) | Gypsum Plasterboard, Component Volume (Gross) (m3)
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 40.548 (kgCO₂) | 701.793 | 0 | 2.60008 | 2.60008 | 0 | 0 | 1.481 | 3.85071 | 3.85071 | 0 | 1.481 | 1.481 | 3.85071 | 1.481 | 3.85071 | 3.85071 | 3.85071 | 1.481 | 1.481 | 0.04443 | 2.60008 | 0.115521 | 4.31425 | 13.6543 | 1.481 | 0.115521 | 0.115521 | 3.022 | 6.91433 | 16.2543 | 4.31425 | 13.6543 | 0.244865 | 2.60008 | 103.969 | 3.85071 | 3.85071 | 0.0780023 | 0.115521
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 25.0085 (kgCO₂) | 432.84 | 0 | 1.81674 | 1.44559 | 0 | 0 | 1.456 | 2.37497 | 2.37499 | 0 | 1.456 | 1.456 | 2.37497 | 1.456 | 2.37499 | 2.37497 | 2.37499 | 1.456 | 1.456 | 0.04368 | 2.6 | 0.0712494 | 2.872 | 12.212 | 1.456 | 0.0712494 | 0.0712494 | 2.972 | 4.68874 | 14.0287 | 2.872 | 12.212 | 0.186627 | 2.44 | 64.1244 | 2.37499 | 2.37499 | 0.078 | 0.0712494
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 17.1447 (kgCO₂) | 296.736 | 0 | 2.6 | 0 | 0 | 0 | 0.626222 | 1.62801 | 1.62834 | 0 | 0.656287 | 0.626159 | 1.62801 | 0.626286 | 1.62834 | 1.70601 | 1.70635 | 0.626159 | 0.626286 | 0.0187867 | 2.6 | 0.0488454 | 0.27 | 9.61 | 0.626286 | 0.0488454 | 0.0511854 | 1.31245 | 2.87 | 12.21 | 0.27 | 9.61 | 0.115573 | 2.44 | 43.9608 | 1.62834 | 1.62834 | 0.078 | 0.0488454
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_140 | 7.61067 (kgCO₂) | 131.723 | 0 | 2.598 | 2.598 | 0 | 0 | 0.278199 | 0.722761 | 0.722761 | 0 | 0.278199 | 0.278199 | 0.722761 | 0.278199 | 0.722761 | 0.722761 | 0.722761 | 0.278199 | 0.278199 | 0.00834596 | 2.598 | 0.0216828 | 1.71425 | 11.0543 | 0.278199 | 0.0216828 | 0.0216828 | 0.616398 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.172572 | 2.598 | 19.5145 | 0.722761 | 0.722761 | 0.07794 | 0.0216828
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T1_Extradossat_190 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 7.61067 (kgCO₂) | 131.723 | 0 | 2.598 | 2.598 | 0 | 0 | 0.278199 | 0.722761 | 0.722761 | 0 | 0.278199 | 0.278199 | 0.722761 | 0.278199 | 0.722761 | 0.722761 | 0.722761 | 0.278199 | 0.278199 | 0.00834596 | 2.598 | 0.0216828 | 1.71425 | 11.0543 | 0.278199 | 0.0216828 | 0.0216828 | 0.616398 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.172572 | 2.598 | 19.5145 | 0.722761 | 0.722761 | 0.07794 | 0.0216828
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T1_Extradossat_190 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 16.698 (kgCO₂) | 289.004 | 0 | 2.598 | 0 | 0 | 0 | 0.625375 | 1.5856 | 1.58591 | 0 | 0.640437 | 0.610314 | 1.5856 | 0.640437 | 1.58591 | 1.66354 | 1.66385 | 0.610314 | 0.640437 | 0.0183113 | 2.598 | 0.0475726 | 1.71425 | 11.0543 | 0.610436 | 0.0475726 | 0.0499109 | 1.32326 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.114563 | 2.598 | 42.8154 | 1.58591 | 1.58591 | 0.07794 | 0.0475726
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 40.2382 (kgCO₂) | 696.43 | 0 | 2.60008 | 0 | 0 | 0 | 1.49972 | 3.82113 | 3.82145 | 0 | 1.49972 | 1.49972 | 3.82113 | 1.49972 | 3.82145 | 3.89908 | 3.89939 | 1.49972 | 1.49972 | 0.0449917 | 2.60008 | 0.114639 | 4.31425 | 13.6543 | 1.49972 | 0.114639 | 0.116977 | 3.05945 | 6.91433 | 16.2543 | 4.31425 | 13.6543 | 0.167084 | 2.60008 | 103.175 | 3.82145 | 3.82145 | 0.0780023 | 0.114639
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral; Sala de reunions | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 5.3491 (kgCO₂) | 92.5805 | 0 | 0.398128 | 0 | 0 | 0 | 1.27594 | 0.507986 | 0.507986 | 0 | 1.27594 | 1.27594 | 0.507986 | 1.27594 | 0.507986 | 0.811495 | 0.811495 | 1.27594 | 1.27594 | 0.0382781 | 0.636 | 0.0152396 | 4.31625 | 13.6563 | 1.27594 | 0.0152396 | 0.0243448 | 2.61187 | 4.71438 | 14.0544 | 4.31625 | 13.6563 | 0.0502219 | 0.636 | 13.7156 | 0.507986 | 0.729835 | 0.01908 | 0.0218951
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 5.82317 (kgCO₂) | 100.786 | 0 | 0.398128 | 0 | 0 | 0 | 1.31902 | 0.553007 | 0.553007 | 0 | 1.31902 | 1.31902 | 0.553007 | 1.31902 | 0.553007 | 0.902495 | 0.902495 | 1.31902 | 1.31902 | 0.0416705 | 0.636 | 0.0165902 | 4.31625 | 13.6563 | 1.38902 | 0.0165902 | 0.0270748 | 2.69803 | 4.71438 | 14.0544 | 4.31625 | 13.6563 | 0.0536144 | 0.636 | 14.9312 | 0.553007 | 0.794518 | 0.01908 | 0.0238355
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 5.91113 (kgCO₂) | 102.308 | 0 | 0.398128 | 0 | 0 | 0 | 1.41 | 0.561361 | 0.561361 | 0 | 1.41 | 1.41 | 0.561361 | 1.41 | 0.561361 | 0.89676 | 0.89676 | 1.41 | 1.41 | 0.0423 | 0.636 | 0.0168408 | 4.31625 | 13.6563 | 1.41 | 0.0168408 | 0.0269028 | 2.88 | 4.71438 | 14.0544 | 4.31625 | 13.6563 | 0.0542439 | 0.636 | 15.1568 | 0.561361 | 0.80652 | 0.01908 | 0.0241956
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 31.2602 (kgCO₂) | 541.043 | 0 | 1.98335 | 1.97489 | 0 | 0 | 1.5 | 2.96295 | 2.97442 | 0 | 1.5 | 1.5 | 2.96295 | 1.5 | 2.97442 | 2.96295 | 2.97442 | 1.5 | 1.5 | 0.045 | 2.6 | 0.0890605 | 2.872 | 12.212 | 1.5 | 0.0890605 | 0.0890605 | 3.06 | 4.85535 | 14.1954 | 2.872 | 12.212 | 0.210186 | 2.44 | 80.1544 | 2.97442 | 2.97442 | 0.078 | 0.0890605
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 40.4041 (kgCO₂) | 699.303 | 0 | 2.6 | 2.6 | 0 | 0 | 1.47579 | 3.83705 | 3.83705 | 0 | 1.47579 | 1.47579 | 3.83705 | 1.47579 | 3.83705 | 3.83705 | 3.83705 | 1.47579 | 1.47579 | 0.0442737 | 2.6 | 0.115112 | 0.27 | 9.61 | 1.47579 | 0.115112 | 0.115112 | 3.01158 | 2.87 | 12.21 | 0.27 | 9.61 | 0.244547 | 2.44 | 103.6 | 3.83705 | 3.83705 | 0.078 | 0.115112
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 36.8877 (kgCO₂) | 638.442 | 0 | 2.6 | 0 | 0 | 0 | 1.34735 | 3.50069 | 3.50553 | 0 | 1.37834 | 1.34642 | 3.50069 | 1.34828 | 3.50553 | 3.57884 | 3.58368 | 1.34642 | 1.34828 | 0.0404205 | 2.6 | 0.105093 | 0.27 | 9.61 | 1.34828 | 0.105093 | 0.107438 | 2.75476 | 2.87 | 12.21 | 0.27 | 9.61 | 0.158841 | 2.44 | 94.584 | 3.50553 | 3.50553 | 0.078 | 0.105093
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 41.067 (kgCO₂) | 710.775 | 0 | 2.6 | 2.6 | 0 | 0 | 1.5 | 3.9 | 3.9 | 0 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.117 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.246 | 2.44 | 105.3 | 3.9 | 3.9 | 0.078 | 0.117
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 27.9487 (kgCO₂) | 483.727 | 0 | 2.00851 | 2.00085 | 0 | 0 | 1.324 | 2.65926 | 2.64913 | 0 | 1.324 | 1.324 | 2.65926 | 1.324 | 2.64913 | 2.65926 | 2.64913 | 1.324 | 1.324 | 0.03972 | 2.6 | 0.0796259 | 2.872 | 12.212 | 1.324 | 0.0796259 | 0.0796259 | 2.708 | 4.88051 | 14.2205 | 2.872 | 12.212 | 0.200991 | 2.44 | 71.6633 | 2.65926 | 2.65926 | 0.078 | 0.0796259
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 31.6636 (kgCO₂) | 548.024 | 0 | 2.0085 | 2.00083 | 0 | 0 | 1.5 | 3.01273 | 3.00126 | 0 | 1.5 | 1.5 | 3.01273 | 1.5 | 3.00126 | 3.01273 | 3.00126 | 1.5 | 1.5 | 0.045 | 2.6 | 0.0902097 | 2.872 | 12.212 | 1.5 | 0.0902097 | 0.0902097 | 3.06 | 4.8805 | 14.2205 | 2.872 | 12.212 | 0.211719 | 2.44 | 81.1888 | 3.01273 | 3.01273 | 0.078 | 0.0902097
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 31.6633 (kgCO₂) | 548.019 | 0 | 2.00848 | 2.00081 | 0 | 0 | 1.5 | 3.0127 | 3.00123 | 0 | 1.5 | 1.5 | 3.0127 | 1.5 | 3.00123 | 3.0127 | 3.00123 | 1.5 | 1.5 | 0.045 | 2.6 | 0.090209 | 2.872 | 12.212 | 1.5 | 0.090209 | 0.090209 | 3.06 | 4.88048 | 14.2205 | 2.872 | 12.212 | 0.211718 | 2.44 | 81.1881 | 3.0127 | 3.0127 | 0.078 | 0.090209
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 40.8236 (kgCO₂) | 706.562 | 0 | 2.6 | 0 | 0 | 0 | 1.49161 | 3.87493 | 3.87819 | 0 | 1.49161 | 1.49161 | 3.87493 | 1.49161 | 3.87819 | 3.87819 | 3.87819 | 1.49161 | 1.49161 | 0.0447483 | 2.6 | 0.116306 | 0.27 | 9.61 | 1.49161 | 0.116306 | 0.116346 | 3.04322 | 2.87 | 12.21 | 0.27 | 9.61 | 0.243509 | 2.44 | 104.676 | 3.87819 | 3.87819 | 0.078 | 0.116306
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 31.7031 (kgCO₂) | 548.708 | 0 | 2.01139 | 2.00293 | 0 | 0 | 1.5 | 3.01648 | 3.00501 | 0 | 1.5 | 1.5 | 3.01648 | 1.5 | 3.00501 | 3.01648 | 3.00501 | 1.5 | 1.5 | 0.045 | 2.6 | 0.0903222 | 2.872 | 12.212 | 1.5 | 0.0903222 | 0.0903222 | 3.06 | 4.88339 | 14.2234 | 2.872 | 12.212 | 0.211869 | 2.44 | 81.29 | 3.01648 | 3.01648 | 0.078 | 0.0903222
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 7.48972 (kgCO₂) | 129.63 | 0 | 2.598 | 2.598 | 0 | 0 | 0.273778 | 0.711275 | 0.711275 | 0 | 0.273778 | 0.273778 | 0.711275 | 0.273778 | 0.711275 | 0.711275 | 0.711275 | 0.273778 | 0.273778 | 0.00821333 | 2.598 | 0.0213382 | 1.71425 | 11.0543 | 0.273778 | 0.0213382 | 0.0213382 | 0.607556 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.172307 | 2.598 | 19.2044 | 0.711275 | 0.711275 | 0.07794 | 0.0213382
F6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 28.0122 (kgCO₂) | 484.827 | 0 | 2.6 | 0 | -5.06677e-09 | 0 | 1.04809 | 2.71198 | 2.60848 | -1.59484e-09 | 1.05311 | 1.04307 | 2.71198 | 1.05311 | 2.60848 | 2.84159 | 2.73808 | 1.04307 | 1.05311 | 0.030695 | 2.6 | 0.079807 | 0.27 | 9.61 | 1.04307 | 0.079807 | 0.083695 | 2.15781 | 2.87 | 12.21 | 0.27 | 9.61 | 0.13939 | 2.44 | 71.8263 | 2.71198 | 2.71198 | 0.078 | 0.079807
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia; Office | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 98.0723 (kgCO₂) | 1697.41 | 0 | 2.13024 | 1.38755 | 0 | 0 | 5.3659 | 9.31366 | 9.31357 | 0 | 5.3659 | 5.3659 | 9.31366 | 5.3659 | 9.31357 | 11.4306 | 11.4306 | 5.3659 | 5.3659 | 0.160977 | 2.13024 | 0.279408 | 2.871 | 12.211 | 5.3659 | 0.279408 | 0.342919 | 10.7918 | 5.00124 | 14.3412 | 2.871 | 12.211 | 0.266891 | 2.44 | 251.468 | 9.31379 | 11.4306 | 0.0639071 | 0.342919

# IfcBuildingElementProxy: Gypsum Plasterboard 44 (8)
In: planta coberta
Classification: 30.20.10.20 Cobertes Pre-fabricades (GuBIMclass CA); Roof (ARCHICAD Classification); Material: Gypsum Plasterboard
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Geometry Method: Single-plane; Pitch: -14.3 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: Te1; Hotlink and Element ID: Te1; Layer: 00_CLT; Building Material / Composite / Profile / Fill: Gypsum Plasterboard; Building Material: Gypsum Plasterboard; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Roof; Structure Type: Basic; Parent ID: Te1; Building Materials (All): Gypsum Plasterboard; Surfaces (All): Wood - Pine Grained Horizontal blank; Cover Fill: Roof Tile 01; Edge Surface: Wood - Pine Grained Horizontal blank; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10.20 Cobertes Pre-fabricades; 104.AMB.ClassificacioCodi: 30.20.10.20; 105.AMB.ClassificacioDescripcio: Cobertes Pre-fabricades; 107.AMB.NomTipus: Te1_SostreSuspèsInclinat; 109.AMB.CodiTipus: Te1; 111.AMB.DescripcioTipus: Sostre suspès inclinat amb contraxapat de pi; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: SostreSuspèsInclinat
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.0436057 m; Vertical Thickness: 0.045 m; Height: 0.0436057 m
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Component Quantities - Gypsum Plasterboard, Component Thickness: 0.0436057 m
5 AMB.Geometria - 503.AMB.Altura: 0.0436057 m; 504.AMB.Gruix: 0.0436057 m; 506.AMB.Profunditat: 0 m
Name | Colliding Zones | Gypsum Plasterboard, Embodied Carbon | Gypsum Plasterboard, Embodied Energy (MJ) | Surface Area of the Roof Bottom (Gross) (m2) = Surface Area of the Roof Top (Gross) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Surface Area of the Roof Bottom (Net) (m2) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Gypsum Plasterboard, Mass (kg) | Gypsum Plasterboard, Projected Component Area (Net) (m2) | Gypsum Plasterboard, Projected Component Area (Gross) (m2) | Gypsum Plasterboard, Component Volume (Net) (m3) | Gypsum Plasterboard, Component Volume (Gross) (m3)
Te1 | Lavabo; Nau Santa Eulàlia; Office; Rack | 82.2301 (kgCO₂) | 1423.21 | 5.37255 | 0.548833 | 5.37255 | 3.96545 | 13.3054 | -0.534553 | 4.01045 | -0.489553 | 13.3504 | 3.69516 | -0.804839 | 13.0352 | 210.846 | 5.43177 | 5.43177 | 0.234274 | 0.234274
Te1 | Lavabo; Nau Santa Eulàlia; Office; Rack | 70.912 (kgCO₂) | 1227.32 | 4.63308 | 0.525027 | 4.63308 | 3.96545 | 13.3054 | -0.534553 | 4.01045 | -0.489553 | 13.3504 | 3.72092 | -0.779082 | 13.0609 | 181.826 | 4.69244 | 4.69244 | 0.202029 | 0.202029
Te1 | Lavabo; Nau Santa Eulàlia; Neteja | 61.5418 (kgCO₂) | 1065.15 | 4.02087 | 0.471892 | 4.02087 | 3.965 | 13.305 | -0.535 | 4.01 | -0.49 | 13.35 | 3.72067 | -0.779335 | 13.0607 | 157.8 | 4.07373 | 4.07373 | 0.175333 | 0.175333
Te1 | Espai d'atenció; Lavabo; Nau Santa Eulàlia; Neteja | 73.8794 (kgCO₂) | 1278.68 | 4.82695 | 0.504023 | 4.82695 | 3.965 | 13.305 | -0.535 | 4.01 | -0.49 | 13.35 | 3.69471 | -0.805286 | 13.0347 | 189.434 | 4.88074 | 4.88074 | 0.210483 | 0.210483
Te1 | Lavabo; Nau Santa Eulàlia; Neteja | 60.9844 (kgCO₂) | 1055.5 | 4.02087 | 0.471892 | 3.98445 | 3.6 | 12.94 | -0.9 | 3.645 | -0.855 | 12.985 | 3.35567 | -1.14433 | 12.6957 | 156.37 | 4.03714 | 4.07373 | 0.173745 | 0.175333
Te1 | Lavabo; Nau Santa Eulàlia; Office; Rack | 68.3223 (kgCO₂) | 1182.5 | 4.46388 | 0.509622 | 4.46388 | 3.59145 | 12.9314 | -0.908553 | 3.63645 | -0.863553 | 12.9764 | 3.34692 | -1.15308 | 12.6869 | 175.185 | 4.52134 | 4.52134 | 0.194651 | 0.194651
Te1 | Lavabo; Nau Santa Eulàlia; Office; Rack | 69.769 (kgCO₂) | 1207.54 | 4.5584 | 0.524778 | 4.5584 | 3.59145 | 12.9314 | -0.908553 | 3.63645 | -0.863553 | 12.9764 | 3.35685 | -1.14315 | 12.6968 | 178.895 | 4.61578 | 4.61578 | 0.198772 | 0.198772
Te1 | Espai d'atenció; Lavabo; Nau Santa Eulàlia; Neteja | 71.3532 (kgCO₂) | 1234.96 | 4.82684 | 0.504009 | 4.6619 | 3.6 | 12.94 | -0.9 | 3.645 | -0.855 | 12.985 | 3.32971 | -1.17029 | 12.6697 | 182.957 | 4.71528 | 4.88063 | 0.203286 | 0.210478

# IfcBuildingElementProxy: HEB 140 140 x 140 (11)
Material: Steel - Structural
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
ArchiCADProperties - Building Material / Composite / Profile / Fill: HEB 140; Complex Profile: HEB 140; Locked: no; Structure Type: Complex Profile; Profile Category: HEB 140; Building Materials (All): Steel - Structural; Surfaces (All): Paint - Light Gray; Cover Fill: Background; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 20
Pset_BuildingElementProxyCommon - Status: NEW
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Si
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
Component Properties - Steel - Structural, Component Type: Core
ArchiCADQuantities - Number of Segments: 1
Name | In | Classification | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 109.AMB.CodiTipus = Element ID = Hotlink and Element ID = Parent ID | 115.AMB.Nivell = Home Story Name | Column Cross Section | Column Slant Angle (deg) | Layer | Colliding Zones | Home Story Number | Element Type | Absolute Top Link Story = Relative Top Link Story = Top Link Story | Slant Angle (deg) | 502.AMB.Amplada (m) = Width (m) = Cross Section Height at Top/End (perpendicular) (m) = Cross Section Height at Bottom/Start (perpendicular) (m) = Cross Section Width at Top/End (perpendicular) (m) = Cross Section Width at Bottom/Start (perpendicular) (m) = Cross Section Height at Top/End (cut) (m) = Cross Section Height at Bottom/Start (cut) (m) = Cross Section Width at Top/End (cut) (m) = Cross Section Width at Bottom/Start (cut) (m) | 503.AMB.Altura (m) = Height (m) | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | Steel - Structural, Mass (kg) | Steel - Structural, Component Cross Section Area (m2) | Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3) = Volume (Net) (m3) | Core Height / Diameter (m) = Core Width (m) | Volume of the Column Core (Net) (m3) = Volume of the Column Core (Gross) (m3) | Surface Area of the Column Core (Gross, without Top/Bottom) (m2) = Surface Area of the Column Core (Net, without Top/Bottom) (m2) | Surface Area of the Column Core Top (Gross) (m2) = Surface Area of the Column Core Bottom (Gross) (m2) = Surface Area of the Column Core Bottom (Net) (m2) = Surface Area of the Column Core Top (Net) (m2) = Top Surface Area (Gross) (m2) | Surface Area of the Column Veneer (Gross, without Top/Bottom) (m2) = Surface Area of the Column Veneer Top (Gross) (m2) = Surface Area of the Column Veneer Bottom (Gross) (m2) = Volume of the Column Veneer (Gross) (m3) = Surface Area of the Column Veneer Bottom (Net) (m2) = Surface Area of the Column Veneer (Net) (m2) = Surface Area of the Column Veneer Top (Net) (m2) = Volume of the Column Veneer (Net) (m3) | Maximum Height of the Column (m) = Minimum Height of the Column (m) | Perimeter of Column Profile (bottom) (m) | Area (m2) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Top Offset (m) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2)
2 x CRE - 008 | planta baixa | 20.20.10.10 Pilars (GuBIMclass CA) | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | planta baixa | Profiled | 90 | 00_ACERO PILARES | Nau Lateral | 0 | Column | Not Linked | 90 | 0.140002 | 6.64778 | 292.66 (kgCO₂) | 4425.17 | 176.301 | 0.00340005 | 0.0226027 | 0.140002 | 0.0226027 | 5.51773 | 0.00340005 | 0 | 6.64778 | 1.5672 | 0.00340005 | 1.71425 | 11.0543 | 1.71425 | 1.44108 | 5.51773 | 6.64778 | 0.0226027 | 8.36203 | 8.36203 | 17.702 | 1.71425 | 1.71425 | 11.0543 | 0.00340005 | 0.00340005 | 0.00340005 | 5.51773
2 x CRE - 008 | planta baixa | 20.20.10.10 Pilars (GuBIMclass CA) | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | planta baixa | Profiled | 90 | 00_ACERO PILARES | Nau Lateral | 0 | Column | Not Linked | 90 | 0.140002 | 7.78372 | 342.669 (kgCO₂) | 5181.32 | 206.427 | 0.00340005 | 0.026465 | 0.140002 | 0.026465 | 6.46057 | 0.00340005 | 0 | 7.78372 | 1.5672 | 0.00340005 | 1.71425 | 11.0543 | 1.71425 | 1.44108 | 6.46057 | 7.78372 | 0.026465 | 9.49797 | 9.49797 | 18.838 | 1.71425 | 1.71425 | 11.0543 | 0.00340005 | 0.00340005 | 0.00340005 | 6.46057
2 x CRE - 008 | planta baixa | 20.20.10.10 Pilars (GuBIMclass CA) | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | planta baixa | Profiled | 90 | 00_ACERO PILARES | Nau Lateral | 0 | Column | Not Linked | 90 | 0.140002 | 6.36 | 279.991 (kgCO₂) | 4233.6 | 168.669 | 0.00340005 | 0.0216243 | 0.140002 | 0.0216243 | 5.27887 | 0.00340005 | 0 | 6.36 | 1.5672 | 0.00340005 | 1.71425 | 11.0543 | 1.71425 | 1.44108 | 5.27887 | 6.36 | 0.0216243 | 8.07425 | 8.07425 | 17.4143 | 1.71425 | 1.71425 | 11.0543 | 0.00340005 | 0.00340005 | 0.00340005 | 5.27887
CRE - 008 | planta baixa | 20.20.10.10 Pilars (GuBIMclass CA) | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | planta baixa | Profiled | 90 | 00_ACERO PILARES | Nau Lateral | 0 | Column | Not Linked | 90 | 0.140002 | 3.56 | 156.725 (kgCO₂) | 2369.75 | 94.4125 | 0.00340005 | 0.0121042 | 0.140002 | 0.0121042 | 2.95484 | 0.00340005 | 0 | 3.56 | 1.5672 | 0.00340005 | 1.71425 | 11.0543 | 1.71425 | 1.44108 | 2.95484 | 3.56 | 0.0121042 | 5.27425 | 5.27425 | 14.6143 | 1.71425 | 1.71425 | 11.0543 | 0.00340005 | 0.00340005 | 0.00340005 | 2.95484
BMR - 007 | planta coberta | 20.20.10.10 Pilars (GuBIMclass CA) | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | BMR - 007_ | BMR - 007 | planta coberta |  |  | 00_ACERO PILARES |  | 1 | Beam |  | 0 | 0.140001 | 0.140001 | 22.478 (kgCO₂) | 339.878 | 13.541 | 0.00340003 | 0.00173602 |  |  |  |  |  |  |  | 0.077201 | 5.20425 | 14.5443 | 0.704252 |  | 0.432004 | 0.56 | 0.00204002 | 5.27425 | 0.774253 | 14.6143 | 5.13425 | 0.634252 | 14.4743 | 0 | 0 | 0.152802 | 0.152802 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: 0 deg; Number of Openings: 0; ArchiCADQuantities - Surface Area of Both Beam Ends: 0 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.0496 m2; Length Left: 0.6 m; Length Right: 0.6 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.0496 m2; Volume (Conditional): 0.00173602 m3
BMR - 007 | planta coberta | 20.20.20.20 Jàsseres (GuBIMclass CA) | 20.20.20.20 Jàsseres | 20.20.20.20 | Jàsseres | BMR - 007_ | BMR - 007 | planta coberta |  |  | 00_ACERO VIGAS |  | 1 | Beam |  | 0 | 0.140001 | 0.140001 | 343.97 (kgCO₂) | 5201 | 207.211 | 0.00340003 | 0.0265655 |  |  |  |  |  |  |  | 1.09543 | 8.00425 | 17.3443 | 3.50425 |  | 6.52043 | 7.85841 | 0.0268041 | 8.07425 | 3.57425 | 17.4143 | 7.93425 | 3.43425 | 17.2743 | 0 | 0.00340003 | 2.14597 | 2.1516 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: 0 deg; Number of Openings: 0; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.00340003 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 1.09544 m2; Length Left: 7.8114 m; Length Right: 7.81152 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 1.09824 m2; Volume (Conditional): 0.0265655 m3
BMR - 007 | planta coberta | 20.20.20.20 Jàsseres (GuBIMclass CA) | 20.20.20.20 Jàsseres | 20.20.20.20 | Jàsseres | BMR - 007_ | BMR - 007 | planta coberta |  |  | 00 ACERO VIGA PLANTA |  | 1 | Beam |  | 0 | 0.140001 | 0.140001 | 339.778 (kgCO₂) | 5137.61 | 204.685 | 0.00340003 | 0.0262417 |  |  |  |  |  |  |  | 1.07991 | 5.20425 | 14.5443 | 0.704252 |  | 6.45294 | 7.85841 | 0.0268041 | 5.27425 | 0.774253 | 14.6143 | 5.13425 | 0.634252 | 14.4743 | 0 | 0.00340003 | 2.11425 | 2.11988 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: 0 deg; Number of Openings: 0; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.00340003 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 1.09544 m2; Length Left: 7.8114 m; Length Right: 7.81152 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 1.09824 m2; Volume (Conditional): 0.0262417 m3
BMR - 007 | planta coberta | 20.20.10.10 Pilars (GuBIMclass CA) | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | BMR - 007_ | BMR - 007 | planta coberta |  |  | 00_ACERO VIGAS |  | 1 | Beam |  | 0 | 0.140001 | 0.140001 | 18.2827 (kgCO₂) | 276.443 | 11.0137 | 0.00340003 | 0.00141201 |  |  |  |  |  |  |  | 0.0610005 | 8.00425 | 17.3443 | 3.50425 |  | 0.352202 | 0.439998 | 0.00204002 | 8.07425 | 3.57425 | 17.4143 | 7.93425 | 3.43425 | 17.2743 | 0 | 0 | 0.120401 | 0.120401 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: 0 deg; Number of Openings: 0; ArchiCADQuantities - Surface Area of Both Beam Ends: 0 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.0471999 m2; Length Left: 0.6 m; Length Right: 0.6 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.0471999 m2; Volume (Conditional): 0.00141201 m3

# IfcBuildingElementProxy: HEB 200 200 x 200 (3)
In: planta coberta
Classification: 30.20.10 Cobertes (GuBIMclass CA); Material: Steel - Structural
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 107.AMB.NomTipus: Cu5_Coberta R60; 109.AMB.CodiTipus: Cu5; 111.AMB.DescripcioTipus: Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
ArchiCADProperties - Beam Cross Section: Profiled; End Surface: Paint - Anthracite; Beam Slant Angle: -17.4808 deg; Extrusion Surface: Paint - Anthracite; Element ID: Cu5; Hotlink and Element ID: Cu5; Layer: 00_ACERO VIGAS; Building Material / Composite / Profile / Fill: HEB 200; Complex Profile: HEB 200; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Beam; Structure Type: Complex Profile; Profile Category: HEB 200; Parent ID: Cu5; Building Materials (All): Steel - Structural; Surfaces (All): Paint - Anthracite; Cover Fill: Background; Slant Angle: -17.4808 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Coberta R60
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Steel - Structural, Component Type: Core
ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0105649 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Offset: 0 m; Height: 0.2 m; Width: 0.2 m; Elevation to Project Zero: 10.2307 m; Elevation to 1st Reference Level: 10.2307 m; Elevation to 2nd Reference Level: 10.2307 m; Elevation to Sea Level: 19.5707 m; Elevation to Linked/Home Story: 5.73066 m; Home Offset: 5.73066 m; Top Elevation To First Reference Level: 10.2307 m; Top Elevation To Home Story: 5.73066 m; Top Elevation To Project Zero: 10.2307 m; Top Elevation To Sea Level: 19.5707 m; Top Elevation To Second Reference Level: 10.2307 m; Cross Section Height at Top/End (perpendicular): 0.2 m; Cross Section Height at Bottom/Start (perpendicular): 0.2 m; Cross Section Width at Top/End (perpendicular): 0.2 m; Cross Section Width at Bottom/Start (perpendicular): 0.2 m; Cross Section Height at Top/End (cut): 0.209684 m; Cross Section Height at Bottom/Start (cut): 0.209684 m; Cross Section Width at Top/End (cut): 0.2 m; Cross Section Width at Bottom/Start (cut): 0.2 m; Cross Section Area at Bottom/Start: 0.00528243 m2; Cross Section Area at Top/End: 0.00528243 m2; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.2 m; 503.AMB.Altura: 0.2 m; 506.AMB.Profunditat: 0 m
Component Quantities - Steel - Structural, Component Cross Section Area: 0.00503848 m2
Name | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | Surface Area of the Beam Left Side (Net) (m2) = Surface Area of the Beam Right Side (Net) (m2) | Length Left (m) = Length Right (m) | Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Volume (Gross) (m3) = Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3) | Surface Area (m2) | 3D Length (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Top Surface Area (Net) (m2) = Bottom Surface Area (Net) (m2) | Steel - Structural, Mass (kg)
Cu5 | 568.426 (kgCO₂) | 8594.88 | 1.74262 | 8.71309 | 1.66214 | 0.0439007 | 10.3582 | 8.77607 | 7.40369 | 2.90369 | 16.7437 | 3.43121 | 342.426
2 x Cu5 | 567.695 (kgCO₂) | 8583.83 | 1.74038 | 8.70188 | 1.66 | 0.0438442 | 10.3449 | 8.76487 | 7.40706 | 2.90706 | 16.7471 | 3.4268 | 341.985

# IfcBuildingElementProxy: IPE 120 64 x 120 (3)
In: planta baixa
Classification: 20.20.20.40 Biguetes (GuBIMclass CA); Material: Steel - Structural
ArchiCADProperties - Beam Cross Section: Profiled; End Surface: Paint - Anthracite; Beam Slant Angle: 0 deg; Extrusion Surface: Paint - Anthracite; Element ID: BMR - 007; Hotlink and Element ID: BMR - 007; Layer: 00_ACERO VIGAS; Building Material / Composite / Profile / Fill: IPE 120; Complex Profile: IPE 120; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Complex Profile; Profile Category: IPE 120; Parent ID: BMR - 007; Building Materials (All): Steel - Structural; Surfaces (All): Paint - Anthracite; Paint - Light Gray; Cover Fill: Background; Slant Angle: 0 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 20.20.20.40 Biguetes; 104.AMB.ClassificacioCodi: 20.20.20.40; 105.AMB.ClassificacioDescripcio: Biguetes; 107.AMB.NomTipus: BMR - 007_; 109.AMB.CodiTipus: BMR - 007; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Si
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 20
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Steel - Structural, Component Type: Core
ArchiCADQuantities - Surface Area of Both Beam Ends: 0 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Offset: 0 m; Height: 0.1198 m; Width: 0.064 m; Elevation to Project Zero: 5.27425 m; Elevation to 1st Reference Level: 5.27425 m; Elevation to 2nd Reference Level: 5.27425 m; Elevation to Sea Level: 14.6143 m; Elevation to Linked/Home Story: 5.27425 m; Home Offset: 5.27425 m; Top Elevation To First Reference Level: 5.27425 m; Top Elevation To Home Story: 5.27425 m; Top Elevation To Project Zero: 5.27425 m; Top Elevation To Sea Level: 14.6143 m; Top Elevation To Second Reference Level: 5.27425 m; Bottom Elevation To First Reference Level: 5.15445 m; Bottom Elevation To Home Story: 5.15445 m; Bottom Elevation To Project Zero: 5.15445 m; Bottom Elevation To Sea Level: 14.4945 m; Bottom Elevation To Second Reference Level: 5.15445 m; Cross Section Height at Top/End (perpendicular): 0.1198 m; Cross Section Height at Bottom/Start (perpendicular): 0.1198 m; Cross Section Width at Top/End (perpendicular): 0.064 m; Cross Section Width at Bottom/Start (perpendicular): 0.064 m; Cross Section Height at Top/End (cut): 0.1198 m; Cross Section Height at Bottom/Start (cut): 0.1198 m; Cross Section Width at Top/End (cut): 0.064 m; Cross Section Width at Bottom/Start (cut): 0.064 m; Cross Section Area at Bottom/Start: 0 m2; Cross Section Area at Top/End: 0 m2; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.064 m; 503.AMB.Altura: 0.1198 m; 506.AMB.Profunditat: 0 m
Component Quantities - Steel - Structural, Component Cross Section Area: 0.00187564 m2
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Name | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | Surface Area of the Beam Left Side (Net) (m2) = Surface Area of the Beam Right Side (Net) (m2) | Length Left (m) = Length Right (m) | Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) | Steel - Structural, Mass (kg)
2 x BMR - 007 | 51.379 (kgCO₂) | 776.875 | 0.256287 | 2.05317 | 0.137406 | 0.0039681 | 1.02848 | 2.14697 | 0.00410902 | 0.255497 | 0.256079 | 30.9512
BMR - 007 | 20.79 (kgCO₂) | 314.354 | 0.106053 | 0.83691 | 0.0539206 | 0.00160565 | 0.420446 | 0.89471 | 0.00177392 | 0.101936 | 0.101936 | 12.5241

# IfcBuildingElementProxy: IPE 200 100 x 200 (3)
In: planta coberta
Classification: 30.20.10 Cobertes (GuBIMclass CA); Material: Steel - Structural
ArchiCADProperties - Beam Cross Section: Profiled; End Surface: Paint - Anthracite; Beam Slant Angle: -17.4808 deg; Extrusion Surface: Paint - Anthracite; Element ID: Cu5; Hotlink and Element ID: Cu5; Layer: 00_ACERO VIGAS; Building Material / Composite / Profile / Fill: IPE 200; Complex Profile: IPE 200; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Beam; Structure Type: Complex Profile; Profile Category: IPE 200; Parent ID: Cu5; Building Materials (All): Steel - Structural; Cover Fill: Background; Slant Angle: -17.4808 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 107.AMB.NomTipus: Cu5_Coberta R60; 109.AMB.CodiTipus: Cu5; 111.AMB.DescripcioTipus: Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Coberta R60
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Steel - Structural, Component Type: Core
ArchiCADQuantities - Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Offset: 0 m; Height: 0.1998 m; Width: 0.1 m; Cross Section Height at Top/End (perpendicular): 0.1998 m; Cross Section Height at Bottom/Start (perpendicular): 0.1998 m; Cross Section Width at Top/End (perpendicular): 0.1 m; Cross Section Width at Bottom/Start (perpendicular): 0.1 m; Cross Section Height at Top/End (cut): 0.209474 m; Cross Section Height at Bottom/Start (cut): 0.209474 m; Cross Section Width at Top/End (cut): 0.1 m; Cross Section Width at Bottom/Start (cut): 0.1 m; Cross Section Area at Top/End: 0.00322623 m2; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.1 m; 503.AMB.Altura: 0.1998 m; 506.AMB.Profunditat: 0 m
Component Quantities - Steel - Structural, Component Cross Section Area: 0.00307724 m2
Name | Surfaces (All) | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | Surface Area of Both Beam Ends (m2) | Surface Area of the Beam Left Side (Net) (m2) = Surface Area of the Beam Right Side (Net) (m2) | Length Left (m) = Length Right (m) | Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Top Elevation To Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) = Top Elevation To Home Story (m) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Cross Section Area at Bottom/Start (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) | Steel - Structural, Mass (kg)
Cu5 | Paint - Anthracite; Paint - Light Gray | 340.822 (kgCO₂) | 5153.39 | 0.00645247 | 1.71108 | 8.56694 | 0.817131 | 0.0263224 | 10.2307 | 19.5707 | 5.73066 | 6.75788 | 8.62987 | 0.0263625 | 7.4478 | 2.9478 | 16.7878 | 0.00322623 | 1.65904 | 1.65755 | 205.314
Cu5 | Paint - Anthracite; Paint - Light Gray | 126.894 (kgCO₂) | 1918.69 | 0.00565833 | 0.637554 | 3.19396 | 0.304646 | 0.00980024 | 8.56356 | 17.9036 | 4.06356 | 2.52092 | 3.25689 | 0.00982859 | 7.39467 | 2.89467 | 16.7347 | 0.00243209 | 0.617123 | 0.616264 | 76.4419
Cu5 | Paint - Anthracite | 126.87 (kgCO₂) | 1918.33 | 0.00645247 | 0.636195 | 3.18416 | 0.303711 | 0.00979842 | 8.55499 | 17.895 | 4.05499 | 2.51302 | 3.24708 | 0.00979842 | 7.38904 | 2.88904 | 16.729 | 0.00322623 | 0.61709 | 0.61709 | 76.4277

# IfcBuildingElementProxy: IPE 220 100 x 220 (7)
Material: Steel - Structural
ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: 0 deg; Building Material / Composite / Profile / Fill: IPE 220; Complex Profile: IPE 220; Locked: no; Element Type: Beam; Structure Type: Complex Profile; Profile Category: IPE 220; Building Materials (All): Steel - Structural; Cover Fill: Background; Slant Angle: 0 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Steel - Structural, Component Type: Core
Component Quantities - Steel - Structural, Component Cross Section Area: 0.00320124 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.1 m; 503.AMB.Altura: 0.2198 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Offset: 0 m; Height: 0.2198 m; Width: 0.1 m; Cross Section Height at Top/End (perpendicular): 0.2198 m; Cross Section Height at Bottom/Start (perpendicular): 0.2198 m; Cross Section Width at Top/End (perpendicular): 0.1 m; Cross Section Width at Bottom/Start (perpendicular): 0.1 m; Cross Section Height at Top/End (cut): 0.2198 m; Cross Section Height at Bottom/Start (cut): 0.2198 m; Cross Section Width at Top/End (cut): 0.1 m; Cross Section Width at Bottom/Start (cut): 0.1 m; Number of Segments: 1
Name | In | Classification | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Layer | Home Story Name = 115.AMB.Nivell | Home Story Number | Surfaces (All) | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 201.AMB.EsEstructural | AUX_104.AMB.ClassificacioCodiCateg | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | Steel - Structural, Mass (kg) | Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3) = Volume (Net) (m3) = Volume (Conditional) (m3) | Surface Area of Both Beam Ends (m2) | Surface Area of the Beam Left Side (Net) (m2) | Length Left (m) = Length Right (m) | Surface Area of the Beam Right Side (Net) (m2) | Area (m2) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Top Elevation To Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) = Top Elevation To Home Story (m) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2)
BMR - 007 | planta baixa | 20.20.20.10 Forjats (GuBIMclass CA) | BMR - 007 | 00_ACERO VIGAS | planta baixa | 0 | Paint - Anthracite; Paint - Light Gray | 20.20.20.10 Forjats | 20.20.20.10 | Forjats | BMR - 007_ | Si | 20 | 187.819 (kgCO₂) | 2839.91 | 113.144 | 0.0145056 | 0.00320124 | 1.00136 | 4.57056 | 1.00136 | 0.451597 | 5.27425 | 14.6143 | 5.27425 | 3.76537 | 4.55996 | 0.0146315 | 5.05445 | 5.05445 | 14.3945 | 0.00320124 | 0 | 0.874632 | 0.874632 | ArchiCADProperties - End Surface: Paint - Anthracite; Extrusion Surface: Paint - Anthracite
BMR - 007 | planta baixa | 20.20.20.10 Forjats (GuBIMclass CA) | BMR - 007 | 00_ACERO VIGAS | planta baixa | 0 | Paint - Anthracite; Paint - Light Gray | 20.20.20.10 Forjats | 20.20.20.10 | Forjats | BMR - 007_ | Si | 20 | 185.388 (kgCO₂) | 2803.16 | 111.68 | 0.0143179 | 0.00124124 | 0.999258 | 4.56806 | 0.999258 | 0.442679 | 5.27425 | 14.6143 | 5.27425 | 3.72159 | 4.55876 | 0.0147253 | 5.05445 | 5.05445 | 14.3945 | 0.00124124 | 0 | 0.856221 | 0.856221 | ArchiCADProperties - End Surface: Paint - Anthracite; Extrusion Surface: Paint - Anthracite
BMR - 007 | planta baixa | 20.20.20.10 Forjats (GuBIMclass CA) | BMR - 007 | 00 ACERO VIGA PLANTA | planta baixa | 0 | Paint - Anthracite; Paint - Light Gray | 20.20.20.10 Forjats | 20.20.20.10 | Forjats | BMR - 007_ | Si | 20 | 186.604 (kgCO₂) | 2821.54 | 112.412 | 0.0144118 | 0.00421426 | 1.00136 | 4.56806 | 0.999258 | 0.447138 | 5.27425 | 14.6143 | 5.27425 | 3.74449 | 4.60686 | 0.0146235 | 5.05445 | 5.05445 | 14.3945 | 0.00124124 | 0.00297302 | 0.865426 | 0.865426 | ArchiCADProperties - End Surface: Paint - Anthracite; Extrusion Surface: Paint - Anthracite
BMR - 007 | planta coberta | 20.20.20.20 Jàsseres (GuBIMclass CA) | BMR - 007 | 00_ACERO VIGAS | planta coberta | 1 | Paint - Light Gray | 20.20.20.20 Jàsseres | 20.20.20.20 | Jàsseres | BMR - 007_ | Si | 20 | 210.371 (kgCO₂) | 3180.91 | 126.729 | 0.0162474 | 0.00530348 | 1.1382 | 5.22832 | 1.1382 | 0.516333 | 8.07425 | 17.4143 | 3.57425 | 4.44421 | 5.1785 | 0.0167371 | 7.85445 | 3.35445 | 17.1945 | 0.00320124 | 0.00210224 | 1.00206 | 1.00206
BMR - 007 | planta coberta | 20.20.20.20 Jàsseres (GuBIMclass CA) | BMR - 007 | 00 ACERO VIGA PLANTA | planta coberta | 1 | Paint - Light Gray | 20.20.20.20 Jàsseres | 20.20.20.20 | Jàsseres | BMR - 007_ | Si | 20 | 209.156 (kgCO₂) | 3162.53 | 125.997 | 0.0161535 | 0.00320124 | 1.1366 | 5.22832 | 1.1366 | 0.511639 | 5.27425 | 14.6143 | 0.774253 | 4.41904 | 5.1754 | 0.016839 | 5.05445 | 0.554453 | 14.3945 | 0.00320124 | 0 | 0.992619 | 0.992619
BMR - 007 | planta coberta | 20.20.20.20 Jàsseres (GuBIMclass CA) | BMR - 007 | 00_ACERO VIGAS | planta coberta | 1 | Paint - Light Gray | 20.20.20.20 Jàsseres | 20.20.20.20 | Jàsseres | BMR - 007_ | Si | 20 | 177.593 (kgCO₂) | 2685.29 | 106.983 | 0.0137158 | 0.00297302 | 0.956925 | 4.37386 | 0.953723 | 0.433733 | 5.27425 | 14.6143 | 0.774253 | 3.6883 | 4.39633 | 0.0140018 | 5.05445 | 0.554453 | 14.3945 | 0.00297302 | 0 | 0.841419 | 0.841419
Cu5 | planta coberta | 30.20.10 Cobertes (GuBIMclass CA) | Cu5 | 00_ACERO VIGAS | planta coberta | 1 | Paint - Light Gray | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | No | 30 | 191.277 (kgCO₂) | 2892.2 | 115.227 | 0.0147727 | 0.00616699 | 1.0129 | 4.63806 | 1.01393 | 0.462806 | 8.36203 | 17.702 | 3.86203 | 3.8449 | 4.62806 | 0.0148476 | 8.14223 | 3.64223 | 17.4822 | 0.0030835 | 0.0030835 | 0.895559 | 0.89226 | 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT; GENERAL PROPERTIES - AUX_107.NomTipus: Coberta R60

# IfcBuildingElementProxy: Insulation 80 (19)
In: planta baixa
Material: Insulation - Mineral Soft
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Layer: 00_TABIQUE; Building Material / Composite / Profile / Fill: Insulation; Composite Structure: Insulation; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Composite; Building Materials (All): Insulation - Mineral Soft; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Insulation - Mineral Soft, Component Type: Core
1 AMB.Identificacio - 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
Component Quantities - Insulation - Mineral Soft, Component Thickness: 0.08 m; Insulation - Mineral Soft, Rectangular Component Width: 0.08 m
ArchiCADQuantities - Number of Holes (Number of Empty Openings): 0; Volume of the Columns: 0 m3; Air Skin Thickness: 0 m; Wall Component Thickness on the Inside Face: 0.08 m; Wall Component Thickness on the Outside Face: 0.08 m; End Thickness of the Wall: 0.08 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.08 m; Top Offset: 0 m; Thickness: 0.08 m; Insulation Skin Thickness: 0.08 m
5 AMB.Geometria - 502.AMB.Amplada: 0.08 m; 504.AMB.Gruix: 0.08 m; 506.AMB.Profunditat: 0 m
