Properties of the parts of a building model (IFC2X3), part 57 of 99

# IfcBuildingElementProxy: Rhino_Object_1601, Object_1601
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1601; Hotlink and Element ID: Object_1601; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1601; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1601; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1601 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1601_; 109.AMB.CodiTipus: Object_1601; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147744 m; Area: 0.00866213 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0586292 m; Elevation to Project Zero: 3.92949 m; Elevation to 1st Reference Level: 3.92949 m; Elevation to 2nd Reference Level: 3.92949 m; Elevation to Sea Level: 13.2695 m; Elevation to Linked/Home Story: 3.92949 m; Home Offset: 3.92949 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97018 m; Top Elevation To Home Story: 3.97018 m; Top Elevation To Project Zero: 3.97018 m; Top Elevation To Sea Level: 13.3102 m; Top Elevation To Second Reference Level: 3.97018 m; Bottom Elevation To First Reference Level: 3.92949 m; Bottom Elevation To Home Story: 3.92949 m; Bottom Elevation To Project Zero: 3.92949 m; Bottom Elevation To Sea Level: 13.2695 m; Bottom Elevation To Second Reference Level: 3.92949 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.2695 m; Top Surface Area (Net): 0.00866213 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1601 - Dimension 1: 0.147744 m; Dimension 2: 0.0586292 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0586292 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1602, Object_1602
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1602; Hotlink and Element ID: Object_1602; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1602; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1602; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1602 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1602_; 109.AMB.CodiTipus: Object_1602; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941367 m; Area: 0.00334263 m2; Height: 0.0575 m; Volume (Net): 0.000159563 m3; Width: 0.0355082 m; Elevation to Project Zero: 3.87199 m; Elevation to 1st Reference Level: 3.87199 m; Elevation to 2nd Reference Level: 3.87199 m; Elevation to Sea Level: 13.212 m; Elevation to Linked/Home Story: 3.87199 m; Home Offset: 3.87199 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92949 m; Top Elevation To Home Story: 3.92949 m; Top Elevation To Project Zero: 3.92949 m; Top Elevation To Sea Level: 13.2695 m; Top Elevation To Second Reference Level: 3.92949 m; Bottom Elevation To First Reference Level: 3.87199 m; Bottom Elevation To Home Story: 3.87199 m; Bottom Elevation To Project Zero: 3.87199 m; Bottom Elevation To Sea Level: 13.212 m; Bottom Elevation To Second Reference Level: 3.87199 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.212 m; Top Surface Area (Net): 0.00334263 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1602 - Dimension 1: 0.0941367 m; Dimension 2: 0.0355082 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0355082 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159563 m3; Component, Component Volume (Gross): 0.000159563 m3

# IfcBuildingElementProxy: Rhino_Object_1603, Object_1603
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1603; Hotlink and Element ID: Object_1603; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1603; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1603; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1603 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1603_; 109.AMB.CodiTipus: Object_1603; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Equantity_Rhino_Object_1603 - Dimension 1: 0.216263 m; Dimension 2: 0.112485 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112485 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3
ArchiCADQuantities - Length (A): 0.216263 m; Area: 0.0243264 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112485 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30992 m; Top Elevation To Home Story: 4.30992 m; Top Elevation To Project Zero: 4.30992 m; Top Elevation To Sea Level: 13.6499 m; Top Elevation To Second Reference Level: 4.30992 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0243264 m2; Bottom Surface Area (Net): 0.0778487 m2

# IfcBuildingElementProxy: Rhino_Object_1604, Object_1604
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1604; Hotlink and Element ID: Object_1604; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1604; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1604; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1604 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1604_; 109.AMB.CodiTipus: Object_1604; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.15015 m; Area: 0.0147983 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.0985568 m; Elevation to Project Zero: 4.19492 m; Elevation to 1st Reference Level: 4.19492 m; Elevation to 2nd Reference Level: 4.19492 m; Elevation to Sea Level: 13.5349 m; Elevation to Linked/Home Story: 4.19492 m; Home Offset: 4.19492 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25242 m; Top Elevation To Home Story: 4.25242 m; Top Elevation To Project Zero: 4.25242 m; Top Elevation To Sea Level: 13.5924 m; Top Elevation To Second Reference Level: 4.25242 m; Bottom Elevation To First Reference Level: 4.19492 m; Bottom Elevation To Home Story: 4.19492 m; Bottom Elevation To Project Zero: 4.19492 m; Bottom Elevation To Sea Level: 13.5349 m; Bottom Elevation To Second Reference Level: 4.19492 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.5349 m; Top Surface Area (Net): 0.0147983 m2; Bottom Surface Area (Net): 0.053125 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1604 - Dimension 1: 0.15015 m; Dimension 2: 0.0985568 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0985568 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1605, Object_1605
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1605 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1605; Hotlink and Element ID: Object_1605; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1605; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1605; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.10463 m; Area: 0.00898444 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0858688 m; Elevation to Project Zero: 3.97018 m; Elevation to 1st Reference Level: 3.97018 m; Elevation to 2nd Reference Level: 3.97018 m; Elevation to Sea Level: 13.3102 m; Elevation to Linked/Home Story: 3.97018 m; Home Offset: 3.97018 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19492 m; Top Elevation To Home Story: 4.19492 m; Top Elevation To Project Zero: 4.19492 m; Top Elevation To Sea Level: 13.5349 m; Top Elevation To Second Reference Level: 4.19492 m; Bottom Elevation To First Reference Level: 3.97018 m; Bottom Elevation To Home Story: 3.97018 m; Bottom Elevation To Project Zero: 3.97018 m; Bottom Elevation To Sea Level: 13.3102 m; Bottom Elevation To Second Reference Level: 3.97018 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.3102 m; Top Surface Area (Net): 0.00898444 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1605 - Dimension 1: 0.10463 m; Dimension 2: 0.0858688 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0858688 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1605_; 109.AMB.CodiTipus: Object_1605; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1606, Object_1606
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1606 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1606_; 109.AMB.CodiTipus: Object_1606; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1606; Hotlink and Element ID: Object_1606; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1606; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1606; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147744 m; Area: 0.00866213 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0586292 m; Elevation to Project Zero: 3.92949 m; Elevation to 1st Reference Level: 3.92949 m; Elevation to 2nd Reference Level: 3.92949 m; Elevation to Sea Level: 13.2695 m; Elevation to Linked/Home Story: 3.92949 m; Home Offset: 3.92949 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97018 m; Top Elevation To Home Story: 3.97018 m; Top Elevation To Project Zero: 3.97018 m; Top Elevation To Sea Level: 13.3102 m; Top Elevation To Second Reference Level: 3.97018 m; Bottom Elevation To First Reference Level: 3.92949 m; Bottom Elevation To Home Story: 3.92949 m; Bottom Elevation To Project Zero: 3.92949 m; Bottom Elevation To Sea Level: 13.2695 m; Bottom Elevation To Second Reference Level: 3.92949 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.2695 m; Top Surface Area (Net): 0.00866213 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1606 - Dimension 1: 0.147744 m; Dimension 2: 0.0586292 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0586292 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1607, Object_1607
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1607 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1607; Hotlink and Element ID: Object_1607; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1607; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1607; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1607_; 109.AMB.CodiTipus: Object_1607; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941367 m; Area: 0.00334263 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0355082 m; Elevation to Project Zero: 3.87199 m; Elevation to 1st Reference Level: 3.87199 m; Elevation to 2nd Reference Level: 3.87199 m; Elevation to Sea Level: 13.212 m; Elevation to Linked/Home Story: 3.87199 m; Home Offset: 3.87199 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92949 m; Top Elevation To Home Story: 3.92949 m; Top Elevation To Project Zero: 3.92949 m; Top Elevation To Sea Level: 13.2695 m; Top Elevation To Second Reference Level: 3.92949 m; Bottom Elevation To First Reference Level: 3.87199 m; Bottom Elevation To Home Story: 3.87199 m; Bottom Elevation To Project Zero: 3.87199 m; Bottom Elevation To Sea Level: 13.212 m; Bottom Elevation To Second Reference Level: 3.87199 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.212 m; Top Surface Area (Net): 0.00334263 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1607 - Dimension 1: 0.0941367 m; Dimension 2: 0.0355082 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0355082 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Rhino_Object_1608, Object_1608
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1608; Hotlink and Element ID: Object_1608; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1608; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1608; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1608 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1608_; 109.AMB.CodiTipus: Object_1608; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216263 m; Area: 0.0243264 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112485 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30992 m; Top Elevation To Home Story: 4.30992 m; Top Elevation To Project Zero: 4.30992 m; Top Elevation To Sea Level: 13.6499 m; Top Elevation To Second Reference Level: 4.30992 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0243264 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1608 - Dimension 1: 0.216263 m; Dimension 2: 0.112485 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112485 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1609, Object_1609
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1609; Hotlink and Element ID: Object_1609; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1609; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1609; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1609 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1609_; 109.AMB.CodiTipus: Object_1609; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15015 m; Area: 0.0147983 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.0985568 m; Elevation to Project Zero: 4.19492 m; Elevation to 1st Reference Level: 4.19492 m; Elevation to 2nd Reference Level: 4.19492 m; Elevation to Sea Level: 13.5349 m; Elevation to Linked/Home Story: 4.19492 m; Home Offset: 4.19492 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25242 m; Top Elevation To Home Story: 4.25242 m; Top Elevation To Project Zero: 4.25242 m; Top Elevation To Sea Level: 13.5924 m; Top Elevation To Second Reference Level: 4.25242 m; Bottom Elevation To First Reference Level: 4.19492 m; Bottom Elevation To Home Story: 4.19492 m; Bottom Elevation To Project Zero: 4.19492 m; Bottom Elevation To Sea Level: 13.5349 m; Bottom Elevation To Second Reference Level: 4.19492 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.5349 m; Top Surface Area (Net): 0.0147983 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1609 - Dimension 1: 0.15015 m; Dimension 2: 0.0985568 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0985568 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_161, Object_161
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_161; Hotlink and Element ID: Object_161; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_161; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_161; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_161 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_161_; 109.AMB.CodiTipus: Object_161; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.015273 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.693152 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426586 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693152 m2
AC_Equantity_Rhino_Object_161 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -6.13198e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.015273 m3; Component, Component Volume (Gross): 0.015273 m3

# IfcBuildingElementProxy: Rhino_Object_1610, Object_1610
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1610; Hotlink and Element ID: Object_1610; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1610; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1610; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1610 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1610_; 109.AMB.CodiTipus: Object_1610; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.10463 m; Area: 0.00898444 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0858688 m; Elevation to Project Zero: 3.97018 m; Elevation to 1st Reference Level: 3.97018 m; Elevation to 2nd Reference Level: 3.97018 m; Elevation to Sea Level: 13.3102 m; Elevation to Linked/Home Story: 3.97018 m; Home Offset: 3.97018 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19492 m; Top Elevation To Home Story: 4.19492 m; Top Elevation To Project Zero: 4.19492 m; Top Elevation To Sea Level: 13.5349 m; Top Elevation To Second Reference Level: 4.19492 m; Bottom Elevation To First Reference Level: 3.97018 m; Bottom Elevation To Home Story: 3.97018 m; Bottom Elevation To Project Zero: 3.97018 m; Bottom Elevation To Sea Level: 13.3102 m; Bottom Elevation To Second Reference Level: 3.97018 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.3102 m; Top Surface Area (Net): 0.00898444 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1610 - Dimension 1: 0.10463 m; Dimension 2: 0.0858688 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0858688 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1611, Object_1611
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1611; Hotlink and Element ID: Object_1611; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1611; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1611; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1611 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1611_; 109.AMB.CodiTipus: Object_1611; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147744 m; Area: 0.00866213 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0586292 m; Elevation to Project Zero: 3.92949 m; Elevation to 1st Reference Level: 3.92949 m; Elevation to 2nd Reference Level: 3.92949 m; Elevation to Sea Level: 13.2695 m; Elevation to Linked/Home Story: 3.92949 m; Home Offset: 3.92949 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97018 m; Top Elevation To Home Story: 3.97018 m; Top Elevation To Project Zero: 3.97018 m; Top Elevation To Sea Level: 13.3102 m; Top Elevation To Second Reference Level: 3.97018 m; Bottom Elevation To First Reference Level: 3.92949 m; Bottom Elevation To Home Story: 3.92949 m; Bottom Elevation To Project Zero: 3.92949 m; Bottom Elevation To Sea Level: 13.2695 m; Bottom Elevation To Second Reference Level: 3.92949 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.2695 m; Top Surface Area (Net): 0.00866213 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1611 - Dimension 1: 0.147744 m; Dimension 2: 0.0586292 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0586292 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1612, Object_1612
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1612; Hotlink and Element ID: Object_1612; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1612; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1612; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1612 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1612_; 109.AMB.CodiTipus: Object_1612; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941367 m; Area: 0.00334263 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0355082 m; Elevation to Project Zero: 3.87199 m; Elevation to 1st Reference Level: 3.87199 m; Elevation to 2nd Reference Level: 3.87199 m; Elevation to Sea Level: 13.212 m; Elevation to Linked/Home Story: 3.87199 m; Home Offset: 3.87199 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92949 m; Top Elevation To Home Story: 3.92949 m; Top Elevation To Project Zero: 3.92949 m; Top Elevation To Sea Level: 13.2695 m; Top Elevation To Second Reference Level: 3.92949 m; Bottom Elevation To First Reference Level: 3.87199 m; Bottom Elevation To Home Story: 3.87199 m; Bottom Elevation To Project Zero: 3.87199 m; Bottom Elevation To Sea Level: 13.212 m; Bottom Elevation To Second Reference Level: 3.87199 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.212 m; Top Surface Area (Net): 0.00334263 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1612 - Dimension 1: 0.0941367 m; Dimension 2: 0.0355082 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0355082 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3

# IfcBuildingElementProxy: Rhino_Object_1613, Object_1613
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1613; Hotlink and Element ID: Object_1613; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1613; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1613; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1613 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1613_; 109.AMB.CodiTipus: Object_1613; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216263 m; Area: 0.0243264 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112485 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30992 m; Top Elevation To Home Story: 4.30992 m; Top Elevation To Project Zero: 4.30992 m; Top Elevation To Sea Level: 13.6499 m; Top Elevation To Second Reference Level: 4.30992 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0243264 m2; Bottom Surface Area (Net): 0.0778487 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.112485 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1613 - Dimension 1: 0.216263 m; Dimension 2: 0.112485 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1614, Object_1614
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1614; Hotlink and Element ID: Object_1614; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1614; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1614; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1614 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1614_; 109.AMB.CodiTipus: Object_1614; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15015 m; Area: 0.0147983 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.0985568 m; Elevation to Project Zero: 4.19492 m; Elevation to 1st Reference Level: 4.19492 m; Elevation to 2nd Reference Level: 4.19492 m; Elevation to Sea Level: 13.5349 m; Elevation to Linked/Home Story: 4.19492 m; Home Offset: 4.19492 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25242 m; Top Elevation To Home Story: 4.25242 m; Top Elevation To Project Zero: 4.25242 m; Top Elevation To Sea Level: 13.5924 m; Top Elevation To Second Reference Level: 4.25242 m; Bottom Elevation To First Reference Level: 4.19492 m; Bottom Elevation To Home Story: 4.19492 m; Bottom Elevation To Project Zero: 4.19492 m; Bottom Elevation To Sea Level: 13.5349 m; Bottom Elevation To Second Reference Level: 4.19492 m; Survey Coordinate X: 426582 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.5349 m; Top Surface Area (Net): 0.0147983 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1614 - Dimension 1: 0.15015 m; Dimension 2: 0.0985568 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0985568 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1615, Object_1615
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1615 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
