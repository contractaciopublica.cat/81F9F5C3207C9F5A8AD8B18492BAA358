Properties of the parts of a building model (IFC2X3), part 15 of 99

# IfcBuildingElementProxy: Pocket Double Door 27 (4)
AC_Pset_Pocket_Double_Door_27 - Wall Contours (0-None,1-Full,2-Side,3-Length): 0; Hotspots 0-None,1-2D,2-3D,3-All: 3; Show 2D Hotspots in 3D: yes; Floor Plan Display Option: 3; Hole Position Angle: 0 deg; Hole has Wall's Side Surface: yes; Hole Surface's Split is Curved in Curved Walls: no; Reveal Anchor Position: 1; Flip: no; Demolition / New construction: 1; New Wall Fill Type: Masonry Block; New Wall Fill Pen: General - General; New Wall Fill Background Pen: Backgrounds - color 1; Show new construction on Wall: no; Demolition line type: 1; Show Demolition/New parameter: no; Display as Transom: no; Sidelight (gs_SidelightTransomRelation): Under Transom; Sidelight (gs_SidelightTransomRelation_m): 1; Uniform Tolerances: yes; Nominal Size: 0; Set Wallhole Size as Nominal Size: yes; Set Reveal Size as Nominal Size: no; Set Unit Size as Nominal Size: no; Set Egress Size as Nominal Size: no; Set Leaf Size as Nominal Size: no; Transfer Current Nominal Size to Selection: no; Show Editable Hotspots: yes; 2D Detail Level: 1; Show Reveal on Symbol: 1; Symbolic Display of Opening: no; 3D Detail Level: 8; Opening Direction Sidelight (gs_opening_dir_sl): Opposite to Leaf; Opening Direction Sidelight (gs_opening_dir_sl_m): 2; Door Frame (gs_pocket_door_frame): yes; Frame Style (gs_frame_style): Block; Frame Style (gs_frame_style_m): 1; Uniform Frame Thickness: yes; Centered Leaf: yes; Uniform Frame Width: yes; Frame Style Changed Automatically: no; Number of Door Leaves: 4; Number of Door Leaves - Side 2: 3; Door Panel Style: 46; Leaves Configuration (gs_LeavesConfig): Uniform Leaves; Leaves Configuration (gs_iLeavesConfig): 1; Grid Position (gs_grill_pos): Throughout; Grid Position (gs_grill_pos_m): 3; Panes Number Vertically: 4; Panes Number Horizontally: 3; Panes Number Vertically Side 1: 4; Panes Number Horizontally Side 1: 3; Show as Glass Panel on Symbol: no; Show Chinese Spring Door Symbol: no; Show Symbol as Airtight Panel: no; Opening Handle (gs_handle_type_m): 0; Show Handle on Symbol: no; Kick Board Outside (bKickBoardOut): no; Kick Board Inside (bKickBoardIn): no; Uniform Sashes: no; Opening Type (gs_optype_m_05): 3; Opening Type (gs_optype_m_09): 3; Opening Type (gs_optype_m_02): 1; Opening Type (gs_optype_m_06): 1; Opening Type (gs_optype_m_10): 1; Sash Type (MullionStyle_00): No Grid; Sash Type (iMullionStyle_00): 1; Sash Type (iMullionStyle_05): 1; Sash Type (iMullionStyle_09): 1; Sash Type (iMullionStyle_02): 1; Sash Type (iMullionStyle_06): 1; Sash Type (iMullionStyle_10): 1; Hotspot Grill Editing: yes; Grid Position (MullionPosition): Throughout; Grid Position (iMullionPosition): 3; Panes Number Vertically Main Sash Side 1: 4; Panes Number Horizontally Main Sash Side 1: 2; Panes Number Vertically 2 Main Sash Side 1: 4; Panes Number Horizontally 2 Main Sash Side 1: 2; Panes Number Vertically Main Sash Side 2: 4; Panes Number Horizontally Main Sash Side 2: 2; Panes Number Vertically 2 Main Sash Side 2: 4; Panes Number Horizontally 2 Main Sash Side 2: 2; Panes Number Vertically Middle Transom: 2; Panes Number Horizontally Middle Transom: 2; Panes Number Vertically 2 Middle Transom: 2; Panes Number Horizontally 2 Middle Transom: 2; Panes Number Vertically Transom Side 1: 2; Panes Number Horizontally Transom Side 1: 2; Panes Number Vertically 2 Transom Side 1: 2; Panes Number Horizontally 2 Transom Side 1: 2; Panes Number Vertically Transom Side 2: 2; Panes Number Horizontally Transom Side 2: 2; Panes Number Vertically 2 Transom Side 2: 2; Panes Number Horizontally 2 Transom Side 2: 2; Right Sidelight: no; Left Sidelight: no; Transom: no; Casing (gs_trim_outside): no; Casing Type Outside (gs_trimtype_out): Simple; Casing Type Outside (gs_trimtype_out_int): 1; Outside Casing Head Type: 1; Architrave Capital: yes; Architrave Capital Type: 1; Cover Outer Wall Surface: yes; Uniform Casing Widths (gs_trim_outside_uniform): yes; Casing (gs_trim_inside): no; Casing Type Inside (gs_trimtype_in): Simple; Casing Type Inside (gs_trimtype_in_int): 1; Cover Inner Wall Surface: yes; Uniform Casing Widths (gs_trim_inside_uniform): yes; Threshold (bThreshold): no; Threshold Type: -1; Threshold Angle: 3.1996 deg; Threshold Changed Automatically: no; Sill - Door: no; Sill - Sidelight Side 1: no; Sill - Sidelight: no; Sill Oversize: no; Type of the Sill: 1; Sill Angle: 3 deg; Sill is Curved in Curved Walls: yes; Insulation below Sill: yes; Use Wall Insulation Skin: no; Brick Sill 3D Detail Level: 1; Sill Style Changed Automatically: no; Board - Sidelight Side 1: no; Board - Sidelight: no; Board - Door: no; Board Angle: 0 deg; Board is Curved in Curved Walls: yes; Board in Polygonal Walls: 1; Enabled Sunshade Types: 126; Number of Panels: 2; Number of Panels 2: 1; Panel Position (gs_shutter_iPanelPos): 1; Automatic Shutter Height: yes; Extra Frame: no; Cover Type (gs_slidingShutter_cover): Z-Profile; Cover Type (gs_slidingShutter_iCover): 1; Stacking Direction (gs_foldingShutter_stacking): Inside; Stacking Direction (gs_foldingShutter_iStacking): 1; Open in 3D: yes; 3D Opening Angle: 180 deg; Show 2D Symbol: yes; Show Opening Lines on Symbol: no; Panel Type (gs_shutPanel_type): Style 1; Panel Type (gs_shutPanel_iType): 1; Different Bottom Frame Width: no; Automatic Shutter Width: yes; Louver Angle: 30 deg; Holes Number Horizontal: 5; Holes Number Vertical: 8; Box Type (gs_shutRoll_boxType): Rectangular; Box Type (gs_shutRoll_iBoxType): 1; Rail Position (gs_shutRoll_railPos): On Casing; Rail Position (gs_shutRoll_iRailPos): 1; Show Casing behind Sunshade (gs_shutRoll_showCasingBehind): no; Insulation behind Box (gs_shutRoll_cutWallBehind): no; Include Height in Wallhole Height: no; Box Top Angle: 10 deg; Box Default Width (gs_shutRoll_iBoxDefaultSize): 1; Venetian Blinds Placement (gs_shutLam_placement): Fixed on Facade; Venetian Blinds Placement (gs_shutLam_iPlacement): 1; Insulation behind Box (gs_shutLam_cutWallBehind): no; Opened Box: yes; Rail (gs_shutLam_bRail): yes; Rail Position (gs_shutLam_railPos): On Casing; Rail Position (gs_shutLam_iRailPos): 1; Show Casing behind Sunshade (gs_shutLam_showCasingBehind): no; Rotation Angle of Slats (gs_shutLam_rotation): 45 deg; Rotation Angle of Slats (gs_shutLam2_rotation): 45 deg; Masonry Arch (bMasonryArch): no; Masonry Arch (gs_masonry_arch_int): 0; Masonry Arch Type (gs_masonry_arch_structure): Stucco Arch; Masonry Arch Type (gs_masonry_arch_structure_int): 0; Arch on Header: yes; Niche below Arch: yes; Skewback Angle: 75 deg; Custom Niche Surface: no; Reveal Type (gs_reveal_type_new): No Reveal - Edge; Reveal Type (gs_reveal_type_int): 1; Bottom Reveal Type (gs_reveal_type_bottom): No Reveal; Bottom Reveal Type (gs_reveal_type_bottom_int): 2; Set Jamb Depth on Side: 1; Uniform Jamb Depth: yes; Outer Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleOuterTypeInt): 0; Inner Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleInnerTypeInt): 0; Angle Side 2: 20 deg; Angle Side: 20 deg; Upper Side Angle: 20 deg; Bottom Side Angle: 20 deg; Outer Angle Side 2: 20 deg; Outer Angle Side: 20 deg; Outer Angle Upper Side: 20 deg; Outer Angle Bottom Side: 20 deg; Rail (gs_door_rail): no; Rail Position (gs_door_rail_ext): Rail at Bottom; Rail Position (gs_door_rail_ext_m): 2; Use Wall Finish Component: no; Auto Turn Inside Face Plaster: yes; Turn Inside Face Plaster: 0; Auto Turn Outside Face Plaster: yes; Turn Outside Face Plaster: 0; Dimensionable on 2D: no; Show in 3D: no; Closure Type (gs_closure_type): No Closure; Closure Type (gs_closure_type_int): 1; Turn Skin on Side (gs_cavity_side): Both; Turn Skin on Side (iCavityClosureSide): 1; Number of Skins to Turn: 1; Number from (gs_nTurnDir): Outside Face; Number from (iCavityClosureTurnDir): 1; Place Closer on Side 1: yes; Place Closer on Side 2: yes; Place Closer on Top: no; Place Closer on Bottom: no; Place Closer to Skin: 1; Place Closer from Side (gs_cc_dutch_ClosureToSide): 1; Gap at Outside Skin: yes; Turn Skin to Closer: no; Insert Insulation Strip: yes; Show Insulation Strip: yes; Contour Pen (gs_penJoint): Openings - Cut Non-Structural; Contour Line Type (gs_ltJoint): 1; Fill Type (gs_fillJoint): Rigid Insulation; Fill Pen (gs_penJointFg): General - General; Fill Background Pen (gs_penJointBg): 2D Elements - Drafting; Custom Surface: no; Surface: Wood - Pine Grained Horizontal; Contour Pen (gs_penPlug): Openings - Cut Non-Structural; Contour Line Type (gs_ltPlug): 1; Fill Type (gs_fillPlug): Rigid Insulation; Fill Pen (gs_penPlugFg): General - General; Fill Background Pen (gs_penPlugBg): 2D Elements - Drafting; Edited Jamb Side: 1; Edited Wall Side: 1; Edited Skin Number: 1; Turn-in Skin: no; Consider Skin as Plaster: no; Turn-in Thickness: 1; Hatch Orientation: 1; Separating Line at Turn-in: no; Separating Line Pen: General - General; Last Selected Side: no; Closure Method Changed Automatically: no; Connection on Side 1: no; Connection on Side 2: no; Connection on the Top: no; Opening Type (gs_leaf_optype): Double Pocket; Opening Type (gs_leaf_optype_m): 27; End Panel Opening Side 1: no; End Panel Opening Side 2: no; Opening Angle in 2D: 90 deg; Opening Angle in 2D on Side 2: 90 deg; Opening Angle in 3D: 0 deg; End Panel Opening Angle in 3D on Side 2: 0 deg; Opening Angle of Main Sash Side 1 (openingAngle_05): 0 deg; Opening Angle of Main Sash Side 1 (openingAngle2_05): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle_09): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle2_09): 0 deg; Opening Angle of Middle Transom (openingAngle_02): 0 deg; Opening Angle of Middle Transom (openingAngle2_02): 0 deg; Opening Angle of Transom Side 1 (openingAngle_06): 0 deg; Opening Angle of Transom Side 1 (openingAngle2_06): 0 deg; Opening Angle of Transom Side 2 (openingAngle_10): 0 deg; Opening Angle of Transom Side 2 (openingAngle2_10): 0 deg; Opening Line in 2D: no; Override MVO for 2D Symbolic Display: yes; Opening Line Type: 1; Opening Line Shape (or_SwingType): Curved; Opening Line Shape (or_iSwingType): 1; Opening Line Shape (or_SlidingType): Arrow; Opening Line Shape (or_iSlidingType): 1; Override MVO for 3D Projections: yes; Show Opening Line (or_bOplines3d): yes; Line Type Opening Side (or_opLineType3dIn): Dashed; Line Type Opening Side (or_iOpLineType3dIn): 1; Line Type Opposite Side (or_opLineType3dOut): Dashed; Line Type Opposite Side (or_iOpLineType3dOut): 1; Line Orientation (or_oplineStyle): Handle; Line Orientation (or_iOplineStyle): 1; Opening Line Pen in 2D/3D (or_opLinePen): Roofs/Shells - Outlines and Cover Fills; Opening Line Pen in 2D/3D (or_iOpLinePen): 92; Override MVO for Sidelight/Transom 3D Projections: no; Show Opening Line (or_bWinOplines3d): yes; Line Type Opening Side (or_winOpLineType3dIn): Dashed; Line Type Opening Side (or_iWinOpLineType3dIn): 1; Line Type Opposite Side (or_winOpLineType3dOut): Solid Line; Line Type Opposite Side (or_iWinOpLineType3dOut): 0; Line Orientation (or_winOplineStyle): Handle; Line Orientation (or_iWinOplineStyle): 1; Opening Line Pen in 2D/3D (or_winOpLinePen): Openings - General; Opening Line Pen in 2D/3D (or_iWinOpLinePen): 3; Symbol Pen: Openings - General; Frame Contour Pen: Openings - Cut Structural; Pocket Contour Pen: Openings - General; Casing Cut Line Pen on Both Sides: Openings - General; Leaf Contour Pen: Openings - General; Wall Contour Line (gs_wcont_line): Off; Wall Contour Line (iWallContourLine): 1; Wall Contour Line Type Inside: 1; Wall Contour Line Type Outside: 1; Hidden Wall Contour Line Type Inside: 4; Hidden Wall Contour Line Type Outside: 4; Sidelight Wall Contour Line: 4; Wall Contour Line Pen: Openings - General; Use Fills: yes; Frame Fill Type: Background; Frame Fill Pen: Openings - Cut Fills; Frame Fill Background Pen: Backgrounds - color 1; Leaf Fill Type: Air Space; Leaf Fill Pen: Backgrounds - color 1; Leaf Fill Background Pen: Backgrounds - color 1; Airtight Symbol Fill Type: Foreground; Airtight Symbol Fill Pen: General - General; Airtight Symbol Fill Background Pen: General - General; Plan Symbol Fill Type: Air Space; Plan Symbol Fill Pen: Transparent; Plan Symbol Fill Background Pen: Transparent; Sidelight Plan Symbol Fill Type: Background; Sidelight Plan Symbol Fill Pen: Backgrounds - color 1; Sidelight Plan Symbol Fill Background Pen: Backgrounds - color 1; Threshold and Sill Line Type: 1; Threshold Section Contour Pen: Openings - General; Threshold Section Fill Type: Background; Threshold Section Fill Pen: Backgrounds - color 1; Threshold Section Fill Background Pen: Backgrounds - color 1; Sill 3D and Uncut Pen: General - General; Sill Section Contour Pen: General - General; Sill Section Fill Type: Air Space; Sill Section Fill Pen: Backgrounds - color 1; Sill Section Fill Background Pen: Backgrounds - color 1; Section Insulation Contour Pen: General - General; Section Insulation Fill Type: Rigid Insulation; Section Insulation Fill Pen: General - General; Section Insulation Fill Background Pen: Backgrounds - color 1; Board 3D and Uncut Pen: General - General; Board Section Contour Pen: General - General; Board Section Fill Type: Air Space; Board Section Fill Pen: Backgrounds - color 1; Board Section Fill Bkg. Pen: Backgrounds - color 1; Casing Fill Type Inside: Air Space; Casing Fill Pen Inside: Backgrounds - color 1; Casing Fill Background Pen Inside: Backgrounds - color 1; Casing Fill Type Outside: Air Space; Casing Fill Pen Outside: Backgrounds - color 1; Casing Fill Background Pen Outside: Backgrounds - color 1; Arch Section Fill Type: Background; Arch Section Fill Pen: Backgrounds - color 1; Arch Section Fill Bkg. Pen: Backgrounds - color 1; Sunshade Symbol Line Type: 1; Sunshade Cut Line Pen: General - General; 3D/Section Uncut Line Pen: General - General; Sunshade Cut Fill Type: Background; Sunshade Cut Fill Pen: General - General; Sunshade Cut Fill Background Pen: Window Background; Sunshade Insulation Fill Type: Batt Insulation; Sunshade Insulation Fill Pen: General - General; Sunshade Insulation Background Pen: Window Background; Uncut Fill Type: Background; Uncut Fill Pen: Backgrounds - color 1; Uncut Fill Background Pen: Backgrounds - color 1; Opening Side Values (gs_opside_list): Custom; Opening Side Values (gs_opside_list_m): 0; Frame Element Joinery (gs_SashText_typ): Butt Joint; Frame Element Joinery (gs_SashText_typ_num): 2; Frame Pen: Openings - General; Leaf Pen: Openings - General; Sash Glass Pen: Openings - Cut Non-Structural; Leaf Glass Pen: Openings - Cut Non-Structural; Masonry Arch Pen: Walls/Curtain Walls - General; Curve Resolution: 24; Shadow: yes; Uniform Door Surfaces: no; Leaf Outside: Metal - Aluminium; Leaf Inside: Metal - Aluminium; Leaf 2: Wood - Pine Grained Horizontal; Leaf 3: Wood - Pine Grained Horizontal; Lock: Paint - Anthracite; Grid Outside (gs_grill_mat): Wood - Pine Grained Horizontal; Grid Inside (gs_grill_mat2): Wood - Pine Grained Horizontal; Grid Outside (gs_leaf_grill_mat): Wood - Pine Grained Horizontal; Grid Inside (gs_leaf_grill_mat2): Wood - Pine Grained Horizontal; Solid Panel Outside: Wood - Pine Grained Horizontal; Solid Panel Inside: Wood - Pine Grained Horizontal; Sash Glass: Glass - Clear Fast; Leaf Glass: Glass - Clear Fast; Rail (gs_rail_mat): Metal - Iron; Louver Outside: Wood - Pine Grained Horizontal; Louver Inside: Wood - Pine Grained Horizontal; Kick Plate: Metal - Aluminium; Uniform Casing Surfaces: yes; Interior Casing: Wood - Pine Grained Horizontal; Exterior Casing: Wood - Pine Grained Horizontal; Shutter Panel: Wood - Pine Grained Horizontal; Shutter Panel Frame: Wood - Pine Grained Horizontal; Rolling Shutter Box: Metal - Stainless Steel; Rolling Shutter Blades: Paint - Glossy White; Rolling Shutter Rail: Paint - Glossy White; Venetian Blinds Box: Metal - Stainless Steel; Venetian Blinds Segments: Paint - Glossy White; Sliding Shutter Rail: Metal - Stainless Steel; Threshold (gs_treshold_mat): Wood - Pine Grained Horizontal; Threshold Metal: Metal - Aluminium; Sill (gs_sill_mat): Brick - Running Bond; Brick Sill Mortar: Stucco - White Rough; Board (gs_board_mat): Wood - Pine Grained Horizontal; Handle: Metal - Stainless Steel; Handle Accessories: Metal - Iron; Kick Board Outside (matKickBoardOut): Metal - Stainless Steel; Kick Board Inside (matKickBoardIn): Metal - Stainless Steel; Masonry Arch Brick: Brick - Running Bond; Masonry Arch Mortar: Stucco - White Rough; Masonry Arch Keystone: Stone - Sandstone 01; Niche: Paint - Lead Oxide Yellow; Door belongs to the Zone into which it opens: yes; Cost: 0; Location as: Custom; Total Glazed Area (gs_list_glassarea_tmp): 0; Override Glazed Area: no; Total Glass Perimeter: 0; Group Type (FM_Type): Default Objects; Group Type (iFMType): 1; Object Weight: 0; Object Weight Unit: kg; Door Orientation Definition: 1; Door Closer: no; Vision Panel Type: No Vision Panel; Hold Open Device: no; IFC Operation (ifc_optypestr): Other; IFC Operation (ifc_optype): 12
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Sill/Header Value: 0.27 m; W/D Nominal Sill Height: 0.27 m; Elevation to Project Zero: 0.27 m; Elevation to 1st Reference Level: 0.27 m; Elevation to 2nd Reference Level: 0.27 m; Elevation to Sea Level: 9.61 m; Elevation to Linked/Home Story: 0.27 m; Home Offset: 0.27 m; Bottom Elevation To First Reference Level: 0.27 m; Bottom Elevation To Home Story: 0.27 m; Bottom Elevation To Project Zero: 0.27 m; Bottom Elevation To Sea Level: 9.61 m; Bottom Elevation To Second Reference Level: 0.27 m
AC_Equantity_Pocket_Double_Door_27 - Z Dimension: 1 m; Bottom Level: 1 m; Top Level: 0 m; Sill Height to Current Story: 0.27 m; Reveal to Wall Core: 0 m; New Wall Fill Width Right: 0.15 m; New Wall Fill Width Left: 0.15 m; Pivot Axis Offset: 0.275 m; Tolerance Right: 0 m; Tolerance Side 1 Lower: 0 m; Tolerance Sidelight 1 Bottom: 0 m; Tolerance Left: 0 m; Tolerance Side 2 Lower: 0 m; Tolerance Sidelight 2 Bottom: 0 m; Tolerance Upper: 0 m; Tolerance Lower: 0 m; Frame Thickness: 0.19 m; Frame Thickness Inside: 0.115 m; Leaf Offset: 0.01 m; Frame Width Side 1: 0.04 m; Middle Frame Width Side 1: 0.04 m; Bottom Frame Width Side 1: 0.04 m; Frame Width Side 2: 0.04 m; Middle Frame Width Side 2: 0.04 m; Bottom Frame Width Side 2: 0.04 m; Transom Frame Width (gs_frame_width_transom): 0.04 m; Upper Frame Width: 0.04 m; Door Stop Thickness: 0 m; Door Stop Width: 0 m; Rebate Width: 0 m; Leaf Rebate Depth in 3D: 0.04 m; Sidelight and Transom Rebate Width: 0.01 m; Sidelight and Transom Rebate Depth: 0.018 m; Pocket Frame Thickness: 0.023 m; Leaf Frame Width Side: 0.05 m; Leaf Frame Width Right: 0.1 m; Leaf Frame Width Left: 0.1 m; Leaf Frame Width Lower: 0.05 m; Leaf Frame Width Upper: 0.05 m; Leaf Frame Width Internal: 0.025 m; Leaf Undercut: 0 m; Grid Width: 0.012 m; Grid Thickness: 0.025 m; Handle Height: 1 m; Handle Position: 0.05 m; Kick Board Height: 0.1 m; Horizontal Division Height Sidelight Side 1: 0.9 m; Horizontal Division Height Sidelight Side 2: 0.9 m; Horizontal Division Height Middle Transom: 0.9 m; Horizontal Division Height Transom Side 1: 0.9 m; Horizontal Division Height Transom Side 2: 0.9 m; Sidelight and Transom Frame Thickness: 0.044 m; Transom Frame Width (gs_sash_width): 0.067 m; Sidelight Frame Width: 0.067 m; Grill Width: 0.02 m; Grill Thickness: 0.025 m; Sidelight Division Width: 0.04 m; Sidelight Width Right (gs_sidelight_width_right): 0 m; Sidelight Width Right (gs_sidelight_width_right_half): 0.15 m; Sidelight Width Right (gs_sidelight_width_right_orig): 0.3 m; Side 1 Sill Height: 0 m; Sidelight Width Left (gs_sidelight_width_left): 0 m; Sidelight Width Left (gs_sidelight_width_left_half): 0.15 m; Sidelight Width Left (gs_sidelight_width_left_orig): 0.3 m; Side Sill Height: 0 m; Transom Height: 0.3 m; Architrave Capital Width: 0.02 m; Width Side 1 (gs_tw_right_out): 0.05 m; Width Side 2 (gs_tw_left_out): 0.05 m; Width Top (gs_tw_top_out): 0.05 m; Thickness on Wall (gs_trim_thk_out): 0.019 m; Thickness in Wallhole (gs_trim_width_out): 0.025 m; Offset (gs_trim_offs_out): 0.012 m; Nosing (gs_trim_jambext_nosing_out): 0.05 m; Top Overhang (gs_trimov_top_left_out): 0.1 m; Top Overhang (gs_trimov_top_right_out): 0.1 m; Width Side 1 (gs_tw_right_in): 0.05 m; Width Side 2 (gs_tw_left_in): 0.05 m; Width Top (gs_tw_top_in): 0.05 m; Thickness on Wall (gs_trim_thk_in): 0.019 m; Thickness in Wallhole (gs_trim_width_in): 0.025 m; Offset (gs_trim_offs_in): 0.012 m; Nosing (gs_trim_jambext_nosing_in): 0.05 m; Top Overhang (gs_trimov_top_left_in): 0.1 m; Top Overhang (gs_trimov_top_right_in): 0.1 m; Threshold Thickness: 0.012 m; Threshold Width: 0 m; Threshold External Thickness: 0.00580738 m; Threshold Nosing Outside: 0.025 m; Threshold Nosing Inside: 0.025 m; Side Overhang Outside: 0 m; Side Overhang Inside: 0 m; Sill Thickness: 0.1 m; Sill Front Side Thickness: 0.015 m; Sill Elevation: 0.005 m; Sill Drip Overlap: 0.02 m; Sill Drip Width: 0.03 m; Sill Nosing: 0.03 m; Sill Overhang Side 1: 0 m; Sill Overhang Side 2: 0 m; Sill Slip-in Depth: 0.02 m; Sill Top Width: 0.01 m; Sill Top Height: 0.01 m; Sill Slip from Wall: 0 m; Rear Hole Depth (gs_sill_holeDepthBehind): 0 m; Width of Sill: 0 m; Brick Thickness (gs_brick_sill_br_thk): 0.065 m; Mortar Thickness (gs_brick_sill_mort_thk): 0.015 m; Board Width: 0.1 m; Board Thickness: 0.025 m; Board Nosing: 0.03 m; Board Overhang Side 1: 0 m; Board Overhang Side 2: 0 m; Board Slip-in Depth: 0 m; Inner Offset: 0.02 m; Closing Depth: 0 m; Extra Frame Width: 0.04 m; Extra Frame Thickness: 0.03 m; Rail Width: 0.03 m; Hanging Stick Length: 0.02 m; Hanging Stick Radius: 0.005 m; Panel Distance: 0.006 m; Outside Overhang: 0 m; Inner Panel Width: 0.12 m; 3D Opening Length: 1.5 m; 3D Closed Length: 0 m; 3D Opening Length 1: 0.56 m; 3D Opening Length 2: 0.14 m; 3D Closed Height: 0 m; Panel Thickness: 0.05 m; Panel Frame Width: 0.05 m; Frame Width Bottom: 0.05 m; Panel Fill Thickness: 0.01 m; Louver Thickness: 0.01 m; Louver Width: 0.04 m; Horizontal Frame Divider Width: 0.05 m; Vertical Frame Divider Width: 0.05 m; Hole Radius: 0.01 m; Vertical Board Width: 0.1 m; Z Frame Width: 0.05 m; Z Frame Thickness: 0.025 m; Vertical Boards Thickness: 0.025 m; Horizontal Boards Thickness: 0.025 m; Vertical Boards Approximate Width: 0.08 m; Horizontal Boards Approximate Width: 0.115 m; Box Depth (gs_shutRoll_boxWidth): 0.15 m; Distance from Wall (gs_shutRoll_distFromWall): 0 m; Distance from Header (gs_shutRoll_distFromHead): 0 m; Slat Width: 0.05 m; Box Height (gs_shutLam_boxHeight): 0.2 m; Box Depth (gs_shutLam_boxWidth): 0.15 m; Cover Width: 0 m; Distance from Wall (gs_shutLam_distFromWall): 0 m; Distance from Header (gs_shutLam_distFromHead): 0 m; Segment Width (gs_shutLam_segmentWidth): 0.06 m; Box Height (gs_shutLam2_boxHeight): 0.06 m; Box Width: 0.06 m; Distance from Window: 0.06 m; Distance from Header (gs_shutLam2_distFromHead): 0.06 m; Box Axis Height from Header: 0 m; Segment Width (gs_shutLam2_segmentWidth): 0.06 m; Distance between Arch and Door: 0 m; Masonry Arch Overhang Side 1: 0 m; Masonry Arch Overhang Side 2: 0 m; Masonry Arch Rise: 0.03 m; Masonry Arch Projection: 0 m; Masonry Arch Height: 0.25 m; Masonry Arch Depth: 0.12 m; Rear Hole Depth (gs_masonry_arch_rearHoleDepth): 0 m; Brick Thickness (gs_masonry_arch_brick_thk): 0.065 m; Mortar Thickness (gs_masonry_arch_mort_thk): 0.01 m; Keystone Width: 0.1 m; Keystone Oversize: 0 m; Keystone Projection: 0.01 m; Reveal Depth (gs_wido_sill): 0 m; Reveal Depth (AC_wido_sill): 0 m; Jamb Depth: 0.06 m; Jamb Depth Side 2: 0.06 m; Lower Jamb Depth Side 1: 0.06 m; Lower Jamb Depth Side 2: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_splayed_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_splayed_innerRight): 0.06 m; Inner Jamb Depth (gs_reveal_double_innerRight): 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_double_innerLeft): 0.06 m; Inner Lower Jamb Depth Side 1: 0.06 m; Inner Lower Jamb Depth Side 2: 0.06 m; Head Depth: 0.06 m; Sill Depth: 0.06 m; Sill Depth Side 1: 0.06 m; Sill Depth Side 2: 0.06 m; Inner Head Depth (gs_reveal_splayed_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_splayed_innerBottom): 0.06 m; Inner Head Depth (gs_reveal_double_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_double_innerBottom): 0.06 m; Inner Sill Depth Side 1: 0 m; Inner Sill Depth Side 2: 0 m; Outer Jamb Depth: 0.08 m; Plaster Thickness Limit: 0.04 m; Distance of Skin from Closer: 0 m; Closer Width: 0.038 m; Closer Thickness: 0.1 m; Strip Thickness: 0.025 m; Profile Width: 0.15 m; Custom Thickness: 0.015 m; Skin Overhang to Frame Depth: 0 m; Left Opening Oversize: 0 m; Right Opening Oversize: 0 m; Upper Opening Oversize: 0 m; Lower Opening Oversize: 0 m; Opening Width in 3D on Side 2: 0 m; Opening Width in 2D: 0 m; Opening Width in 2D on Side 2: 0 m; Opening Distance 1 Main Sash Side 1: 0 m; Opening Distance 2 Main Sash Side 1: 0 m; Opening Distance 1 Main Sash Side 2: 0 m; Opening Distance 2 Main Sash Side 2: 0 m; Opening Distance 1 Middle Transom: 0 m; Opening Distance 2 Middle Transom: 0 m; Opening Distance 1 Transom Side 1: 0 m; Opening Distance 2 Transom Side 1: 0 m; Opening Distance 1 Transom Side 2: 0 m; Opening Distance 2 Transom Side 2: 0 m; Opening Width in 3D (gs_open): 0.1 m; Opening Side Depth: 1.2 m; Opposite Side Depth: 1.2 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m
1 AMB.Identificacio - 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
Name | Classification | Reveal Dimensions = Wallhole Dimensions = Nominal W x H Size | Unit Dimensions | Egress Dimensions = Leaf Dimensions | Nominal W x H x T Size | Wall Structure | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Layer | Colliding Zones | Parent ID | Surfaces (All) | Wall Type | Wall Direction Type | Opening Direction | Parapet Wall Inset Value | Frame Thickness=Wall Thickness | Pocket Frame = Sunshade | Sunshade Type | Panel Position (gs_shutter_panelPos) | Rolling Shutter Placement (gs_shutRoll_placement) | Rolling Shutter Placement (gs_shutRoll_iPlacement) | Box Default Width (gs_shutRoll_boxDefaultSize) | Frame Outside = Frame Inside | Total Glazed Area (gs_list_glassarea) | Door Leaf Widths | Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) = Volume (Net) (m3) | 502.AMB.Amplada (m) = W/D Opening Width on the Reveal Side (m) = Nominal W/D Opening Width on the Reveal Side (m) = Nominal W/D Opening Width on the Side Opposite to the Reveal Side (m) = Width (m) = Wallhole Width (m) = Reveal Width (m) | 503.AMB.Altura (m) = W/D Opening Height on the Reveal Side (m) = Nominal W/D Opening Height on the Reveal Side (m) = Nominal W/D Opening Height on the Side Opposite to the Reveal Side (m) = Height (m) = Wallhole Height (m) = Reveal Height (m) = Unit Height (m) | W/D Opening Opening Volume (m3) | W/D Opening Nominal Volume (m3) | W/D Opening Surface Area (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | W/D Opening Nominal Surface Area (m2) = W/D Opening Surface Area on the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | W/D Opening Width on the Side Opposite to the Reveal Side (m) | W/D Opening Height on the Side Opposite to the Reveal Side (m) | W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | W/D Sill Height on the Reveal Side (m) = W/D Sill Height on the Side Opposite to the Reveal Side (m) | W/D Nominal Head Height (m) | W/D Head Height on the Reveal Side (m) = W/D Head Height on the Side Opposite to the Reveal Side (m) | Wall Thickness (m) | Frame Thickness (m) = Real Frame Thickness (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | AUX_104.AMB.ClassificacioCodiCateg | AUX_107.NomTipus | Shoulder Height (m) | Unit Width (m) | Egress Width (m) = Nominal Leaf Width (m) | Egress Height (m) = Nominal Leaf Height (m) | Frame Width (m) | Nominal Leaf Width Side 1 (m) | Leaf Thickness (m) | Glass Thickness (m) | Sidelight Division Thickness (m) | Panel Height (m) = 3D Opening Height (m) | Panel Width (m) | Box Height (gs_shutRoll_boxHeight) (m) | Box Left Offset (m) = Box Right Offset (m) | Depth of Rails (m) | Opening Width in 3D (gs_open3D) (m) | Width 2 (m) = Width 1 (m) = Opposite Side Width 2 (m) = Opposite Side Width 1 (m) | Opposite Side Width (m) | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 111.AMB.DescripcioTipus
PE001 | 30.10.20.20 Portes de façanes (GuBIMclass CA) | 2.000,0×2.600,0 | 2.000,0×2.600,0 | 2.000,0×2.600,0 | 2.000,0×2.600,0×400,0 | Concrete 15-10-15 | PE001 | 00_MURO HORMIGON | Nau Santa Eulàlia | F2 | Glass - Clear Fast; Metal - Aluminium | 0 | 0 | 0 | 3 | yes | no | 1 | Symmetric | On Facade | 1 | Reveal Width | Metal - Aluminium | 4.5 | 1,00 / 1,00 | 0.021 | 2 | 2.6 | 2.08 | 2.08 | 11.536 | 5.2 | 2 | 2.6 | 5.2 | 0.45 | 2.87 | 3.05 | 0.4 | 0.4 | 2.87 | 12.21 | 30 | PortaExtTipusU | 2.585 | 2 | 2 | 2.6 | 0 | 0.7 | 0.03 | 0.02 | 0.04 | 1.5 | 0 | 0.2 | 0 | 0.0725 | 0 | 0 | 2 | 30.10.20.20 Portes de façanes | 30.10.20.20 | Portes de façanes | PE001_PortaExtTipusU | Porta corredissa automàtica | 4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60; 2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
PE004 | 30.10.20.20 Portes de façanes (GuBIMclass CA) | 2.400,0×2.600,0 | 2.400,0×2.600,0 | 2.400,0×2.600,0 | 2.400,0×2.600,0×400,0 | Concrete 15-10-15 | PE004 | 00_MURO HORMIGON | Nau Santa Eulàlia | F2 | Glass - Clear Fast; Metal - Aluminium | 0 | 1 | 1 | 2 | yes | no | 1 | Symmetric | On Facade | 1 | Reveal Width | Metal - Aluminium | 5.5 | 1,20 / 1,20 | 0.0222 | 2.4 | 2.6 | 2.496 | 2.496 | 13.68 | 6.24 | 2.4 | 2.6 | 6.24 | 0.45 | 2.87 | 3.05 | 0.4 | 0.4 | 2.87 | 12.21 | 30 | PortaExtTipusU | 2.585 | 2.4 | 2.4 | 2.6 | 0 | 0.7 | 0.03 | 0.02 | 0.04 | 1.5 | 0 | 0.2 | 0 | 0.0725 | 0 | -0.2 | 2 | 30.10.20.20 Portes de façanes | 30.10.20.20 | Portes de façanes | PE004_PortaExtTipusU | Porta corredissa automàtica | 4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60; 2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
PI012 | 80.10.40.20 Portes d'accés (GuBIMclass CA) | 1.410,0×3.360,0 | 2.756,0×3.360,0 | 1.350,0×3.330,0 | 1.410,0×3.360,0×160,0 | Concrete 40-20 (2) | PI012 | 00_TABIQUE | Nau Santa Eulàlia | F1 | Metal - Stainless Steel; Wood - Pine Grained Horizontal; Glass - Clear Fast; Metal - Aluminium; Paint - Glossy White | 1 | 0 | 1 | 2 | no | yes | 6 | Symmetrical | Behind Facade | 3 | To Reveal Width | Wood - Pine Grained Horizontal | 3.7145 | 68 / 68 | 0.0922897 | 1.41 | 3.36 | 0.970192 | 0.758016 | 20.9494 | 4.7376 | 2.12257 | 3.46 | 4.94986 | 0 | 3.63 | 3.26 | 0.16 | 0.19 | 3.73 | 13.07 | 80 | PortaIntTipusF | 2.95482 | 2.756 | 1.35 | 3.33 | 0.03 | 0.675 | 0.02 | 0.012 | 0.05 | 3.36 | 0.705 | 0.1 | 0.7 | 0.01 | 0.675 | 0.295 | 1.94 | 80.10.40.20 Portes d'accés | 80.10.40.20 | Portes d'accés | PI012_PortaIntTipusF | Porta de pi amb doble fulla corredissa de 72.5cm
PI011 | 80.10.40.20 Portes d'accés (GuBIMclass CA) | 1.410,0×3.360,0 | 2.756,0×3.360,0 | 1.350,0×3.330,0 | 1.410,0×3.360,0×160,0 | Concrete 40-20 (2) | PI011 | 00_TABIQUE | Espai d'espera; Nau Santa Eulàlia | F1 | Metal - Stainless Steel; Wood - Pine Grained Horizontal; Glass - Clear Fast; Metal - Aluminium; Paint - Glossy White | 1 | 1 | 1 | 2 | no | yes | 6 | Symmetrical | Behind Facade | 3 | To Reveal Width | Wood - Pine Grained Horizontal | 3.7145 | 68 / 68 | 0.0922897 | 1.41 | 3.36 | 0.866828 | 0.758016 | 20.9494 | 4.7376 | 1.737 | 3.46 | 4.9113 | 0 | 3.63 | 3.26 | 0.16 | 0.19 | 3.73 | 13.07 | 80 | PortaIntTipusF | 2.95482 | 2.756 | 1.35 | 3.33 | 0.03 | 0.675 | 0.02 | 0.012 | 0.05 | 3.36 | 0.705 | 0.1 | 0.7 | 0.01 | 0.675 | 0.295 | 1.94 | 80.10.40.20 Portes d'accés | 80.10.40.20 | Portes d'accés | PI011_PortaIntTipusF | Porta de pi amb doble fulla corredissa de 72.5cm

# IfcBuildingElementProxy: RHS 40x40x4 50 x 50 (11)
In: planta coberta
Classification: 20.20.10.10 Pilars (GuBIMclass CA); Material: Steel - Structural
ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -53.973 deg; Element ID: BMR - 007; Hotlink and Element ID: BMR - 007; Building Material / Composite / Profile / Fill: RHS 40x40x4; Complex Profile: RHS 40x40x4; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Beam; Structure Type: Complex Profile; Profile Category: RHS 40x40x4; Parent ID: BMR - 007; Building Materials (All): Steel - Structural; Surfaces (All): Paint - Light Gray; Cover Fill: Background; Slant Angle: -53.973 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 20.20.10.10 Pilars; 104.AMB.ClassificacioCodi: 20.20.10.10; 105.AMB.ClassificacioDescripcio: Pilars; 107.AMB.NomTipus: BMR - 007_; 109.AMB.CodiTipus: BMR - 007; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Si
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 20
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Steel - Structural, Component Type: Core
ArchiCADQuantities - Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Length Left: 0.544057 m; Length Right: 0.544057 m; Offset: 0 m; Height: 0.05 m; Width: 0.05 m; Volume (Gross): 0.000400426 m3; Cross Section Height at Top/End (perpendicular): 0.05 m; Cross Section Height at Bottom/Start (perpendicular): 0.05 m; Cross Section Width at Top/End (perpendicular): 0.05 m; Cross Section Width at Bottom/Start (perpendicular): 0.05 m; Cross Section Height at Top/End (cut): 0.0850099 m; Cross Section Height at Bottom/Start (cut): 0.0850099 m; Cross Section Width at Top/End (cut): 0.05 m; Cross Section Width at Bottom/Start (cut): 0.05 m; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.05 m; 503.AMB.Altura: 0.05 m; 506.AMB.Profunditat: 0 m
Component Quantities - Steel - Structural, Component Cross Section Area: 0.000736 m2
Name | Layer | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | Surface Area of Both Beam Ends (m2) | Surface Area of the Beam Left Side (Net) (m2) | Surface Area of the Beam Right Side (Net) (m2) | Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Surface Area (m2) | 3D Length (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) = Bottom Surface Area (Net) (m2) | Steel - Structural, Mass (kg)
BMR - 007 | 00_ACERO VIGAS | 5.17925 (kgCO₂) | 78.3127 | 0.00125135 | 0.0500005 | 0.0500005 | 0.0159829 | 0.000400004 | 2.43473 | 11.7747 | -2.06527 | 0.202505 | 0.612234 | 2.47677 | -2.02323 | 11.8168 | 1.95223 | -2.54777 | 11.2922 | 0 | 0.00125135 | 0.0500005 | 3.12003 | ArchiCADProperties - Colliding Zones: Nau Lateral
BMR - 007 | 00_ACERO VIGAS | 5.17925 (kgCO₂) | 78.3128 | 0.00125135 | 0.0500068 | 0.0499942 | 0.015983 | 0.000400004 | 5.09175 | 14.4317 | 0.591747 | 0.202505 | 0.612309 | 5.13425 | 0.634252 | 14.4743 | 4.60965 | 0.109645 | 13.9496 | 0.00125135 | 0 | 0.0500005 | 3.12003
BMR - 007 | 00_ACERO VIGAS | 5.17925 (kgCO₂) | 78.3127 | 0.00125135 | 0.0500005 | 0.0500005 | 0.0159829 | 0.000400004 | 3.49873 | 12.8387 | -1.00127 | 0.202505 | 0.612234 | 3.54077 | -0.959226 | 12.8808 | 3.01623 | -1.48377 | 12.3562 | 0 | 0.00125135 | 0.0500005 | 3.12003 | ArchiCADProperties - Colliding Zones: Nau Lateral
BMR - 007 | 00_ACERO VIGAS | 5.17925 (kgCO₂) | 78.3128 | 0.00125135 | 0.0500068 | 0.0499942 | 0.015983 | 0.000400004 | 4.02775 | 13.3677 | -0.472253 | 0.202505 | 0.612309 | 4.07025 | -0.429748 | 13.4103 | 3.54565 | -0.954354 | 12.8856 | 0.00125135 | 0 | 0.0500005 | 3.12003 | ArchiCADProperties - Colliding Zones: Nau Lateral
BMR - 007 | 00_ACERO VIGAS | 5.18472 (kgCO₂) | 78.3954 | 0.00250269 | 0.0500533 | 0.0500533 | 0.0159998 | 0.000400426 | 5.75974 | 15.0997 | 1.25974 | 0.202716 | 0.612808 | 5.80225 | 1.30225 | 15.1422 | 5.27724 | 0.777238 | 14.6172 | 0.00125135 | 0.00125135 | 0.0500533 | 3.12332
BMR - 007 | 00_ACERO VIGAS | 5.18423 (kgCO₂) | 78.3881 | 0.00125514 | 0.050047 | 0.050047 | 0.0159987 | 0.000400389 | 6.28876 | 15.6288 | 1.78876 | 0.202697 | 0.612808 | 6.33126 | 1.83126 | 15.6713 | 5.80625 | 1.30625 | 15.1463 | 0.000627568 | 0.000627568 | 0.0500501 | 3.12303
BMR - 007 | 00_ACERO VIGAS | 5.18472 (kgCO₂) | 78.3954 | 0.00250269 | 0.0500533 | 0.0500533 | 0.0159998 | 0.000400426 | 6.82374 | 16.1637 | 2.32374 | 0.202716 | 0.612808 | 6.86625 | 2.36625 | 16.2062 | 6.34124 | 1.84124 | 15.6812 | 0.00125135 | 0.00125135 | 0.0500533 | 3.12332
BMR - 007 | 00_ACERO VIGAS | 5.17925 (kgCO₂) | 78.3127 | 0.00125135 | 0.0500005 | 0.0500005 | 0.0159829 | 0.000400004 | 4.56273 | 13.9027 | 0.0627323 | 0.202505 | 0.612234 | 4.60477 | 0.104773 | 13.9448 | 4.08023 | -0.419773 | 13.4202 | 0 | 0.00125135 | 0.0500005 | 3.12003 | ArchiCADProperties - Colliding Zones: Nau Lateral
BMR - 007 | 00_ACERO VIGAS | 5.18423 (kgCO₂) | 78.3881 | 0.00125514 | 0.050047 | 0.050047 | 0.0159987 | 0.000400389 | 7.35276 | 16.6928 | 2.85276 | 0.202697 | 0.612808 | 7.39526 | 2.89526 | 16.7353 | 6.87025 | 2.37025 | 16.2103 | 0.000627568 | 0.000627568 | 0.0500501 | 3.12303
BMR - 007 | 00_ACERO PILARES | 5.18472 (kgCO₂) | 78.3954 | 0.00250269 | 0.0500533 | 0.0500533 | 0.0159998 | 0.000400426 | 7.88774 | 17.2277 | 3.38774 | 0.202716 | 0.612808 | 7.93025 | 3.43025 | 17.2702 | 7.40524 | 2.90524 | 16.7452 | 0.00125135 | 0.00125135 | 0.0500533 | 3.12332
BMR - 007 | 00_ACERO VIGAS | 5.17925 (kgCO₂) | 78.3128 | 0.00125135 | 0.0500068 | 0.0499942 | 0.015983 | 0.000400004 | 2.96375 | 12.3037 | -1.53625 | 0.202505 | 0.612309 | 3.00625 | -1.49375 | 12.3463 | 2.48165 | -2.01835 | 11.8216 | 0.00125135 | 0 | 0.0500005 | 3.12003 | ArchiCADProperties - Colliding Zones: Nau Lateral

# IfcBuildingElementProxy: RHS 60x60 60 x 60 (4)
In: planta coberta
Classification: 20.20.10.60 Tensors verticals (GuBIMclass CA); Material: Steel - Structural
ArchiCADProperties - Beam Cross Section: Profiled; Element ID: BMR - 007; Hotlink and Element ID: BMR - 007; Layer: 00_ACERO VIGAS; Building Material / Composite / Profile / Fill: RHS 60x60; Complex Profile: RHS 60x60; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Beam; Structure Type: Complex Profile; Profile Category: RHS 60x60; Parent ID: BMR - 007; Building Materials (All): Steel - Structural; Surfaces (All): Paint - Light Gray; Cover Fill: Background; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 20.20.10.60 Tensors verticals; 104.AMB.ClassificacioCodi: 20.20.10.60; 105.AMB.ClassificacioDescripcio: Tensors verticals; 107.AMB.NomTipus: BMR - 007_; 109.AMB.CodiTipus: BMR - 007; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Si
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 20
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Steel - Structural, Component Type: Core
ArchiCADQuantities - Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Offset: 0 m; Height: 0.06 m; Width: 0.06 m; Cross Section Height at Top/End (perpendicular): 0.06 m; Cross Section Height at Bottom/Start (perpendicular): 0.06 m; Cross Section Width at Top/End (perpendicular): 0.06 m; Cross Section Width at Bottom/Start (perpendicular): 0.06 m; Cross Section Width at Top/End (cut): 0.06 m; Cross Section Width at Bottom/Start (cut): 0.06 m; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.06 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Steel - Structural, Component Cross Section Area: 0.000896 m2
Name | Beam Slant Angle (deg) = Slant Angle (deg) | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | Surface Area of Both Beam Ends (m2) | Surface Area of the Beam Left Side (Net) (m2) | Length Left (m) = Length Right (m) | Surface Area of the Beam Right Side (Net) (m2) | Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Cross Section Height at Top/End (cut) (m) = Cross Section Height at Bottom/Start (cut) (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) | Steel - Structural, Mass (kg)
BMR - 007 | -40.1841 | 43.6496 (kgCO₂) | 660.003 | 0.00218241 | 0.421686 | 3.78473 | 0.421686 | 0.172804 | 0.00337115 | 7.85445 | 17.1945 | 3.35445 | 1.69198 | 3.8354 | 0.00339111 | 7.89372 | 3.39372 | 17.2337 | 5.37311 | 0.873108 | 14.7131 | 0.0785366 | 0.00106195 | 0.00112045 | 0.419991 | 0.422208 | 26.2949
BMR - 007 | -40.5855 | 43.3857 (kgCO₂) | 656.013 | 0.00112715 | 0.416474 | 3.8078 | 0.416468 | 0.172282 | 0.00335076 | 7.84269 | 17.1827 | 3.34269 | 1.68449 | 3.84629 | 0.00341178 | 7.87379 | 3.37379 | 17.2138 | 5.3259 | 0.825899 | 14.6659 | 0.079006 | 0 | 0.00112715 | 0.42031 | 0.422129 | 26.136
BMR - 007 | -47.8774 | 48.9825 (kgCO₂) | 740.639 | 0.00133588 | 0.470167 | 4.26746 | 0.470159 | 0.17136 | 0.00378302 | 5.0088 | 14.3488 | 0.508799 | 1.89765 | 4.3245 | 0.00382364 | 5.04662 | 0.546619 | 14.3866 | 1.79885 | -2.70115 | 11.1388 | 0.0894561 | 0 | 0.00133588 | 0.475591 | 0.475591 | 29.5075 | ArchiCADProperties - Colliding Zones: Nau Lateral
BMR - 007 | -47.0687 | 48.4918 (kgCO₂) | 733.219 | 0.00263096 | 0.46814 | 4.17982 | 0.46814 | 0.170818 | 0.00374512 | 4.97929 | 14.3193 | 0.479292 | 1.87519 | 4.24431 | 0.00374512 | 5.02334 | 0.523337 | 14.3633 | 1.87491 | -2.62509 | 11.2149 | 0.08809 | 0.00131548 | 0.00131548 | 0.46814 | 0.46814 | 29.2119 | ArchiCADProperties - Colliding Zones: Nau Lateral

# IfcBuildingElementProxy: RHS 80x80 80 x 80 (3)
In: planta baixa
Classification: 30.10.10.20 Façanes prefabricades (GuBIMclass CA); Material: Steel - Structural
ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Extrusion Surface: Metal - Nickel; End Surface: Metal - Nickel; Element ID: PE102; Hotlink and Element ID: PE102; Layer: 00_TRAMEX PILARES; Building Material / Composite / Profile / Fill: RHS 80x80; Complex Profile: RHS 80x80; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Column; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Complex Profile; Profile Category: RHS 80x80; Parent ID: PE102; Building Materials (All): Steel - Structural; Surfaces (All): Metal - Nickel; Cover Fill: Background; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.20 Façanes prefabricades; 104.AMB.ClassificacioCodi: 30.10.10.20; 105.AMB.ClassificacioDescripcio: Façanes prefabricades; 107.AMB.NomTipus: PE102_TipusW; 109.AMB.CodiTipus: PE102; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: TipusW
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Steel - Structural, Embodied Carbon: 40.9364 (kgCO₂); Steel - Structural, Embodied Energy: 618.978 MJ; Steel - Structural, Component Type: Core
ArchiCADQuantities - Core Height / Diameter: 0.08 m; Volume of the Column Core (Net): 0.0031616 m3; Core Width: 0.08 m; Surface Area of the Column Core (Gross, without Top/Bottom): 1.5808 m2; Surface Area of the Column Core Top (Gross): 0.001216 m2; Surface Area of the Column Core Bottom (Gross): 0.001216 m2; Volume of the Column Core (Gross): 0.0031616 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 2.6 m; Minimum Height of the Column: 2.6 m; Surface Area of the Column Core Bottom (Net): 0.001216 m2; Surface Area of the Column Core (Net, without Top/Bottom): 1.5808 m2; Surface Area of the Column Core Top (Net): 0.001216 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 0.32 m; Volume of the Column Veneer (Net): 0 m3; Area: 0.001216 m2; Height: 2.6 m; Volume (Net): 0.0031616 m3; Width: 0.08 m; Elevation to Project Zero: 1.94511 m; Elevation to 1st Reference Level: 1.94511 m; Elevation to 2nd Reference Level: 1.94511 m; Elevation to Sea Level: 11.2851 m; Elevation to Linked/Home Story: 1.94511 m; Home Offset: 1.94511 m; Top Offset: 1.44108 m; Surface Area: 1.5808 m2; 3D Length: 2.6 m; Volume (Gross): 0.0031616 m3; Top Elevation To First Reference Level: 4.54511 m; Top Elevation To Home Story: 4.54511 m; Top Elevation To Project Zero: 4.54511 m; Top Elevation To Sea Level: 13.8851 m; Top Elevation To Second Reference Level: 4.54511 m; Bottom Elevation To First Reference Level: 1.94511 m; Bottom Elevation To Home Story: 1.94511 m; Bottom Elevation To Project Zero: 1.94511 m; Bottom Elevation To Sea Level: 11.2851 m; Bottom Elevation To Second Reference Level: 1.94511 m; Cross Section Height at Top/End (perpendicular): 0.08 m; Cross Section Height at Bottom/Start (perpendicular): 0.08 m; Cross Section Width at Top/End (perpendicular): 0.08 m; Cross Section Width at Bottom/Start (perpendicular): 0.08 m; Cross Section Height at Top/End (cut): 0.08 m; Cross Section Height at Bottom/Start (cut): 0.08 m; Cross Section Width at Top/End (cut): 0.08 m; Cross Section Width at Bottom/Start (cut): 0.08 m; Cross Section Area at Bottom/Start: 0.001216 m2; Cross Section Area at Top/End: 0.001216 m2; Number of Segments: 1; Top Surface Area (Net): 0.001216 m2; Bottom Surface Area (Net): 1.5808 m2; Top Surface Area (Gross): 0.001216 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.08 m; 503.AMB.Altura: 2.6 m; 506.AMB.Profunditat: 0 m
Component Quantities - Steel - Structural, Mass: 24.6605 kg; Steel - Structural, Component Cross Section Area: 0.001216 m2; Steel - Structural, Component Volume (Net): 0.0031616 m3; Steel - Structural, Component Volume (Gross): 0.0031616 m3

# IfcBuildingElementProxy: RHS100x100 100 x 100 (18)
Material: Steel - Structural
ArchiCADProperties - Building Material / Composite / Profile / Fill: RHS100x100; Complex Profile: RHS100x100; Locked: no; Structure Type: Complex Profile; Profile Category: RHS100x100; Building Materials (All): Steel - Structural; Surfaces (All): Paint - Light Gray; Cover Fill: Background; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Component Properties - Steel - Structural, Component Type: Core
Pset_BuildingElementProxyCommon - Status: NEW
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 20
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Si
1 AMB.Identificacio - 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
ArchiCADQuantities - Width: 0.1 m; Cross Section Height at Top/End (perpendicular): 0.1 m; Cross Section Height at Bottom/Start (perpendicular): 0.1 m; Cross Section Width at Top/End (perpendicular): 0.1 m; Cross Section Width at Bottom/Start (perpendicular): 0.1 m; Cross Section Width at Top/End (cut): 0.1 m; Cross Section Width at Bottom/Start (cut): 0.1 m; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.1 m; 506.AMB.Profunditat: 0 m
Component Quantities - Steel - Structural, Component Cross Section Area: 0.0019 m2
Name | In | Classification | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Layer | Home Story Name = 115.AMB.Nivell | Home Story Number | Element Type | Slant Angle (deg) | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | Area (m2) | Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) = Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Cross Section Height at Top/End (cut) (m) = Cross Section Height at Bottom/Start (cut) (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) | Steel - Structural, Mass (kg) | Beam Cross Section | Beam Slant Angle (deg) | Number of Openings = Hole Number = Holes Edge Surface Area (m2) = Holes Surface Area (m2) = Holes Volume (m3) = Offset (m) | Surface Area of Both Beam Ends (m2) | Surface Area of the Beam Left Side (Net) (m2) | Length Left (m) | Length Right (m) | Surface Area of the Beam Right Side (Net) (m2) | Volume (Conditional) (m3)
CRE - 008 | planta baixa | 20.20.10.10 Pilars (GuBIMclass CA) | CRE - 008 | 00_ACERO PILARES | planta baixa | 0 | Column | 90 | 73.2677 (kgCO₂) | 1107.84 | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | 0.0019 | 2.97822 | 0.00565861 | 1 | 10.34 | 1 | 2.26344 | 2.97822 | 0.00565861 | 3.97822 | 3.97822 | 13.3182 | 1 | 1 | 10.34 | 0.1 | 0.0019 | 0.0019 | 0.0019 | 2.26344 | 44.1372 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.1 m; Volume of the Column Core (Net): 0.00565861 m3; Core Width: 0.1 m; Surface Area of the Column Core (Gross, without Top/Bottom): 2.26344 m2; Surface Area of the Column Core Top (Gross): 0.0019 m2; Surface Area of the Column Core Bottom (Gross): 0.0019 m2; Volume of the Column Core (Gross): 0.00565861 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 2.97822 m; Minimum Height of the Column: 2.97822 m; Surface Area of the Column Core Bottom (Net): 0.0019 m2; Surface Area of the Column Core (Net, without Top/Bottom): 2.26344 m2; Surface Area of the Column Core Top (Net): 0.0019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 0.4 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.0019 m2
5 x CRE - 008 | planta baixa | 20.20.10.10 Pilars (GuBIMclass CA) | CRE - 008 | 00_ACERO PILARES | planta baixa | 0 | Column | 90 | 95.8503 (kgCO₂) | 1449.3 | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | 0.0019 | 3.89616 | 0.00740271 | 1 | 10.34 | 1 | 2.96108 | 3.89616 | 0.00740271 | 4.89616 | 4.89616 | 14.2362 | 1 | 1 | 10.34 | 0.1 | 0.0019 | 0.0019 | 0.0019 | 2.96108 | 57.7411 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.1 m; Volume of the Column Core (Net): 0.00740271 m3; Core Width: 0.1 m; Surface Area of the Column Core (Gross, without Top/Bottom): 2.96108 m2; Surface Area of the Column Core Top (Gross): 0.0019 m2; Surface Area of the Column Core Bottom (Gross): 0.0019 m2; Volume of the Column Core (Gross): 0.00740271 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 3.89616 m; Minimum Height of the Column: 3.89616 m; Surface Area of the Column Core Bottom (Net): 0.0019 m2; Surface Area of the Column Core (Net, without Top/Bottom): 2.96108 m2; Surface Area of the Column Core Top (Net): 0.0019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 0.4 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.0019 m2
CRE - 008 | planta baixa | 20.20.10.10 Pilars (GuBIMclass CA) | CRE - 008 | 00_ACERO PILARES | planta baixa | 0 | Column | 90 | 34.3697 (kgCO₂) | 519.687 | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | 0.0019 | 1.39707 | 0.00265444 | 4.89616 | 14.2362 | 4.89616 | 1.06178 | 1.39707 | 0.00265444 | 6.29324 | 6.29324 | 15.6332 | 4.89616 | 4.89616 | 14.2362 | 0.1 | 0.0019 | 0.0019 | 0.0019 | 1.06178 | 20.7046 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.1 m; Volume of the Column Core (Net): 0.00265444 m3; Core Width: 0.1 m; Surface Area of the Column Core (Gross, without Top/Bottom): 1.06178 m2; Surface Area of the Column Core Top (Gross): 0.0019 m2; Surface Area of the Column Core Bottom (Gross): 0.0019 m2; Volume of the Column Core (Gross): 0.00265444 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 1.39707 m; Minimum Height of the Column: 1.39707 m; Surface Area of the Column Core Bottom (Net): 0.0019 m2; Surface Area of the Column Core (Net, without Top/Bottom): 1.06178 m2; Surface Area of the Column Core Top (Net): 0.0019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 0.4 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.0019 m2
