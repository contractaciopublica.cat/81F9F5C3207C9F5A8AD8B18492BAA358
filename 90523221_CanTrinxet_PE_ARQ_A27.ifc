Properties of the parts of a building model (IFC2X3), part 95 of 99

# IfcBuildingElementProxy: TEJA 179 x 60 (325)
Name | Classification | Beam Slant Angle (deg) = Slant Angle (deg) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Renovation Status | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | AUX_107.NomTipus | Status | Fiberboard, Embodied Carbon | Fiberboard, Embodied Energy (MJ) | Surface Area of Both Beam Ends (m2) | Length Left (m) = Length Right (m) | Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Volume (Gross) (m3) = Fiberboard, Component Volume (Net) (m3) = Fiberboard, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Top Elevation To Sea Level (m) | Surface Area (m2) | 3D Length (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Cross Section Height at Top/End (cut) (m) | Cross Section Height at Bottom/Start (cut) (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) | Fiberboard, Mass (kg)
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 15.67 (kgCO₂) | 235.049 | 0.00794075 | 5.53632 | 0.959867 | 0.0212907 | 6.40825 | 15.7483 | 2.42809 | 5.55158 | 4.97006 | 14.3101 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.15609 | 1.26406 | 17.0326
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 16.2146 (kgCO₂) | 243.219 | 0.00794075 | 5.72875 | 0.993229 | 0.0220307 | 6.40825 | 15.7483 | 2.51221 | 5.74401 | 4.92221 | 14.2622 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.19628 | 1.30799 | 17.6245
36 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | -17.48 | Cu5 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 27.2909 (kgCO₂) | 409.364 | 0.00806364 | 9.64212 | 1.64624 | 0.0370801 | 10.4721 | 19.8121 | 4.22302 | 9.66083 | 7.51357 | 16.8536 | 0.0631938 | 0.0631938 | 0.00403182 | 0.00403182 | 2.01346 | 2.20149 | 29.6641
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 14.7485 (kgCO₂) | 221.228 | 0.00794075 | 5.21077 | 0.903424 | 0.0200387 | 6.40771 | 15.7477 | 2.28578 | 5.22603 | 5.05048 | 14.3905 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.08811 | 1.18973 | 16.031
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 14.0101 (kgCO₂) | 210.152 | 0.00794075 | 4.94988 | 0.858193 | 0.0190355 | 6.40771 | 15.7477 | 2.17174 | 4.96515 | 5.11536 | 14.4554 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.03363 | 1.13016 | 15.2284
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 15.4869 (kgCO₂) | 232.304 | 0.00794075 | 5.47165 | 0.948655 | 0.021042 | 6.40771 | 15.7477 | 2.39982 | 5.48691 | 4.9856 | 14.3256 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.14259 | 1.24929 | 16.8336
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 16.2253 (kgCO₂) | 243.38 | 0.00794075 | 5.73253 | 0.993886 | 0.0220452 | 6.40771 | 15.7477 | 2.51386 | 5.74779 | 4.92072 | 14.2607 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.19707 | 1.30886 | 17.6362
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 13.2717 (kgCO₂) | 199.076 | 0.00794075 | 4.689 | 0.812962 | 0.0180322 | 6.40771 | 15.7477 | 2.05769 | 4.70426 | 5.18024 | 14.5202 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 0.979156 | 1.0706 | 14.4258
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 15.67 (kgCO₂) | 235.049 | 0.00794075 | 5.53632 | 0.959867 | 0.0212907 | 6.40771 | 15.7477 | 2.42809 | 5.55158 | 4.96952 | 14.3095 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.15609 | 1.26406 | 17.0326
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 16.2146 (kgCO₂) | 243.219 | 0.00794075 | 5.72875 | 0.993229 | 0.0220307 | 6.40771 | 15.7477 | 2.51221 | 5.74401 | 4.92166 | 14.2617 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.19628 | 1.30799 | 17.6245
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 15.1253 (kgCO₂) | 226.88 | 0.00794075 | 5.3439 | 0.926506 | 0.0205507 | 6.40771 | 15.7477 | 2.34398 | 5.35916 | 5.01737 | 14.3574 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.11591 | 1.22012 | 16.4406
24 x Cu3 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -36.5 | Cu3 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 8.70541 (kgCO₂) | 130.581 | 0.00862962 | 3.1 | 0.443779 | 0.011828 | 6.63269 | 15.9727 | 1.35402 | 3.1 | 4.74096 | 14.081 | 0.0602756 | 0.074983 | 0.00478398 | 0.00384564 | 0.644145 | 0.701246 | 9.4624
19 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | -17.48 | Cu5 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 11.5818 (kgCO₂) | 173.727 | 0.00806364 | 4.09193 | 0.698633 | 0.0157361 | 8.80499 | 18.145 | 1.79681 | 4.11065 | 7.51357 | 16.8536 | 0.0631938 | 0.0631938 | 0.00403182 | 0.00403182 | 0.854477 | 0.934273 | 12.5889
14 x BMR - 004 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.48 | BMR - 004 | Existing | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | BMR - 004_ |  | Nau Lateral | Preexistències |  | EXISTING | 27.2909 (kgCO₂) | 409.364 | 0.00806364 | 9.64212 | 1.64624 | 0.0370801 | 10.4721 | 19.8121 | 4.22302 | 9.66083 | 7.51357 | 16.8536 | 0.0631938 | 0.0631938 | 0.00403182 | 0.00403182 | 2.01346 | 2.20149 | 29.6641

# IfcBuildingElementProxy: Tile - Wall 20 (5)
In: planta baixa
Classification: 40.10.20.10 Revestiments discontinus (GuBIMclass CA); Material: Tile - Wall
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Inside Face Surface: Tiles - Terracota Rojo 10x20; Outside Face Surface: Tiles - Terracota Rojo 10x20; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Layer: 00_PLAYWOOD; Building Material / Composite / Profile / Fill: Tile - Wall; Building Material: Tile - Wall; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Building Materials (All): Tile - Wall; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Tiles - Terracota Rojo 10x20; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40; AUX_107.NomTipus: Extradossat_170
Pset_BuildingElementProxyCommon - Status: NEW
5 AMB.Geometria - 502.AMB.Amplada: 0.02 m; 503.AMB.Altura: 2.7 m; 504.AMB.Gruix: 0.02 m; 506.AMB.Profunditat: 0 m
Component Quantities - Tile - Wall, Component Thickness: 0.02 m; Tile - Wall, Rectangular Component Height: 2.7 m; Tile - Wall, Rectangular Component Width: 0.02 m; Tile - Wall, Component Cross Section Area: 0.054 m2
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 2.7 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.02 m; Surface Area of Empty Openings in the Wall: 0 m2; Height: 2.7 m; Width: 0.02 m; Elevation to Project Zero: 1 m; Elevation to 1st Reference Level: 1 m; Elevation to 2nd Reference Level: 1 m; Elevation to Sea Level: 10.34 m; Elevation to Linked/Home Story: 1 m; Home Offset: 1 m; Top Offset: 0 m; Thickness: 0.02 m; Insulation Skin Thickness: 0 m; Top Elevation To First Reference Level: 3.7 m; Top Elevation To Home Story: 3.7 m; Top Elevation To Project Zero: 3.7 m; Top Elevation To Sea Level: 13.04 m; Top Elevation To Second Reference Level: 3.7 m; Bottom Elevation To First Reference Level: 1 m; Bottom Elevation To Home Story: 1 m; Bottom Elevation To Project Zero: 1 m; Bottom Elevation To Sea Level: 10.34 m; Bottom Elevation To Second Reference Level: 1 m
1 AMB.Identificacio - 103.AMB.Classificacio: 40.10.20.10 Revestiments discontinus; 104.AMB.ClassificacioCodi: 40.10.20.10; 105.AMB.ClassificacioDescripcio: Revestiments discontinus; 111.AMB.DescripcioTipus: Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
Name | Reference Line Location | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Colliding Zones | Surfaces (All) | Tile - Wall, Embodied Carbon | Tile - Wall, Embodied Energy (MJ) | 501.AMB.Longitud (m) = Length of Reference Line (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) | Tile - Wall, Mass (kg) | Tile - Wall, Projected Component Area (Net) (m2) | Tile - Wall, Projected Component Area (Gross) (m2) | Tile - Wall, Component Volume (Net) (m3) = Volume (Net) (m3) = Volume (Conditional) (m3) | Tile - Wall, Component Volume (Gross) (m3) | Minimum Height of the Wall (m) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Length of the Wall Inside Face (Conditional) (m) = Length of the Wall on the Inside Face (m) | Surface Area of the Wall Inside Face (Gross) (m2) = Surface Area of the Wall Outside Face (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Edge Surface Area (Net) (m2) | 107.AMB.NomTipus
F4 | Outside Face | F4 | Lavabo; Nau Annexa | Tiles - White Matte 15x15; Tiles - Terracota Rojo 10x20 | 47.8387 (kgCO₂) | 597.983 | 2.48084 | 199.328 | 6.64426 | 6.64426 | 0.132885 | 0.132885 | 0 | 2.47084 | 6.64426 | 6.64426 | 2.46084 | 6.69826 | 0.0492167 | 2.46084 | 0.133965 | 4.98996 | 0.152433 | F4_Extradossat_170
T3 | Outside Face | T3 | Nau Annexa | Tiles - Terracota Rojo 10x20 | 47.8549 (kgCO₂) | 598.186 | 2.46167 | 199.395 | 6.64651 | 6.64651 | 0.13293 | 0.13293 | 0 | 2.45167 | 6.64651 | 6.64651 | 2.44167 | 6.64651 | 0.0492334 | 2.46167 | 0.13293 | 4.95163 | 0.152467 | T3_Extradossat_170
F3 | Outside Face | F3 | Nau Annexa | Tiles - Terracota Rojo 10x20 | 24.2094 (kgCO₂) | 302.617 | 1.24534 | 100.872 | 3.36242 | 3.36242 | 0.0672483 | 0.0672483 | 2.7 | 1.24534 | 3.36242 | 3.36242 | 1.24534 | 3.36242 | 0.0249068 | 1.24534 | 0.0672483 | 2.53068 | 0.157814 | F3_Extradossat_170
T3 | Inside Face | T3 | Nau Annexa | Tiles - Terracota Rojo 10x20 | 47.2546 (kgCO₂) | 590.683 | 2.45084 | 196.894 | 6.56675 | 6.61726 | 0.131263 | 0.132345 | 0.630153 | 2.45084 | 6.56326 | 6.55276 | 2.45084 | 6.61726 | 0.0490167 | 2.45084 | 0.132345 | 4.94167 | 0.206033 | T3_Extradossat_170
T3 | Outside Face | T3 | Lavabo; Nau Annexa | Tiles - White Matte 15x15; Tiles - Terracota Rojo 10x20 | 0.5832 (kgCO₂) | 7.29 | 0.0463336 | 2.43 | 0.081 | 0.081 | 0.00162 | 0.00162 | 0 | 0.0463336 | 0.081 | 0.081 | 0.0463336 | 0.125101 | 0.0006 | 0.03 | 0.00250201 | 0.132667 | 0.0552 | T3_Extradossat_170

# IfcBuildingElementProxy: Timber - Structural 60 x 120 (14)
In: planta coberta
Classification: 30.20.10.50 Remats de cobertes (GuBIMclass CA); Material: Timber - Structural
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Wood - Pine Grained Horizontal; Left Side Surface: Wood - Pine Grained Horizontal; Right Side Surface: Wood - Pine Grained Horizontal; Beam Slant Angle: -18 deg; Element ID: Cu1; Hotlink and Element ID: Cu1; Layer: 00_VIGUETAS ALERO; Building Material / Composite / Profile / Fill: Timber - Structural; Building Material: Timber - Structural; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Beam; Structure Type: Basic; Parent ID: Cu1; Building Materials (All): Timber - Structural; Surfaces (All): Wood - Pine Grained Horizontal; Cover Fill: Background; Slant Angle: -18 deg; Number of Openings: 0; Top Surface: Wood - Pine Grained Horizontal; Bottom Surface: Wood - Pine Grained Horizontal; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10.50 Remats de cobertes; 104.AMB.ClassificacioCodi: 30.20.10.50; 105.AMB.ClassificacioDescripcio: Remats de cobertes; 107.AMB.NomTipus: Cu1_; 109.AMB.CodiTipus: Cu1; 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Timber - Structural, Component Type: Core
ArchiCADQuantities - Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Offset: 0 m; Height: 0.12 m; Width: 0.06 m; Cross Section Height at Top/End (perpendicular): 0.12 m; Cross Section Height at Bottom/Start (perpendicular): 0.12 m; Cross Section Width at Top/End (perpendicular): 0.06 m; Cross Section Width at Bottom/Start (perpendicular): 0.06 m; Cross Section Height at Top/End (cut): 0.126175 m; Cross Section Height at Bottom/Start (cut): 0.126175 m; Cross Section Width at Top/End (cut): 0.06 m; Cross Section Width at Bottom/Start (cut): 0.06 m; Cross Section Area at Top/End: 0.00757053 m2; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.06 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Timber - Structural, Component Thickness: 0.06 m; Timber - Structural, Rectangular Component Height: 0.12 m; Timber - Structural, Rectangular Component Width: 0.06 m; Timber - Structural, Component Cross Section Area: 0.0072 m2
Name | Colliding Zones | Timber - Structural, Embodied Carbon | Timber - Structural, Embodied Energy (MJ) | Surface Area of Both Beam Ends (m2) | Surface Area of the Beam Left Side (Net) (m2) | Length Left (m) = Length Right (m) | Surface Area of the Beam Right Side (Net) (m2) | Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Timber - Structural, Component Volume (Net) (m3) = Timber - Structural, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Cross Section Area at Bottom/Start (m2) | Top Surface Area (Net) (m2) = Bottom Surface Area (Net) (m2) | Timber - Structural, Mass (kg) | Timber - Structural, Projected Component Area (Net) (m2) = Timber - Structural, Projected Component Area (Gross) (m2)
Cu1 | Espai públic; Nau Santa Eulàlia | 2.20201 (kgCO₂) | 68.3186 | 0.0151411 | 0.134433 | 1.12027 | 0.134433 | 0.0639265 | 0.00806595 | 4.24966 | 13.5897 | -0.250337 | 0.418439 | 1.15926 | 0.00806595 | 4.37584 | -0.124161 | 13.7158 | 3.90348 | -0.59652 | 13.2435 | 0.00757053 | 0.0672163 | 5.64617 | 0.134433
Cu1 | Espai públic; Nau Santa Eulàlia | 2.20201 (kgCO₂) | 68.3186 | 0.0151411 | 0.134433 | 1.12027 | 0.134433 | 0.0639265 | 0.00806595 | 4.24978 | 13.5898 | -0.250217 | 0.418439 | 1.15926 | 0.00806595 | 4.37596 | -0.124042 | 13.716 | 3.9036 | -0.5964 | 13.2436 | 0.00757053 | 0.0672163 | 5.64617 | 0.134433
3 x Cu1 | Espai públic; Nau Santa Eulàlia | 2.20147 (kgCO₂) | 68.3021 | 0.0151411 | 0.1344 | 1.12 | 0.1344 | 0.063911 | 0.008064 | 4.24975 | 13.5897 | -0.250252 | 0.418341 | 1.15899 | 0.008064 | 4.37592 | -0.124076 | 13.7159 | 3.90365 | -0.596351 | 13.2436 | 0.00757053 | 0.0672 | 5.6448 | 0.1344
Cu1 | Espai públic; Nau Santa Eulàlia | 2.18013 (kgCO₂) | 67.64 | 0.00777467 | 0.133748 | 1.12 | 0.133749 | 0.063911 | 0.00798583 | 4.25113 | 13.5911 | -0.248866 | 0.418341 | 1.15899 | 0.008064 | 4.37731 | -0.12269 | 13.7173 | 3.90504 | -0.594965 | 13.245 | 0.000204137 | 0.0668698 | 5.59008 | 0.134399
Cu1 | Espai públic; Nau Santa Eulàlia | 2.20147 (kgCO₂) | 68.3021 | 0.0151411 | 0.1344 | 1.12 | 0.1344 | 0.063911 | 0.008064 | 4.24966 | 13.5897 | -0.250345 | 0.418341 | 1.15899 | 0.008064 | 4.37583 | -0.124169 | 13.7158 | 3.90356 | -0.596444 | 13.2436 | 0.00757053 | 0.0672 | 5.6448 | 0.1344
Cu1 | Espai públic; Nau Santa Eulàlia | 2.20147 (kgCO₂) | 68.3021 | 0.0151411 | 0.1344 | 1.12 | 0.1344 | 0.063911 | 0.008064 | 4.24966 | 13.5897 | -0.250337 | 0.418341 | 1.15899 | 0.008064 | 4.37584 | -0.124161 | 13.7158 | 3.90356 | -0.596436 | 13.2436 | 0.00757053 | 0.0672 | 5.6448 | 0.1344
Cu1 | Espai públic; Nau Santa Eulàlia | 2.20147 (kgCO₂) | 68.3021 | 0.0151411 | 0.1344 | 1.12 | 0.1344 | 0.063911 | 0.008064 | 4.24978 | 13.5898 | -0.250217 | 0.418341 | 1.15899 | 0.008064 | 4.37596 | -0.124042 | 13.716 | 3.90368 | -0.596316 | 13.2437 | 0.00757053 | 0.0672 | 5.6448 | 0.1344
Cu1 | Espai públic; Nau Santa Eulàlia | 2.20201 (kgCO₂) | 68.3186 | 0.0151411 | 0.134433 | 1.12027 | 0.134433 | 0.0639265 | 0.00806595 | 4.24966 | 13.5897 | -0.250345 | 0.418439 | 1.15926 | 0.00806595 | 4.37583 | -0.124169 | 13.7158 | 3.90347 | -0.596528 | 13.2435 | 0.00757053 | 0.0672163 | 5.64617 | 0.134433
3 x Cu1 | Espai públic; Nau Santa Eulàlia | 2.20201 (kgCO₂) | 68.3186 | 0.0151411 | 0.134433 | 1.12027 | 0.134433 | 0.0639265 | 0.00806595 | 4.24975 | 13.5897 | -0.250252 | 0.418439 | 1.15926 | 0.00806595 | 4.37592 | -0.124076 | 13.7159 | 3.90357 | -0.596435 | 13.2436 | 0.00757053 | 0.0672163 | 5.64617 | 0.134433
Cu1 | Nau Santa Eulàlia | 2.20201 (kgCO₂) | 68.3186 | 0.0151411 | 0.134433 | 1.12027 | 0.134433 | 0.0639265 | 0.00806595 | 4.25113 | 13.5911 | -0.248866 | 0.418439 | 1.15926 | 0.00806595 | 4.37731 | -0.12269 | 13.7173 | 3.90495 | -0.595048 | 13.245 | 0.00757053 | 0.0672163 | 5.64617 | 0.134433

# IfcBuildingElementProxy: Timber - Structural 80 (2)
In: planta baixa
Classification: 30.20.10 Cobertes (GuBIMclass CA); Material: Timber - Structural
ArchiCADProperties - Geometry Method: Single-plane; Pitch: -36.5 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: Cu3; Hotlink and Element ID: Cu3; Layer: 00_CLT; Building Material / Composite / Profile / Fill: Timber - Structural; Building Material: Timber - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Roof; Structure Type: Basic; Parent ID: Cu3; Building Materials (All): Timber - Structural; Surfaces (All): Paint - Anthracite; Wood - Pine Grained Horizontal; Cover Fill: Roof Tile 01; Edge Surface: Wood - Pine Grained Horizontal; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 107.AMB.NomTipus: Cu3_CobertaInclinada; 109.AMB.CodiTipus: Cu3; 111.AMB.DescripcioTipus: Coberta amb teules Verea, aïllament i acabat en contraxapat de pi; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: CobertaInclinada
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Timber - Structural, Embodied Carbon: 181.32 (kgCO₂); Timber - Structural, Embodied Energy: 5625.56 MJ
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Surface Area of the Roof Bottom (Gross): 8.26236 m2; Surface Area of the Roof Edges (Gross): 0.924758 m2; Surface Area of the Roof Top (Gross): 8.26236 m2; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Surface Area of the Roof Bottom (Net): 8.26236 m2; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.0803857 m; Vertical Thickness: 0.1 m; Height: 0.0803857 m; Elevation to Project Zero: 6.38433 m; Elevation to 1st Reference Level: 6.38433 m; Elevation to 2nd Reference Level: 6.38433 m; Elevation to Sea Level: 15.7243 m; Elevation to Linked/Home Story: 6.38433 m; Home Offset: 6.38433 m; Top Elevation To First Reference Level: 6.48434 m; Top Elevation To Home Story: 6.48434 m; Top Elevation To Project Zero: 6.48434 m; Top Elevation To Sea Level: 15.8243 m; Top Elevation To Second Reference Level: 6.48434 m; Bottom Elevation To First Reference Level: 4.65242 m; Bottom Elevation To Home Story: 4.65242 m; Bottom Elevation To Project Zero: 4.65242 m; Bottom Elevation To Sea Level: 13.9924 m; Bottom Elevation To Second Reference Level: 4.65242 m
5 AMB.Geometria - 503.AMB.Altura: 0.0803857 m; 504.AMB.Gruix: 0.0803857 m; 506.AMB.Profunditat: 0 m
Component Quantities - Timber - Structural, Mass: 464.923 kg; Timber - Structural, Projected Component Area (Net): 8.26236 m2; Timber - Structural, Projected Component Area (Gross): 8.26236 m2; Timber - Structural, Component Thickness: 0.0803857 m; Timber - Structural, Component Volume (Net): 0.664175 m3; Timber - Structural, Component Volume (Gross): 0.664175 m3

# IfcBuildingElementProxy: Timber - Structural 80 x 200 (82)
In: planta baixa
Classification: 30.20.10 Cobertes (GuBIMclass CA); Material: Timber - Structural
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Wood - Pine Grained Horizontal; Left Side Surface: Wood - Pine Grained Horizontal; Right Side Surface: Wood - Pine Grained Horizontal; Layer: 00_VIGUETAS ALERO; Building Material / Composite / Profile / Fill: Timber - Structural; Building Material: Timber - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Building Materials (All): Timber - Structural; Surfaces (All): Wood - Pine Grained Horizontal; Cover Fill: Background; Number of Openings: 0; Top Surface: Wood - Pine Grained Horizontal; Bottom Surface: Wood - Pine Grained Horizontal; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Timber - Structural, Component Type: Core
ArchiCADQuantities - Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Offset: 0 m; Height: 0.2 m; Width: 0.08 m; Cross Section Height at Top/End (perpendicular): 0.2 m; Cross Section Height at Bottom/Start (perpendicular): 0.2 m; Cross Section Width at Top/End (perpendicular): 0.08 m; Cross Section Width at Bottom/Start (perpendicular): 0.08 m; Cross Section Width at Top/End (cut): 0.08 m; Cross Section Width at Bottom/Start (cut): 0.08 m; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.08 m; 503.AMB.Altura: 0.2 m; 506.AMB.Profunditat: 0 m
Component Quantities - Timber - Structural, Component Thickness: 0.08 m; Timber - Structural, Rectangular Component Height: 0.2 m; Timber - Structural, Rectangular Component Width: 0.08 m; Timber - Structural, Component Cross Section Area: 0.016 m2
Name | Beam Slant Angle (deg) = Slant Angle (deg) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Colliding Zones | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_107.NomTipus | Timber - Structural, Embodied Carbon | Timber - Structural, Embodied Energy (MJ) | Surface Area of Both Beam Ends (m2) | Surface Area of the Beam Left Side (Net) (m2) | Length Left (m) = Length Right (m) | Surface Area of the Beam Right Side (Net) (m2) | Area (m2) | Volume (Net) (m3) = Timber - Structural, Component Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | Surface Area (m2) | 3D Length (m) | Volume (Conditional) (m3) = Timber - Structural, Component Volume (Gross) (m3) | Volume (Gross) (m3) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Cross Section Height at Top/End (cut) (m) = Cross Section Height at Bottom/Start (cut) (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) | Timber - Structural, Mass (kg) | Timber - Structural, Projected Component Area (Net) (m2) = Timber - Structural, Projected Component Area (Gross) (m2)
59 x Cu1 | -14.4 | Cu1 | Espai públic; Nau Santa Eulàlia | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | BMR - 004 | 3.9312 (kgCO₂) | 121.968 | 0.0330379 | 0.18 | 0.9 | 0.18 | 0.069738 | 0.0144 | 4.73054 | 14.0705 | 0.537038 | 0.951351 | 0.0144 | 0.0144 | 4.83378 | 14.1738 | 4.40347 | 13.7435 | 0.206487 | 0.016519 | 0.016519 | 0.072 | 0.072 | 10.08 | 0.18
2 x Cu1 | -14.4 | Cu1 | Nau Santa Eulàlia | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | BMR - 004 | 3.9312 (kgCO₂) | 121.968 | 0.0330379 | 0.18 | 0.9 | 0.18 | 0.069738 | 0.0144 | 4.73054 | 14.0705 | 0.537038 | 0.951351 | 0.0144 | 0.0144 | 4.83378 | 14.1738 | 4.40347 | 13.7435 | 0.206487 | 0.016519 | 0.016519 | 0.072 | 0.072 | 10.08 | 0.18
Cu1 | -14.4 | Cu1 | Espai públic; Nau Santa Eulàlia | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | BMR - 004 | 2.9833 (kgCO₂) | 92.5589 | 0.0189606 | 0.129136 | 0.9 | 0.146428 | 0.0529227 | 0.0109279 | 4.73054 | 14.0705 | 0.429492 | 0.834844 | 0.0109279 | 0.0144 | 4.83378 | 14.1738 | 4.40347 | 13.7435 | 0.206487 | 0.00244163 | 0.016519 | 0.0546393 | 0.0546393 | 7.6495 | 0.146428
Cu1 | -14.4 | Cu1 | Espai públic; Nau Santa Eulàlia | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | BMR - 004 | 2.84167 (kgCO₂) | 88.1646 | 0.016519 | 0.139154 | 0.9 | 0.121072 | 0.0504101 | 0.010409 | 4.73054 | 14.0705 | 0.405327 | 0.747121 | 0.010409 | 0.0144 | 4.78299 | 14.123 | 4.40347 | 13.7435 | 0.206487 | 0 | 0.016519 | 0.0520452 | 0.0520452 | 7.28633 | 0.139154
18 x Cu5 | -17.48 | Cu5 |  | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Coberta R60 | 4.67896 (kgCO₂) | 145.168 | 0.0335492 | 0.214238 | 1.07119 | 0.214238 | 0.081738 | 0.017139 | 7.63459 | 16.9746 | 0.633416 | 1.13417 | 0.017139 | 0.017139 | 7.73943 | 17.0794 | 7.20799 | 16.548 | 0.209683 | 0.0167746 | 0.0167746 | 0.0856952 | 0.0856952 | 11.9973 | 0.214238
Cu5 | -17.48 | Cu5 |  | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Coberta R60 | 4.64336 (kgCO₂) | 144.063 | 0.0335498 | 0.214238 | 1.07119 | 0.120479 | 0.0815604 | 0.0170086 | 7.63459 | 16.9746 | 0.633661 | 1.13417 | 0.0169822 | 0.017139 | 7.73943 | 17.0794 | 7.20799 | 16.548 | 0.209683 | 0.0167752 | 0.0167746 | 0.085509 | 0.0849108 | 11.906 | 0.214238

# IfcBuildingElementProxy: Timber - Structural 95, Cu5
In: planta baixa
Classification: 30.20.10 Cobertes (GuBIMclass CA); Material: Timber - Structural
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Geometry Method: Single-plane; Pitch: -17.48 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: Cu5; Hotlink and Element ID: Cu5; Layer: 00_CLT; Building Material / Composite / Profile / Fill: Timber - Structural; Building Material: Timber - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Roof; Structure Type: Basic; Parent ID: Cu5; Building Materials (All): Timber - Structural; Surfaces (All): Wood - Pine Grained Horizontal; Cover Fill: Roof Tile 01; Edge Surface: Wood - Pine Grained Horizontal; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 107.AMB.NomTipus: Cu5_CobertaInclinadaR60; 109.AMB.CodiTipus: Cu5; 111.AMB.DescripcioTipus: Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: CobertaInclinadaR60
Pset_BuildingElementProxyCommon - Status: NEW
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Surface Area of the Roof Bottom (Gross): 81.4843 m2; Surface Area of the Roof Edges (Gross): 4.12279 m2; Surface Area of the Roof Top (Gross): 81.4844 m2; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Surface Area of the Roof Bottom (Net): 81.4843 m2; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.0953822 m; Vertical Thickness: 0.1 m; Height: 0.0953822 m; Elevation to Project Zero: 10.1844 m; Elevation to 1st Reference Level: 10.1844 m; Elevation to 2nd Reference Level: 10.1844 m; Elevation to Sea Level: 19.5244 m; Elevation to Linked/Home Story: 10.1844 m; Home Offset: 10.1844 m; Top Elevation To First Reference Level: 10.3306 m; Top Elevation To Home Story: 10.3306 m; Top Elevation To Project Zero: 10.3306 m; Top Elevation To Sea Level: 19.6706 m; Top Elevation To Second Reference Level: 10.3306 m; Bottom Elevation To First Reference Level: 7.64989 m; Bottom Elevation To Home Story: 7.64989 m; Bottom Elevation To Project Zero: 7.64989 m; Bottom Elevation To Sea Level: 16.9899 m; Bottom Elevation To Second Reference Level: 7.64989 m
5 AMB.Geometria - 503.AMB.Altura: 0.0953822 m; 504.AMB.Gruix: 0.0953822 m; 506.AMB.Profunditat: 0 m
Component Quantities - Timber - Structural, Mass: 5440.51 kg; Timber - Structural, Projected Component Area (Net): 81.8582 m2; Timber - Structural, Projected Component Area (Gross): 81.8582 m2; Timber - Structural, Component Thickness: 0.0953822 m; Timber - Structural, Component Volume (Net): 7.77216 m3; Timber - Structural, Component Volume (Gross): 7.77216 m3
Component Properties - Timber - Structural, Embodied Carbon: 2121.8 (kgCO₂); Timber - Structural, Embodied Energy: 65830.2 MJ

# IfcBuildingElementProxy: Tr1 Plywood 165 (5)
In: planta baixa
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Inside Face Surface: Wood - Pine Grained Horizontal; Outside Face Surface: Paint - Titanium White; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Layer: 00_TABIQUE; Building Material / Composite / Profile / Fill: Tr1 Plywood; Composite Structure: Tr1 Plywood; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Composite; Building Materials (All): Air Space - Frame; Insulation - Mineral Soft; Timber - Structural; Slant Angle: 90 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 109.AMB.CodiTipus: T3; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Number of Holes (Number of Empty Openings): 0; Number of Columns: 0; Volume of the Columns: 0 m3; Minimum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0.08 m; Wall Component Thickness on the Inside Face: 0.015 m; Wall Component Thickness on the Outside Face: 0.08 m; End Thickness of the Wall: 0.165 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.165 m; Top Offset: 0 m; Thickness: 0.165 m; Insulation Skin Thickness: 0.07 m
5 AMB.Geometria - 502.AMB.Amplada: 0.165 m; 504.AMB.Gruix: 0.165 m; 506.AMB.Profunditat: 0 m
Name | Classification | Reference Line Location | Element ID = Hotlink and Element ID = Parent ID | Colliding Zones | Surfaces (All) | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | AUX_107.NomTipus | Number of Doors | Number of Windows | Maximum Height of the Wall Skin on the Inside Face (m) | Maximum Height of the Wall (m) | Maximum Height of the Wall Skin on the Outside Face (m) | Area of the Doors (m2) | Combined Width of Doors (m) | Area of the Windows (m2) | Combined Width of Windows (m) | Wall Component Volume on the Inside Face (Net) (m3) | Wall Component Volume on the Outside Face (Net) (m3) | Analytic Surface Area of Openings on the Inside Face (m2) = Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Surface Area of the Wall Inside Face (Conditional) (m2) | Length of the Wall Outside Face (Conditional) (m) | Surface Area of the Wall Outside Face (Conditional) (m2) | Volume of the Wall Inside Face Component (Conditional) (m3) | Volume of the Wall Outside Face Component (Conditional) (m3) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | 3D Length (m) | Volume (Conditional) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2)
F3 | 40.10.10.30 Extradossats (GuBIMclass CA) | Outside Face | F3 | Nau Annexa | Paint - Anthracite; Wood - Pine Grained Horizontal; Paint - Titanium White; Insulation - Cellulose | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T3_Extradossat_170 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Extradossat_170 | 0 | 0 | 3.96287 | 3.96287 | 3.96287 | 0 | 0 | 0 | 0 | 0.146658 | 0.877984 | 0 | 2.61584 | 9.77723 | 10.3494 | 0 | 2.78084 | 2.45084 | 9.77723 | 2.78084 | 10.3494 | 0.146658 | 0.877984 | 11.0201 | 11.0201 | 2.45084 | 2.78084 | 0.442948 | 3.96287 | 1.74788 | 1 | 10.34 | 2.77849 | 1.74788 | 1.81832 | 5.69836 | 4.96287 | 14.3029 | 0.885895
Tr1 | 40.10.10.30 Extradossats (GuBIMclass CA) | Outside Face | Tr1 | Nau Annexa | Paint - Anthracite; Wood - Pine Grained Horizontal; Paint - Titanium White; Insulation - Cellulose | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T3_Extradossat_170 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Extradossat_170 | 0 | 0 | 5.38432 | 5.38434 | 5.38434 | 0 | 0 | 0 | 0 | 0.17783 | 1.03385 | 0 | 2.61167 | 11.8553 | 12.9232 | 0 | 2.77667 | 2.44667 | 11.8553 | 2.77667 | 12.9232 | 0.17783 | 1.03385 | 13.2372 | 13.2372 | 2.44667 | 2.77667 | 0.436237 | 5.38434 | 2.06974 | 1 | 10.34 | 2.69667 | 2.06974 | 2.18414 | 5.69003 | 6.38434 | 15.7243 | 0.973606
F3 | 40.10.10.30 Extradossats (GuBIMclass CA) | Outside Face | F3 | Nau Annexa | Paint - Anthracite; Wood - Pine Grained Horizontal; Paint - Titanium White; Insulation - Cellulose | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T3_Extradossat_170 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Extradossat_170 | 1 | 2 | 5.38397 | 5.38397 | 5.38396 | 3.22201 | 1.2 | 0.990639 | 1.05589 | 0.114634 | 0.696795 | 4.21265 | 2.61167 | 7.64226 | 8.70993 | 0.695087 | 2.77667 | 1.24667 | 8.6329 | 1.57667 | 9.70057 | 0.177824 | 1.03381 | 13.2367 | 13.2366 | 2.44667 | 2.77667 | 0.238237 | 5.38434 | 1.37457 | 1 | 10.34 | 2.69667 | 2.06966 | 2.18405 | 5.69003 | 6.38397 | 15.724 | 0.775606
T3 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Center | T3 | Nau Annexa | Wood - Pine Grained Horizontal; Paint - Titanium White; Insulation - Cellulose; Tiles - Terracota Rojo 10x20 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T3_Enva_100_Mao | Envà de Maó | Enva_100_Mao | 0 | 0 | 2.18556 | 2.18556 | 2.12267 | 0 | 0 | 0 | 0 | 0.0801429 | 0.410382 | 0 | 2.45084 | 5.35646 | 5.05723 | 0 | 2.78084 | 2.45084 | 5.35646 | 2.45084 | 5.05723 | 0.0801429 | 0.410382 | 6.84489 | 6.84489 | 2.45084 | 2.45084 | 0.404388 | 2.46145 | 0.85913 | 3.7 | 13.04 | 2.45084 | 0.85913 | 1.12941 | 5.23167 | 5.88556 | 15.2256 | 0.404388
F4 | 40.10.10.30 Extradossats (GuBIMclass CA) | Outside Face | F4 | Lavabo; Nau Annexa | Paint - Anthracite; Wood - Pine Grained Horizontal; Paint - Titanium White; Insulation - Cellulose | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T3_Extradossat_170 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Extradossat_170 | 0 | 0 | 4.93921 | 4.93921 | 4.87631 | 0 | 0 | 0 | 0 | 0.181374 | 1.0162 | 0 | 2.61584 | 12.1052 | 12.6249 | 0 | 2.78084 | 2.45084 | 12.1052 | 2.78084 | 12.6249 | 0.181374 | 1.0162 | 14.973 | 14.973 | 2.45084 | 2.78084 | 0.420088 | 5.38434 | 2.04888 | 1 | 10.34 | 2.62084 | 2.04888 | 2.47054 | 5.69836 | 5.93921 | 15.2792 | 0.420088

# IfcBuildingElementProxy: Window 27 (42)
In: planta baixa
Classification: 30.10.20.10 Finestres de façanes (GuBIMclass CA)
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0; Status: NEW
ArchiCADProperties - Opening Library Part Name: Window 27; Opening Side Fill Index: Background; Layer: 00_TABIQUE; Library Part Name: Window 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Element Type: Window; Surfaces (All): Wood - Pine Grained Horizontal; Glass - Clear Fast; Metal - Aluminium; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.20.10 Finestres de façanes; 104.AMB.ClassificacioCodi: 30.10.20.10; 105.AMB.ClassificacioDescripcio: Finestres de façanes; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30
ArchiCADQuantities - Frame Thickness: 0.05 m
