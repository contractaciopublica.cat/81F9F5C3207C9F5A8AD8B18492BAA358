Properties of the parts of a building model (IFC2X3), part 26 of 99

# IfcBuildingElementProxy: Rhino_Object_1148, Object_1148
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1148; Hotlink and Element ID: Object_1148; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1148; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1148; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1148 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1148_; 109.AMB.CodiTipus: Object_1148; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1148 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1149, Object_1149
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1149; Hotlink and Element ID: Object_1149; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1149; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1149; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1149 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1149_; 109.AMB.CodiTipus: Object_1149; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426553 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1149 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_115, Object_115
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_115; Hotlink and Element ID: Object_115; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_115; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_115; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_115 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_115_; 109.AMB.CodiTipus: Object_115; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_115 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1150, Cu1
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Cu1; Hotlink and Element ID: Cu1; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1150; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Cu1; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1150 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Cu1_; 109.AMB.CodiTipus: Cu1; 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 23.6207 m; Area: 37.1065 m2; Height: 0.170126 m; Volume (Net): 0.279172 m3; Width: 1.57093 m; Elevation to Project Zero: 4.3698 m; Elevation to 1st Reference Level: 4.3698 m; Elevation to 2nd Reference Level: 4.3698 m; Elevation to Sea Level: 13.7098 m; Elevation to Linked/Home Story: 4.3698 m; Home Offset: 4.3698 m; Surface Area: 11.3839 m2; Top Elevation To First Reference Level: 4.53993 m; Top Elevation To Home Story: 4.53993 m; Top Elevation To Project Zero: 4.53993 m; Top Elevation To Sea Level: 13.8799 m; Top Elevation To Second Reference Level: 4.53993 m; Bottom Elevation To First Reference Level: 4.3698 m; Bottom Elevation To Home Story: 4.3698 m; Bottom Elevation To Project Zero: 4.3698 m; Bottom Elevation To Sea Level: 13.7098 m; Bottom Elevation To Second Reference Level: 4.3698 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 13.7098 m; Top Surface Area (Net): 37.1065 m2; Bottom Surface Area (Net): 11.3839 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 1.57093 m; 503.AMB.Altura: 0.170126 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.279172 m3; Component, Component Volume (Gross): 0.279172 m3
AC_Equantity_Rhino_Object_1150 - Dimension 1: 23.6207 m; Dimension 2: 1.57093 m; Height: 0.170126 m; Bottom Level: -3.63612e-07 m; Top Level: 0.170126 m

# IfcBuildingElementProxy: Rhino_Object_1151, Cu1
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Cu1; Hotlink and Element ID: Cu1; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1151; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Cu1; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1151 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
AC_Equantity_Rhino_Object_1151 - Dimension 1: 23.6163 m; Dimension 2: 1.50132 m; Height: 0.05 m; Bottom Level: -2.02889e-08 m; Top Level: 0.05 m
5 AMB.Geometria - 502.AMB.Amplada: 1.50132 m; 503.AMB.Altura: 0.05 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 23.6163 m; Area: 35.4556 m2; Height: 0.05 m; Volume (Net): 0.0354904 m3; Width: 1.50132 m; Elevation to Project Zero: 4.2598 m; Elevation to 1st Reference Level: 4.2598 m; Elevation to 2nd Reference Level: 4.2598 m; Elevation to Sea Level: 13.5998 m; Elevation to Linked/Home Story: 4.2598 m; Home Offset: 4.2598 m; Surface Area: 3.78864 m2; Top Elevation To First Reference Level: 4.3098 m; Top Elevation To Home Story: 4.3098 m; Top Elevation To Project Zero: 4.3098 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.3098 m; Bottom Elevation To First Reference Level: 4.2598 m; Bottom Elevation To Home Story: 4.2598 m; Bottom Elevation To Project Zero: 4.2598 m; Bottom Elevation To Sea Level: 13.5998 m; Bottom Elevation To Second Reference Level: 4.2598 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 13.5998 m; Top Surface Area (Net): 35.4556 m2; Bottom Surface Area (Net): 3.78864 m2
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Cu1_; 109.AMB.CodiTipus: Cu1; 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Component Quantities - Component, Component Volume (Net): 0.0354904 m3; Component, Component Volume (Gross): 0.0354904 m3

# IfcBuildingElementProxy: Rhino_Object_1154, Object_1154
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1154; Hotlink and Element ID: Object_1154; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1154; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1154; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1154 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1154_; 109.AMB.CodiTipus: Object_1154; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 27.3022 m; Area: 46.6139 m2; Height: 0.0500001 m; Volume (Net): 0 m3; Width: 1.70733 m; Elevation to Project Zero: 1.34817 m; Elevation to 1st Reference Level: 1.34817 m; Elevation to 2nd Reference Level: 1.34817 m; Elevation to Sea Level: 10.6882 m; Elevation to Linked/Home Story: 1.34817 m; Home Offset: 1.34817 m; Surface Area: 2.50064 m2; Top Elevation To First Reference Level: 1.39817 m; Top Elevation To Home Story: 1.39817 m; Top Elevation To Project Zero: 1.39817 m; Top Elevation To Sea Level: 10.7382 m; Top Elevation To Second Reference Level: 1.39817 m; Bottom Elevation To First Reference Level: 1.34817 m; Bottom Elevation To Home Story: 1.34817 m; Bottom Elevation To Project Zero: 1.34817 m; Bottom Elevation To Sea Level: 10.6882 m; Bottom Elevation To Second Reference Level: 1.34817 m; Survey Coordinate X: 426572 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 10.6882 m; Top Surface Area (Net): 46.6139 m2; Bottom Surface Area (Net): 2.50064 m2
AC_Equantity_Rhino_Object_1154 - Dimension 1: 27.3022 m; Dimension 2: 1.70733 m; Height: 0.0500001 m; Bottom Level: 0 m; Top Level: 0.0500001 m
5 AMB.Geometria - 502.AMB.Amplada: 1.70733 m; 503.AMB.Altura: 0.0500001 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1155, Object_1155
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1155 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1155; Hotlink and Element ID: Object_1155; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1155; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1155; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1155_; 109.AMB.CodiTipus: Object_1155; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1155 - Dimension 1: 27.3022 m; Dimension 2: 1.70733 m; Height: 0.0500001 m; Bottom Level: 0 m; Top Level: 0.0500001 m
5 AMB.Geometria - 502.AMB.Amplada: 1.70733 m; 503.AMB.Altura: 0.0500001 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3
ArchiCADQuantities - Length (A): 27.3022 m; Area: 46.6139 m2; Height: 0.0500001 m; Volume (Net): 0 m3; Width: 1.70733 m; Elevation to Project Zero: 1.34817 m; Elevation to 1st Reference Level: 1.34817 m; Elevation to 2nd Reference Level: 1.34817 m; Elevation to Sea Level: 10.6882 m; Elevation to Linked/Home Story: 1.34817 m; Home Offset: 1.34817 m; Surface Area: 0.396891 m2; Top Elevation To First Reference Level: 1.39817 m; Top Elevation To Home Story: 1.39817 m; Top Elevation To Project Zero: 1.39817 m; Top Elevation To Sea Level: 10.7382 m; Top Elevation To Second Reference Level: 1.39817 m; Bottom Elevation To First Reference Level: 1.34817 m; Bottom Elevation To Home Story: 1.34817 m; Bottom Elevation To Project Zero: 1.34817 m; Bottom Elevation To Sea Level: 10.6882 m; Bottom Elevation To Second Reference Level: 1.34817 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.6882 m; Top Surface Area (Net): 46.6139 m2; Bottom Surface Area (Net): 0.396891 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_1156, Object_1156
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1156 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1156; Hotlink and Element ID: Object_1156; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1156; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1156; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADQuantities - Length (A): 0.0771548 m; Area: 0.0985184 m2; Height: 3.6499 m; Volume (Net): 0 m3; Width: 1.27689 m; Elevation to Project Zero: 1.34817 m; Elevation to 1st Reference Level: 1.34817 m; Elevation to 2nd Reference Level: 1.34817 m; Elevation to Sea Level: 10.6882 m; Elevation to Linked/Home Story: 1.34817 m; Home Offset: 1.34817 m; Surface Area: 0.0015 m2; Top Elevation To First Reference Level: 1.39817 m; Top Elevation To Home Story: 1.39817 m; Top Elevation To Project Zero: 1.39817 m; Top Elevation To Sea Level: 10.7382 m; Top Elevation To Second Reference Level: 1.39817 m; Bottom Elevation To First Reference Level: 1.34817 m; Bottom Elevation To Home Story: 1.34817 m; Bottom Elevation To Project Zero: 1.34817 m; Bottom Elevation To Sea Level: 10.6882 m; Bottom Elevation To Second Reference Level: 1.34817 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.6882 m; Top Surface Area (Net): 0.0985184 m2; Bottom Surface Area (Net): 0.0015 m2
AC_Equantity_Rhino_Object_1156 - Dimension 1: 0.0771548 m; Dimension 2: 1.27689 m; Height: 3.6499 m; Bottom Level: -2.48611 m; Top Level: 1.16379 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1156_; 109.AMB.CodiTipus: Object_1156; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3
5 AMB.Geometria - 502.AMB.Amplada: 1.27689 m; 503.AMB.Altura: 3.6499 m; 506.AMB.Profunditat: 0 m
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1157, Object_1157
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1157; Hotlink and Element ID: Object_1157; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1157; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1157; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1157_; 109.AMB.CodiTipus: Object_1157; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Pset_Rhino_Object_1157 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1157 - Dimension 1: 0.0771548 m; Dimension 2: 1.27689 m; Height: 3.6499 m; Bottom Level: -2.48611 m; Top Level: 1.16379 m
ArchiCADQuantities - Length (A): 0.0771548 m; Area: 0.0985184 m2; Height: 3.6499 m; Volume (Net): 0 m3; Width: 1.27689 m; Elevation to Project Zero: 1.34817 m; Elevation to 1st Reference Level: 1.34817 m; Elevation to 2nd Reference Level: 1.34817 m; Elevation to Sea Level: 10.6882 m; Elevation to Linked/Home Story: 1.34817 m; Home Offset: 1.34817 m; Surface Area: 0.0015 m2; Top Elevation To First Reference Level: 1.39817 m; Top Elevation To Home Story: 1.39817 m; Top Elevation To Project Zero: 1.39817 m; Top Elevation To Sea Level: 10.7382 m; Top Elevation To Second Reference Level: 1.39817 m; Bottom Elevation To First Reference Level: 1.34817 m; Bottom Elevation To Home Story: 1.34817 m; Bottom Elevation To Project Zero: 1.34817 m; Bottom Elevation To Sea Level: 10.6882 m; Bottom Elevation To Second Reference Level: 1.34817 m; Survey Coordinate X: 426587 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.6882 m; Top Surface Area (Net): 0.0985184 m2; Bottom Surface Area (Net): 0.0015 m2
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3
5 AMB.Geometria - 502.AMB.Amplada: 1.27689 m; 503.AMB.Altura: 3.6499 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1158, Object_1158
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1158; Hotlink and Element ID: Object_1158; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1158; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1158; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1158 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1158_; 109.AMB.CodiTipus: Object_1158; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.258681 m; Area: 0.0361497 m2; Height: 0.12 m; Volume (Net): 0 m3; Width: 0.139746 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0668498 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426587 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0361497 m2; Bottom Surface Area (Net): 0.0668498 m2
AC_Equantity_Rhino_Object_1158 - Dimension 1: 0.258681 m; Dimension 2: 0.139746 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.139746 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1159, Object_1159
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1159; Hotlink and Element ID: Object_1159; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1159; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1159; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1159 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1159_; 109.AMB.CodiTipus: Object_1159; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.258681 m; Area: 0.0361497 m2; Height: 0.12 m; Volume (Net): 0 m3; Width: 0.139746 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0732053 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0361497 m2; Bottom Surface Area (Net): 0.0732053 m2
AC_Equantity_Rhino_Object_1159 - Dimension 1: 0.258681 m; Dimension 2: 0.139746 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.139746 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_116, Object_116
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_116; Hotlink and Element ID: Object_116; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_116; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_116; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_116 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_116_; 109.AMB.CodiTipus: Object_116; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_116 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1160, Object_1160
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1160; Hotlink and Element ID: Object_1160; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1160; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1160; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1160 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1160_; 109.AMB.CodiTipus: Object_1160; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 21.8399 m; Area: 31.3492 m2; Height: 0.170126 m; Volume (Net): 0 m3; Width: 1.43541 m; Elevation to Project Zero: 1.39817 m; Elevation to 1st Reference Level: 1.39817 m; Elevation to 2nd Reference Level: 1.39817 m; Elevation to Sea Level: 10.7382 m; Elevation to Linked/Home Story: 1.39817 m; Home Offset: 1.39817 m; Surface Area: 7.50481 m2; Top Elevation To First Reference Level: 1.56829 m; Top Elevation To Home Story: 1.56829 m; Top Elevation To Project Zero: 1.56829 m; Top Elevation To Sea Level: 10.9083 m; Top Elevation To Second Reference Level: 1.56829 m; Bottom Elevation To First Reference Level: 1.39817 m; Bottom Elevation To Home Story: 1.39817 m; Bottom Elevation To Project Zero: 1.39817 m; Bottom Elevation To Sea Level: 10.7382 m; Bottom Elevation To Second Reference Level: 1.39817 m; Survey Coordinate X: 426572 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 10.7382 m; Top Surface Area (Net): 31.3492 m2; Bottom Surface Area (Net): 7.50481 m2
AC_Equantity_Rhino_Object_1160 - Dimension 1: 21.8399 m; Dimension 2: 1.43541 m; Height: 0.170126 m; Bottom Level: 0 m; Top Level: 0.170126 m
5 AMB.Geometria - 502.AMB.Amplada: 1.43541 m; 503.AMB.Altura: 0.170126 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1161, Object_1161
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1161; Hotlink and Element ID: Object_1161; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1161; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1161; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1161 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1161_; 109.AMB.CodiTipus: Object_1161; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 21.8399 m; Area: 31.3492 m2; Height: 0.170126 m; Volume (Net): 0 m3; Width: 1.43541 m; Elevation to Project Zero: 1.39817 m; Elevation to 1st Reference Level: 1.39817 m; Elevation to 2nd Reference Level: 1.39817 m; Elevation to Sea Level: 10.7382 m; Elevation to Linked/Home Story: 1.39817 m; Home Offset: 1.39817 m; Surface Area: 1.19721 m2; Top Elevation To First Reference Level: 1.56829 m; Top Elevation To Home Story: 1.56829 m; Top Elevation To Project Zero: 1.56829 m; Top Elevation To Sea Level: 10.9083 m; Top Elevation To Second Reference Level: 1.56829 m; Bottom Elevation To First Reference Level: 1.39817 m; Bottom Elevation To Home Story: 1.39817 m; Bottom Elevation To Project Zero: 1.39817 m; Bottom Elevation To Sea Level: 10.7382 m; Bottom Elevation To Second Reference Level: 1.39817 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.7382 m; Top Surface Area (Net): 31.3492 m2; Bottom Surface Area (Net): 1.19721 m2
AC_Equantity_Rhino_Object_1161 - Dimension 1: 21.8399 m; Dimension 2: 1.43541 m; Height: 0.170126 m; Bottom Level: 0 m; Top Level: 0.170126 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3
5 AMB.Geometria - 502.AMB.Amplada: 1.43541 m; 503.AMB.Altura: 0.170126 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1162, Object_1162
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1162; Hotlink and Element ID: Object_1162; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1162; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1162; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1162 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1162_; 109.AMB.CodiTipus: Object_1162; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0039204 m; Area: 0.000254362 m2; Height: 0.997971 m; Volume (Net): 0 m3; Width: 0.0648817 m; Elevation to Project Zero: 1.51399 m; Elevation to 1st Reference Level: 1.51399 m; Elevation to 2nd Reference Level: 1.51399 m; Elevation to Sea Level: 10.854 m; Elevation to Linked/Home Story: 1.51399 m; Home Offset: 1.51399 m; Surface Area: 0.0648681 m2; Top Elevation To First Reference Level: 2.51196 m; Top Elevation To Home Story: 2.51196 m; Top Elevation To Project Zero: 2.51196 m; Top Elevation To Sea Level: 11.852 m; Top Elevation To Second Reference Level: 2.51196 m; Bottom Elevation To First Reference Level: 1.51399 m; Bottom Elevation To Home Story: 1.51399 m; Bottom Elevation To Project Zero: 1.51399 m; Bottom Elevation To Sea Level: 10.854 m; Bottom Elevation To Second Reference Level: 1.51399 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.854 m; Top Surface Area (Net): 0.000254362 m2; Bottom Surface Area (Net): 0.0648681 m2
AC_Equantity_Rhino_Object_1162 - Dimension 1: 0.0039204 m; Dimension 2: 0.0648817 m; Height: 0.997971 m; Bottom Level: -2.22045e-16 m; Top Level: 0.997971 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0648817 m; 503.AMB.Altura: 0.997971 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1163, Object_1163
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5804 deg; Surface: Brick - Aged Natural; Element ID: Object_1163; Hotlink and Element ID: Object_1163; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_1163; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1163; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1163 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
