Properties of the parts of a building model (IFC2X3), part 92 of 99

# IfcBuildingElementProxy: Steel - Structural 2 x 30 (58)
Component Properties - Steel - Structural, Embodied Carbon: 1.96171 (kgCO₂); Steel - Structural, Embodied Energy: 29.662 MJ; Steel - Structural, Component Type: Core
ArchiCADQuantities - Core Height / Diameter: 0.03 m; Volume of the Column Core (Net): 0.000151507 m3; Core Width: 0.002 m; Surface Area of the Column Core (Gross, without Top/Bottom): 0.161607 m2; Surface Area of the Column Core Top (Gross): 0.00006 m2; Surface Area of the Column Core Bottom (Gross): 0.00006 m2; Volume of the Column Core (Gross): 0.000151507 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 2.52511 m; Minimum Height of the Column: 2.52511 m; Surface Area of the Column Core Bottom (Net): 0.00006 m2; Surface Area of the Column Core (Net, without Top/Bottom): 0.161607 m2; Surface Area of the Column Core Top (Net): 0.00006 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 0.064 m; Volume of the Column Veneer (Net): 0 m3; Area: 0.00006 m2; Height: 2.52511 m; Volume (Net): 0.000151507 m3; Width: 0.002 m; Elevation to Project Zero: 2.01 m; Elevation to 1st Reference Level: 2.01 m; Elevation to 2nd Reference Level: 2.01 m; Elevation to Sea Level: 11.35 m; Elevation to Linked/Home Story: 2.01 m; Home Offset: 2.01 m; Top Offset: 1.44108 m; Surface Area: 0.161607 m2; 3D Length: 2.52511 m; Volume (Gross): 0.000151507 m3; Top Elevation To First Reference Level: 4.53511 m; Top Elevation To Home Story: 4.53511 m; Top Elevation To Project Zero: 4.53511 m; Top Elevation To Sea Level: 13.8751 m; Top Elevation To Second Reference Level: 4.53511 m; Bottom Elevation To First Reference Level: 2.01 m; Bottom Elevation To Home Story: 2.01 m; Bottom Elevation To Project Zero: 2.01 m; Bottom Elevation To Sea Level: 11.35 m; Bottom Elevation To Second Reference Level: 2.01 m; Cross Section Height at Top/End (perpendicular): 0.03 m; Cross Section Height at Bottom/Start (perpendicular): 0.03 m; Cross Section Width at Top/End (perpendicular): 0.002 m; Cross Section Width at Bottom/Start (perpendicular): 0.002 m; Cross Section Height at Top/End (cut): 0.03 m; Cross Section Height at Bottom/Start (cut): 0.03 m; Cross Section Width at Top/End (cut): 0.002 m; Cross Section Width at Bottom/Start (cut): 0.002 m; Cross Section Area at Bottom/Start: 0.00006 m2; Cross Section Area at Top/End: 0.00006 m2; Number of Segments: 1; Top Surface Area (Net): 0.00006 m2; Bottom Surface Area (Net): 0.161607 m2; Top Surface Area (Gross): 0.00006 m2
Component Quantities - Steel - Structural, Mass: 1.18175 kg; Steel - Structural, Component Thickness: 0.002 m; Steel - Structural, Rectangular Component Height: 0.03 m; Steel - Structural, Rectangular Component Width: 0.002 m; Steel - Structural, Component Cross Section Area: 0.00006 m2; Steel - Structural, Component Volume (Net): 0.000151507 m3; Steel - Structural, Component Volume (Gross): 0.000151507 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.002 m; 503.AMB.Altura: 2.52511 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Steel - Structural 30 x 2 (118)
In: planta baixa
Classification: 30.10.10.20 Façanes prefabricades (GuBIMclass CA); Material: Steel - Structural
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Metal - Nickel; Left Side Surface: Metal - Nickel; Right Side Surface: Metal - Nickel; Beam Slant Angle: 0 deg; Element ID: PE102; Hotlink and Element ID: PE102; Layer: 00_TRAMEX; Building Material / Composite / Profile / Fill: Steel - Structural; Building Material: Steel - Structural; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Parent ID: PE102; Building Materials (All): Steel - Structural; Surfaces (All): Metal - Nickel; Paint - Light Gray; Cover Fill: Background; Slant Angle: 0 deg; Number of Openings: 0; Top Surface: Metal - Nickel; Bottom Surface: Metal - Nickel; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.20 Façanes prefabricades; 104.AMB.ClassificacioCodi: 30.10.10.20; 105.AMB.ClassificacioDescripcio: Façanes prefabricades; 107.AMB.NomTipus: PE102_TipusW; 109.AMB.CodiTipus: PE102; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: TipusW
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Steel - Structural, Embodied Carbon: 0.93381 (kgCO₂); Steel - Structural, Embodied Energy: 14.1197 MJ; Steel - Structural, Component Type: Core
Component Quantities - Steel - Structural, Mass: 0.562536 kg; Steel - Structural, Projected Component Area (Net): 0.002404 m2; Steel - Structural, Projected Component Area (Gross): 0.002404 m2; Steel - Structural, Component Thickness: 0.03 m; Steel - Structural, Rectangular Component Height: 0.002 m; Steel - Structural, Rectangular Component Width: 0.03 m; Steel - Structural, Component Cross Section Area: 0.00006 m2; Steel - Structural, Component Volume (Net): 0.00007212 m3; Steel - Structural, Component Volume (Gross): 0.00007212 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.03 m; 503.AMB.Altura: 0.002 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Surface Area of Both Beam Ends: 0 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.002404 m2; Length Left: 1.27 m; Length Right: 1.27 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.002404 m2; Area: 0.03606 m2; Height: 0.002 m; Volume (Net): 0.00007212 m3; Width: 0.03 m; Surface Area: 0.080528 m2; 3D Length: 1.202 m; Volume (Conditional): 0.00007212 m3; Volume (Gross): 0.0000762 m3; Cross Section Height at Top/End (perpendicular): 0.002 m; Cross Section Height at Bottom/Start (perpendicular): 0.002 m; Cross Section Width at Top/End (perpendicular): 0.03 m; Cross Section Width at Bottom/Start (perpendicular): 0.03 m; Cross Section Height at Top/End (cut): 0.002 m; Cross Section Height at Bottom/Start (cut): 0.002 m; Cross Section Width at Top/End (cut): 0.03 m; Cross Section Width at Bottom/Start (cut): 0.03 m; Cross Section Area at Bottom/Start: 0 m2; Cross Section Area at Top/End: 0 m2; Number of Segments: 1; Top Surface Area (Net): 0.03606 m2; Bottom Surface Area (Net): 0.03606 m2
Name | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m)
2 x PE102 | 2.13613 | 11.4761 | 2.13713 | 11.4771 | 2.13513 | 11.4751
2 x PE102 | 2.17817 | 11.5182 | 2.17917 | 11.5192 | 2.17717 | 11.5172
2 x PE102 | 2.09409 | 11.4341 | 2.09509 | 11.4351 | 2.09309 | 11.4331
2 x PE102 | 2.26226 | 11.6023 | 2.26326 | 11.6033 | 2.26126 | 11.6013
2 x PE102 | 2.22022 | 11.5602 | 2.22122 | 11.5612 | 2.21922 | 11.5592
2 x PE102 | 2.3043 | 11.6443 | 2.3053 | 11.6453 | 2.3033 | 11.6433
2 x PE102 | 2.34635 | 11.6863 | 2.34735 | 11.6873 | 2.34535 | 11.6853
2 x PE102 | 2.38839 | 11.7284 | 2.38939 | 11.7294 | 2.38739 | 11.7274
2 x PE102 | 2.43044 | 11.7704 | 2.43144 | 11.7714 | 2.42944 | 11.7694
2 x PE102 | 2.47248 | 11.8125 | 2.47348 | 11.8135 | 2.47148 | 11.8115
2 x PE102 | 2.51452 | 11.8545 | 2.51552 | 11.8555 | 2.51352 | 11.8535
2 x PE102 | 2.55657 | 11.8966 | 2.55757 | 11.8976 | 2.55557 | 11.8956
2 x PE102 | 2.59861 | 11.9386 | 2.59961 | 11.9396 | 2.59761 | 11.9376
2 x PE102 | 2.64065 | 11.9807 | 2.64165 | 11.9817 | 2.63965 | 11.9797
2 x PE102 | 2.05204 | 11.392 | 2.05304 | 11.393 | 2.05104 | 11.391
2 x PE102 | 2.6827 | 12.0227 | 2.6837 | 12.0237 | 2.6817 | 12.0217
2 x PE102 | 2.72474 | 12.0647 | 2.72574 | 12.0657 | 2.72374 | 12.0637
2 x PE102 | 2.76678 | 12.1068 | 2.76778 | 12.1078 | 2.76578 | 12.1058
2 x PE102 | 2.80883 | 12.1488 | 2.80983 | 12.1498 | 2.80783 | 12.1478
2 x PE102 | 2.85087 | 12.1909 | 2.85187 | 12.1919 | 2.84987 | 12.1899
2 x PE102 | 2.89291 | 12.2329 | 2.89391 | 12.2339 | 2.89191 | 12.2319
2 x PE102 | 2.93496 | 12.275 | 2.93596 | 12.276 | 2.93396 | 12.274
2 x PE102 | 2.977 | 12.317 | 2.978 | 12.318 | 2.976 | 12.316
2 x PE102 | 3.01905 | 12.359 | 3.02005 | 12.36 | 3.01805 | 12.358
2 x PE102 | 3.10313 | 12.4431 | 3.10413 | 12.4441 | 3.10213 | 12.4421
2 x PE102 | 3.14518 | 12.4852 | 3.14618 | 12.4862 | 3.14418 | 12.4842
2 x PE102 | 3.18722 | 12.5272 | 3.18822 | 12.5282 | 3.18622 | 12.5262
2 x PE102 | 3.22926 | 12.5693 | 3.23026 | 12.5703 | 3.22826 | 12.5683
2 x PE102 | 3.27131 | 12.6113 | 3.27231 | 12.6123 | 3.27031 | 12.6103
2 x PE102 | 3.06109 | 12.4011 | 3.06209 | 12.4021 | 3.06009 | 12.4001
2 x PE102 | 3.31335 | 12.6534 | 3.31435 | 12.6544 | 3.31235 | 12.6524
2 x PE102 | 3.35539 | 12.6954 | 3.35639 | 12.6964 | 3.35439 | 12.6944
2 x PE102 | 3.43948 | 12.7795 | 3.44048 | 12.7805 | 3.43848 | 12.7785
2 x PE102 | 3.48152 | 12.8215 | 3.48252 | 12.8225 | 3.48052 | 12.8205
2 x PE102 | 3.52357 | 12.8636 | 3.52457 | 12.8646 | 3.52257 | 12.8626
2 x PE102 | 3.56561 | 12.9056 | 3.56661 | 12.9066 | 3.56461 | 12.9046
2 x PE102 | 3.60766 | 12.9477 | 3.60866 | 12.9487 | 3.60666 | 12.9467
2 x PE102 | 3.6497 | 12.9897 | 3.6507 | 12.9907 | 3.6487 | 12.9887
2 x PE102 | 3.73379 | 13.0738 | 3.73479 | 13.0748 | 3.73279 | 13.0728
2 x PE102 | 3.69174 | 13.0317 | 3.69274 | 13.0327 | 3.69074 | 13.0307
2 x PE102 | 3.77583 | 13.1158 | 3.77683 | 13.1168 | 3.77483 | 13.1148
2 x PE102 | 3.81787 | 13.1579 | 3.81887 | 13.1589 | 3.81687 | 13.1569
2 x PE102 | 3.85992 | 13.1999 | 3.86092 | 13.2009 | 3.85892 | 13.1989
2 x PE102 | 3.39744 | 12.7374 | 3.39844 | 12.7384 | 3.39644 | 12.7364
2 x PE102 | 3.944 | 13.284 | 3.945 | 13.285 | 3.943 | 13.283
2 x PE102 | 3.98605 | 13.326 | 3.98705 | 13.327 | 3.98505 | 13.325
2 x PE102 | 4.02809 | 13.3681 | 4.02909 | 13.3691 | 4.02709 | 13.3671
2 x PE102 | 3.90196 | 13.242 | 3.90296 | 13.243 | 3.90096 | 13.241
2 x PE102 | 4.07013 | 13.4101 | 4.07113 | 13.4111 | 4.06913 | 13.4091
2 x PE102 | 4.11218 | 13.4522 | 4.11318 | 13.4532 | 4.11118 | 13.4512
2 x PE102 | 4.15422 | 13.4942 | 4.15522 | 13.4952 | 4.15322 | 13.4932
2 x PE102 | 4.19627 | 13.5363 | 4.19727 | 13.5373 | 4.19527 | 13.5353
2 x PE102 | 4.23831 | 13.5783 | 4.23931 | 13.5793 | 4.23731 | 13.5773
2 x PE102 | 4.28035 | 13.6204 | 4.28135 | 13.6214 | 4.27935 | 13.6194
2 x PE102 | 4.3224 | 13.6624 | 4.3234 | 13.6634 | 4.3214 | 13.6614
2 x PE102 | 4.36444 | 13.7044 | 4.36544 | 13.7054 | 4.36344 | 13.7034
2 x PE102 | 4.40648 | 13.7465 | 4.40748 | 13.7475 | 4.40548 | 13.7455
2 x PE102 | 4.44853 | 13.7885 | 4.44953 | 13.7895 | 4.44753 | 13.7875
2 x PE102 | 4.49057 | 13.8306 | 4.49157 | 13.8316 | 4.48957 | 13.8296

# IfcBuildingElementProxy: Steel - Structural 30 x 5 (4)
In: planta baixa
Classification: 30.10.10.20 Façanes prefabricades (GuBIMclass CA); Material: Steel - Structural
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Metal - Nickel; Left Side Surface: Metal - Nickel; Right Side Surface: Metal - Nickel; Beam Slant Angle: 0 deg; Element ID: PE102; Hotlink and Element ID: PE102; Layer: 00_TRAMEX; Building Material / Composite / Profile / Fill: Steel - Structural; Building Material: Steel - Structural; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Parent ID: PE102; Building Materials (All): Steel - Structural; Surfaces (All): Metal - Nickel; Paint - Light Gray; Cover Fill: Background; Slant Angle: 0 deg; Number of Openings: 0; Top Surface: Metal - Nickel; Bottom Surface: Metal - Nickel; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.20 Façanes prefabricades; 104.AMB.ClassificacioCodi: 30.10.10.20; 105.AMB.ClassificacioDescripcio: Façanes prefabricades; 107.AMB.NomTipus: PE102_TipusW; 109.AMB.CodiTipus: PE102; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: TipusW
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Steel - Structural, Component Type: Core
Component Quantities - Steel - Structural, Component Thickness: 0.03 m; Steel - Structural, Rectangular Component Height: 0.005 m; Steel - Structural, Rectangular Component Width: 0.03 m; Steel - Structural, Component Cross Section Area: 0.00015 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.03 m; 503.AMB.Altura: 0.005 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Length Left: 1.27 m; Length Right: 1.27 m; Offset: 0 m; Height: 0.005 m; Width: 0.03 m; Volume (Gross): 0.0001905 m3; Cross Section Height at Top/End (perpendicular): 0.005 m; Cross Section Height at Bottom/Start (perpendicular): 0.005 m; Cross Section Width at Top/End (perpendicular): 0.03 m; Cross Section Width at Bottom/Start (perpendicular): 0.03 m; Cross Section Height at Top/End (cut): 0.005 m; Cross Section Height at Bottom/Start (cut): 0.005 m; Cross Section Width at Top/End (cut): 0.03 m; Cross Section Width at Bottom/Start (cut): 0.03 m; Number of Segments: 1; Top Surface Area (Net): 0.03606 m2
Name | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | Steel - Structural, Mass (kg) | Steel - Structural, Projected Component Area (Net) (m2) = Steel - Structural, Projected Component Area (Gross) (m2) | Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3) = Volume (Net) (m3) = Volume (Conditional) (m3) | Surface Area of Both Beam Ends (m2) | Surface Area of the Beam Left Side (Net) (m2) = Surface Area of the Beam Right Side (Net) (m2) | Area (m2) = Bottom Surface Area (Net) (m2) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | Surface Area (m2) | 3D Length (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Cross Section Area at Bottom/Start (m2) = Cross Section Area at Top/End (m2)
2 x PE102 | 2.40056 (kgCO₂) | 36.2976 | 1.44612 | 0.00618 | 0.0001854 | 0.00015 | 0.00618 | 0.0381 | 2.01 | 11.35 | 0.09321 | 1.27 | 2.0125 | 11.3525 | 2.0075 | 11.3475 | 0.000075
2 x PE102 | 2.33452 (kgCO₂) | 35.2991 | 1.40634 | 0.00601001 | 0.0001803 | 0 | 0.00601 | 0.03606 | 4.53261 | 13.8726 | 0.09314 | 1.202 | 4.53511 | 13.8751 | 4.53011 | 13.8701 | 0

# IfcBuildingElementProxy: Steel - Structural 5 x 30 (4)
In: planta baixa
Classification: 30.10.10.20 Façanes prefabricades (GuBIMclass CA); Material: Steel - Structural
ArchiCADProperties - Column Cross Section: Rectangular; Column Slant Angle: 90 deg; Extrusion Surface: Metal - Nickel; End Surface: Metal - Nickel; Element ID: PE102; Hotlink and Element ID: PE102; Layer: 00_TRAMEX; Building Material / Composite / Profile / Fill: Steel - Structural; Building Material: Steel - Structural; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Column; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: PE102; Building Materials (All): Steel - Structural; Surfaces (All): Metal - Nickel; Cover Fill: Background; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.20 Façanes prefabricades; 104.AMB.ClassificacioCodi: 30.10.10.20; 105.AMB.ClassificacioDescripcio: Façanes prefabricades; 107.AMB.NomTipus: PE102_TipusW; 109.AMB.CodiTipus: PE102; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: TipusW
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Steel - Structural, Embodied Carbon: 4.90428 (kgCO₂); Steel - Structural, Embodied Energy: 74.155 MJ; Steel - Structural, Component Type: Core
ArchiCADQuantities - Core Height / Diameter: 0.03 m; Volume of the Column Core (Net): 0.000378767 m3; Core Width: 0.005 m; Surface Area of the Column Core (Gross, without Top/Bottom): 0.176758 m2; Surface Area of the Column Core Top (Gross): 0.00015 m2; Surface Area of the Column Core Bottom (Gross): 0.00015 m2; Volume of the Column Core (Gross): 0.000378767 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 2.52511 m; Minimum Height of the Column: 2.52511 m; Surface Area of the Column Core Bottom (Net): 0.00015 m2; Surface Area of the Column Core (Net, without Top/Bottom): 0.176758 m2; Surface Area of the Column Core Top (Net): 0.00015 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 0.07 m; Volume of the Column Veneer (Net): 0 m3; Area: 0.00015 m2; Height: 2.52511 m; Volume (Net): 0.000378767 m3; Width: 0.005 m; Elevation to Project Zero: 2.01 m; Elevation to 1st Reference Level: 2.01 m; Elevation to 2nd Reference Level: 2.01 m; Elevation to Sea Level: 11.35 m; Elevation to Linked/Home Story: 2.01 m; Home Offset: 2.01 m; Top Offset: 1.44108 m; Surface Area: 0.176758 m2; 3D Length: 2.52511 m; Volume (Gross): 0.000378767 m3; Top Elevation To First Reference Level: 4.53511 m; Top Elevation To Home Story: 4.53511 m; Top Elevation To Project Zero: 4.53511 m; Top Elevation To Sea Level: 13.8751 m; Top Elevation To Second Reference Level: 4.53511 m; Bottom Elevation To First Reference Level: 2.01 m; Bottom Elevation To Home Story: 2.01 m; Bottom Elevation To Project Zero: 2.01 m; Bottom Elevation To Sea Level: 11.35 m; Bottom Elevation To Second Reference Level: 2.01 m; Cross Section Height at Top/End (perpendicular): 0.03 m; Cross Section Height at Bottom/Start (perpendicular): 0.03 m; Cross Section Width at Top/End (perpendicular): 0.005 m; Cross Section Width at Bottom/Start (perpendicular): 0.005 m; Cross Section Height at Top/End (cut): 0.03 m; Cross Section Height at Bottom/Start (cut): 0.03 m; Cross Section Width at Top/End (cut): 0.005 m; Cross Section Width at Bottom/Start (cut): 0.005 m; Cross Section Area at Bottom/Start: 0.00015 m2; Cross Section Area at Top/End: 0.00015 m2; Number of Segments: 1; Top Surface Area (Net): 0.00015 m2; Bottom Surface Area (Net): 0.176758 m2; Top Surface Area (Gross): 0.00015 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.005 m; 503.AMB.Altura: 2.52511 m; 506.AMB.Profunditat: 0 m
Component Quantities - Steel - Structural, Mass: 2.95438 kg; Steel - Structural, Component Thickness: 0.005 m; Steel - Structural, Rectangular Component Height: 0.03 m; Steel - Structural, Rectangular Component Width: 0.005 m; Steel - Structural, Component Cross Section Area: 0.00015 m2; Steel - Structural, Component Volume (Net): 0.000378767 m3; Steel - Structural, Component Volume (Gross): 0.000378767 m3

# IfcBuildingElementProxy: Steel Universal Section (1) 160 x 160 (76)
In: planta baixa
Material: Steel - Structural
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
ArchiCADProperties - Extrusion Surface: Paint - Anthracite; End Surface: Paint - Anthracite; Building Material / Composite / Profile / Fill: Steel Universal Section (1); Complex Profile: Steel Universal Section (1); Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Structure Type: Complex Profile; Profile Category: Steel Universal Section (1); Building Materials (All): Steel - Structural; Cover Fill: Background; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Component Properties - Steel - Structural, Component Type: Core
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Cross Section Height at Top/End (perpendicular): 0.160001 m; Cross Section Height at Bottom/Start (perpendicular): 0.160001 m; Number of Segments: 1
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
Name | Classification | 201.AMB.EsEstructural | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 109.AMB.CodiTipus = Element ID = Hotlink and Element ID = Parent ID | Layer | Element Type | Surfaces (All) | Slant Angle (deg) | AUX_104.AMB.ClassificacioCodiCateg | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | Area (m2) | Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) | Width (m) = Cross Section Width at Top/End (perpendicular) (m) = Cross Section Width at Bottom/Start (perpendicular) (m) = Cross Section Width at Top/End (cut) (m) = Cross Section Width at Bottom/Start (cut) (m) = 502.AMB.Amplada (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Cross Section Height at Top/End (cut) (m) | Cross Section Height at Bottom/Start (cut) (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) | Steel - Structural, Mass (kg) | Steel - Structural, Component Cross Section Area (m2) | Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3)
CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 440.919 (kgCO₂) | 6666.91 | 0.0058402 | 5.8308 | 0.0340531 | 0.16 | 0.27 | 9.61 | 5.5043 | 5.93065 | 0.0340531 | 6.20065 | 15.5407 | 0.27 | 9.61 | 0.255888 | 0.160001 | 0.0058402 | 0.00934019 | 0.00934019 | 5.5043 | 265.614 | 0.0058402 | 0.0340531 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0340531 m3; Core Width: 0.16 m; Surface Area of the Column Core (Gross, without Top/Bottom): 5.5043 m2; Surface Area of the Column Core Top (Gross): 0.00934019 m2; Surface Area of the Column Core Bottom (Gross): 0.0058402 m2; Volume of the Column Core (Gross): 0.0340531 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 5.93065 m; Minimum Height of the Column: 5.73096 m; Surface Area of the Column Core Bottom (Net): 0.0058402 m2; Surface Area of the Column Core (Net, without Top/Bottom): 5.5043 m2; Surface Area of the Column Core Top (Net): 0.00934019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00934019 m2
CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 333.333 (kgCO₂) | 5040.15 | 0.00584021 | 4.40805 | 0.0257439 | 0.160001 | 0.27 | 9.61 | 4.16122 | 4.46631 | 0.0257439 | 4.73631 | 14.0763 | 0.27 | 9.61 | 0.197934 | 0.160001 | 0.00584021 | 0.00722481 | 0.00722481 | 4.16122 | 200.803 | 0.00584021 | 0.0257439 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0257439 m3; Core Width: 0.160001 m; Surface Area of the Column Core (Gross, without Top/Bottom): 4.16122 m2; Surface Area of the Column Core Top (Gross): 0.00722481 m2; Surface Area of the Column Core Bottom (Gross): 0.00584021 m2; Volume of the Column Core (Gross): 0.0257439 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 4.46631 m; Minimum Height of the Column: 4.34979 m; Surface Area of the Column Core Bottom (Net): 0.00584021 m2; Surface Area of the Column Core (Net, without Top/Bottom): 4.16122 m2; Surface Area of the Column Core Top (Net): 0.00722481 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00722481 m2
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 422.547 (kgCO₂) | 6389.12 | 0.911639 | 0.160001 | 0.0326342 | 0.16 | 6.1008 | 15.4408 | 5.4239 | 5.88255 | 0.0333493 | 6.20469 | 15.5447 | 4.61966 | 13.9597 | 0.207534 | 0.265864 | 0.00795373 | 0.00438438 | 1.77338 | 1.75198 | 254.546 | 0.0058402 | 0.0326342 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0123381 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.868536 m2; Length Left: 5.71029 m; Length Right: 5.71029 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.904768 m2; Volume (Conditional): 0.0326342 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 229.533 (kgCO₂) | 3470.65 | 0.499591 | 0.160001 | 0.0177273 | 0.16 | 5.43422 | 14.7742 | 2.92802 | 3.26119 | 0.0180758 | 5.4755 | 14.8155 | 4.58191 | 13.9219 | 0.165191 | 0.332225 | 0.0121266 | 0 | 0.948905 | 0.961032 | 138.273 | 0.0058402 | 0.0177273 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; Colliding Zones: Nau Santa Eulàlia; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0121266 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.472844 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.491208 m2; Volume (Conditional): 0.0177273 m3
2 x CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 440.845 (kgCO₂) | 6665.79 | 0.0058402 | 5.82983 | 0.0340474 | 0.16 | 0.27 | 9.61 | 5.50337 | 5.92967 | 0.0340474 | 6.19967 | 15.5397 | 0.27 | 9.61 | 0.255888 | 0.160001 | 0.0058402 | 0.00934019 | 0.00934019 | 5.50337 | 265.569 | 0.0058402 | 0.0340474 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0340474 m3; Core Width: 0.16 m; Surface Area of the Column Core (Gross, without Top/Bottom): 5.50337 m2; Surface Area of the Column Core Top (Gross): 0.00934019 m2; Surface Area of the Column Core Bottom (Gross): 0.0058402 m2; Volume of the Column Core (Gross): 0.0340474 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 5.92967 m; Minimum Height of the Column: 5.72998 m; Surface Area of the Column Core Bottom (Net): 0.0058402 m2; Surface Area of the Column Core (Net, without Top/Bottom): 5.50337 m2; Surface Area of the Column Core Top (Net): 0.00934019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00934019 m2
5 x CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 333.534 (kgCO₂) | 5043.19 | 0.00584021 | 4.41071 | 0.0257595 | 0.160001 | 0.27 | 9.61 | 4.16373 | 4.46897 | 0.0257595 | 4.73897 | 14.079 | 0.27 | 9.61 | 0.197934 | 0.160001 | 0.00584021 | 0.00722481 | 0.00722481 | 4.16373 | 200.924 | 0.00584021 | 0.0257595 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0257595 m3; Core Width: 0.160001 m; Surface Area of the Column Core (Gross, without Top/Bottom): 4.16373 m2; Surface Area of the Column Core Top (Gross): 0.00722481 m2; Surface Area of the Column Core Bottom (Gross): 0.00584021 m2; Volume of the Column Core (Gross): 0.0257595 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 4.46897 m; Minimum Height of the Column: 4.35245 m; Surface Area of the Column Core Bottom (Net): 0.00584021 m2; Surface Area of the Column Core (Net, without Top/Bottom): 4.16373 m2; Surface Area of the Column Core Top (Net): 0.00722481 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00722481 m2
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 229.522 (kgCO₂) | 3470.48 | 0.499564 | 0.160001 | 0.0177264 | 0.16 | 5.43422 | 14.7742 | 2.93991 | 3.26119 | 0.0180758 | 5.4755 | 14.8155 | 4.58191 | 13.9219 | 0.165191 | 0.332225 | 0.0121266 | 0.00602964 | 0.948849 | 0.960977 | 138.266 | 0.0058402 | 0.0177264 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; Colliding Zones: Nau Santa Eulàlia; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0181562 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.47281 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.491187 m2; Volume (Conditional): 0.0177264 m3
2 x CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 332.548 (kgCO₂) | 5028.28 | 0.00584021 | 4.39767 | 0.0256833 | 0.160001 | 0.27 | 9.61 | 4.15142 | 4.45593 | 0.0256833 | 4.72593 | 14.0659 | 0.27 | 9.61 | 0.197934 | 0.160001 | 0.00584021 | 0.00722481 | 0.00722481 | 4.15142 | 200.33 | 0.00584021 | 0.0256833 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0256833 m3; Core Width: 0.160001 m; Surface Area of the Column Core (Gross, without Top/Bottom): 4.15142 m2; Surface Area of the Column Core Top (Gross): 0.00722481 m2; Surface Area of the Column Core Bottom (Gross): 0.00584021 m2; Volume of the Column Core (Gross): 0.0256833 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 4.45593 m; Minimum Height of the Column: 4.33941 m; Surface Area of the Column Core Bottom (Net): 0.00584021 m2; Surface Area of the Column Core (Net, without Top/Bottom): 4.15142 m2; Surface Area of the Column Core Top (Net): 0.00722481 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00722481 m2
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 422.017 (kgCO₂) | 6381.1 | 0.91103 | 0.160001 | 0.0325932 | 0.16 | 6.09983 | 15.4398 | 5.42154 | 5.87861 | 0.0333263 | 6.20372 | 15.5437 | 4.61966 | 13.9597 | 0.207534 | 0.265864 | 0.003135 | 0.00537725 | 1.77207 | 1.74939 | 254.227 | 0.0058402 | 0.0325932 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.00851225 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.867781 m2; Length Left: 5.70636 m; Length Right: 5.70636 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.903312 m2; Volume (Conditional): 0.0325932 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 229.524 (kgCO₂) | 3470.51 | 0.499564 | 0.160001 | 0.0177266 | 0.16 | 5.43422 | 14.7742 | 2.93991 | 3.26119 | 0.0180758 | 5.4755 | 14.8155 | 4.58191 | 13.9219 | 0.165191 | 0.332225 | 0.0121266 | 0.00602964 | 0.948849 | 0.960976 | 138.267 | 0.0058402 | 0.0177266 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; Colliding Zones: Nau Santa Eulàlia; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0181562 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.47281 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.491187 m2; Volume (Conditional): 0.0177266 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 422.125 (kgCO₂) | 6382.73 | 0.91103 | 0.160001 | 0.0326015 | 0.16 | 6.09983 | 15.4398 | 5.41908 | 5.87861 | 0.0333263 | 6.20372 | 15.5437 | 4.61966 | 13.9597 | 0.207534 | 0.265864 | 0.00236874 | 0.00683874 | 1.77157 | 1.75143 | 254.292 | 0.0058402 | 0.0326015 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.00920748 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.867149 m2; Length Left: 5.70636 m; Length Right: 5.70636 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.904851 m2; Volume (Conditional): 0.0326015 m3
CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 441.24 (kgCO₂) | 6671.76 | 0.0058402 | 5.83504 | 0.0340778 | 0.16 | 0.27 | 9.61 | 5.5083 | 5.93489 | 0.0340778 | 6.20489 | 15.5449 | 0.27 | 9.61 | 0.255888 | 0.160001 | 0.0058402 | 0.00934019 | 0.00934019 | 5.5083 | 265.807 | 0.0058402 | 0.0340778 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0340778 m3; Core Width: 0.16 m; Surface Area of the Column Core (Gross, without Top/Bottom): 5.5083 m2; Surface Area of the Column Core Top (Gross): 0.00934019 m2; Surface Area of the Column Core Bottom (Gross): 0.0058402 m2; Volume of the Column Core (Gross): 0.0340778 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 5.93489 m; Minimum Height of the Column: 5.73519 m; Surface Area of the Column Core Bottom (Net): 0.0058402 m2; Surface Area of the Column Core (Net, without Top/Bottom): 5.5083 m2; Surface Area of the Column Core Top (Net): 0.00934019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00934019 m2
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 421.432 (kgCO₂) | 6372.26 | 0.910311 | 0.160001 | 0.0325481 | 0.16 | 6.09983 | 15.4398 | 5.41944 | 5.87861 | 0.0333263 | 6.20372 | 15.5437 | 4.61966 | 13.9597 | 0.207534 | 0.265864 | 0.00513557 | 0.00619112 | 1.76978 | 1.74937 | 253.875 | 0.0058402 | 0.0325481 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0113267 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.865368 m2; Length Left: 5.70636 m; Length Right: 5.70636 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.904239 m2; Volume (Conditional): 0.0325481 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 229.527 (kgCO₂) | 3470.56 | 0.499564 | 0.160001 | 0.0177268 | 0.16 | 5.43422 | 14.7742 | 2.93991 | 3.26119 | 0.0180758 | 5.4755 | 14.8155 | 4.58191 | 13.9219 | 0.165191 | 0.332225 | 0.0121266 | 0.00602964 | 0.948848 | 0.960975 | 138.269 | 0.0058402 | 0.0177268 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; Colliding Zones: Nau Santa Eulàlia; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0181562 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.47281 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.491187 m2; Volume (Conditional): 0.0177268 m3
CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 441.147 (kgCO₂) | 6670.36 | 0.0058402 | 5.83382 | 0.0340707 | 0.16 | 0.27 | 9.61 | 5.50714 | 5.93367 | 0.0340707 | 6.20367 | 15.5437 | 0.27 | 9.61 | 0.255888 | 0.160001 | 0.0058402 | 0.00934019 | 0.00934019 | 5.50714 | 265.751 | 0.0058402 | 0.0340707 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0340707 m3; Core Width: 0.16 m; Surface Area of the Column Core (Gross, without Top/Bottom): 5.50714 m2; Surface Area of the Column Core Top (Gross): 0.00934019 m2; Surface Area of the Column Core Bottom (Gross): 0.0058402 m2; Volume of the Column Core (Gross): 0.0340707 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 5.93367 m; Minimum Height of the Column: 5.73397 m; Surface Area of the Column Core Bottom (Net): 0.0058402 m2; Surface Area of the Column Core (Net, without Top/Bottom): 5.50714 m2; Surface Area of the Column Core Top (Net): 0.00934019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00934019 m2
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 423.128 (kgCO₂) | 6397.9 | 0.913247 | 0.160001 | 0.032679 | 0.16 | 6.10382 | 15.4438 | 5.43295 | 5.89467 | 0.0334201 | 6.20771 | 15.5477 | 4.61966 | 13.9597 | 0.207534 | 0.265864 | 0.00970431 | 0.00164488 | 1.77553 | 1.75642 | 254.897 | 0.0058402 | 0.032679 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0113492 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.870466 m2; Length Left: 5.72242 m; Length Right: 5.72242 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.906068 m2; Volume (Conditional): 0.032679 m3
CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 441.225 (kgCO₂) | 6671.53 | 0.0058402 | 5.83485 | 0.0340767 | 0.16 | 0.27 | 9.61 | 5.50811 | 5.93469 | 0.0340767 | 6.20469 | 15.5447 | 0.27 | 9.61 | 0.255888 | 0.160001 | 0.0058402 | 0.00934019 | 0.00934019 | 5.50811 | 265.798 | 0.0058402 | 0.0340767 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0340767 m3; Core Width: 0.16 m; Surface Area of the Column Core (Gross, without Top/Bottom): 5.50811 m2; Surface Area of the Column Core Top (Gross): 0.00934019 m2; Surface Area of the Column Core Bottom (Gross): 0.0058402 m2; Volume of the Column Core (Gross): 0.0340767 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 5.93469 m; Minimum Height of the Column: 5.735 m; Surface Area of the Column Core Bottom (Net): 0.0058402 m2; Surface Area of the Column Core (Net, without Top/Bottom): 5.50811 m2; Surface Area of the Column Core Top (Net): 0.00934019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00934019 m2
CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 334.016 (kgCO₂) | 5050.49 | 0.00584021 | 4.41709 | 0.0257967 | 0.160001 | 0.27 | 9.61 | 4.16975 | 4.47535 | 0.0257967 | 4.74535 | 14.0854 | 0.27 | 9.61 | 0.197934 | 0.160001 | 0.00584021 | 0.00722481 | 0.00722481 | 4.16975 | 201.215 | 0.00584021 | 0.0257967 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0257967 m3; Core Width: 0.160001 m; Surface Area of the Column Core (Gross, without Top/Bottom): 4.16975 m2; Surface Area of the Column Core Top (Gross): 0.00722481 m2; Surface Area of the Column Core Bottom (Gross): 0.00584021 m2; Volume of the Column Core (Gross): 0.0257967 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 4.47535 m; Minimum Height of the Column: 4.35883 m; Surface Area of the Column Core Bottom (Net): 0.00584021 m2; Surface Area of the Column Core (Net, without Top/Bottom): 4.16975 m2; Surface Area of the Column Core Top (Net): 0.00722481 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00722481 m2
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 424.008 (kgCO₂) | 6411.2 | 0.914158 | 0.160001 | 0.032747 | 0.16 | 6.10485 | 15.4448 | 5.43735 | 5.8988 | 0.0334442 | 6.20873 | 15.5487 | 4.61966 | 13.9597 | 0.207534 | 0.265864 | 0.00970431 | 0.00757523 | 1.77846 | 1.75876 | 255.426 | 0.0058402 | 0.032747 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0172795 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.871199 m2; Length Left: 5.72655 m; Length Right: 5.72655 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.908156 m2; Volume (Conditional): 0.032747 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 230.724 (kgCO₂) | 3488.66 | 0.501979 | 0.160001 | 0.0178193 | 0.16 | 5.43422 | 14.7742 | 2.94146 | 3.26119 | 0.0180758 | 5.4755 | 14.8155 | 4.58191 | 13.9219 | 0.165191 | 0.332225 | 0.0121266 | 0.00471293 | 0.953698 | 0.965825 | 138.99 | 0.0058402 | 0.0178193 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; Colliding Zones: Nau Santa Eulàlia; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0168395 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.47555 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.4932 m2; Volume (Conditional): 0.0178193 m3
CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 441.297 (kgCO₂) | 6672.62 | 0.0058402 | 5.8358 | 0.0340822 | 0.16 | 0.27 | 9.61 | 5.50901 | 5.93564 | 0.0340822 | 6.20564 | 15.5456 | 0.27 | 9.61 | 0.255888 | 0.160001 | 0.0058402 | 0.00934019 | 0.00934019 | 5.50901 | 265.841 | 0.0058402 | 0.0340822 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0340822 m3; Core Width: 0.16 m; Surface Area of the Column Core (Gross, without Top/Bottom): 5.50901 m2; Surface Area of the Column Core Top (Gross): 0.00934019 m2; Surface Area of the Column Core Bottom (Gross): 0.0058402 m2; Volume of the Column Core (Gross): 0.0340822 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 5.93564 m; Minimum Height of the Column: 5.73595 m; Surface Area of the Column Core Bottom (Net): 0.0058402 m2; Surface Area of the Column Core (Net, without Top/Bottom): 5.50901 m2; Surface Area of the Column Core Top (Net): 0.00934019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00934019 m2
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 424.297 (kgCO₂) | 6415.57 | 0.91475 | 0.160001 | 0.0327693 | 0.16 | 6.1058 | 15.4458 | 5.44096 | 5.90262 | 0.0334665 | 6.20968 | 15.5497 | 4.61966 | 13.9597 | 0.207534 | 0.265864 | 0.00970431 | 0.00757523 | 1.77966 | 1.75995 | 255.6 | 0.0058402 | 0.0327693 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0172795 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.871811 m2; Length Left: 5.73037 m; Length Right: 5.73037 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.908767 m2; Volume (Conditional): 0.0327693 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 230.781 (kgCO₂) | 3489.53 | 0.50201 | 0.160001 | 0.0178237 | 0.16 | 5.43422 | 14.7742 | 2.94128 | 3.26119 | 0.0180758 | 5.4755 | 14.8155 | 4.58191 | 13.9219 | 0.165191 | 0.332225 | 0.0121266 | 0.00470811 | 0.953735 | 0.965862 | 139.025 | 0.0058402 | 0.0178237 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; Colliding Zones: Nau Santa Eulàlia; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0168347 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.47608 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.4932 m2; Volume (Conditional): 0.0178237 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 424.703 (kgCO₂) | 6421.71 | 0.915582 | 0.160001 | 0.0328006 | 0.16 | 6.10713 | 15.4471 | 5.44603 | 5.90799 | 0.0334978 | 6.21102 | 15.551 | 4.61966 | 13.9597 | 0.207534 | 0.265864 | 0.00970431 | 0.00757523 | 1.78133 | 1.76163 | 255.845 | 0.0058402 | 0.0328006 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0172795 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.87267 m2; Length Left: 5.73574 m; Length Right: 5.73574 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.909626 m2; Volume (Conditional): 0.0328006 m3
