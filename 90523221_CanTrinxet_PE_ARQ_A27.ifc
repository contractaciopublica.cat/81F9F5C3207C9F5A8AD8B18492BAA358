Properties of the parts of a building model (IFC2X3), part 32 of 99

# IfcBuildingElementProxy: Rhino_Object_1232, Object_1232
AC_Pset_Rhino_Object_1232 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1233, Object_1233
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1233; Hotlink and Element ID: Object_1233; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1233; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1233; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1233 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1233_; 109.AMB.CodiTipus: Object_1233; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Equantity_Rhino_Object_1233 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426585 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2

# IfcBuildingElementProxy: Rhino_Object_1234, Object_1234
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1234_; 109.AMB.CodiTipus: Object_1234; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1234 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1234; Hotlink and Element ID: Object_1234; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1234; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1234; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426585 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1234 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m

# IfcBuildingElementProxy: Rhino_Object_1235, Object_1235
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1235; Hotlink and Element ID: Object_1235; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1235; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1235; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1235 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1235_; 109.AMB.CodiTipus: Object_1235; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1235 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426585 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2

# IfcBuildingElementProxy: Rhino_Object_1236, Object_1236
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1236; Hotlink and Element ID: Object_1236; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1236; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1236; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1236 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426586 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1236 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1236_; 109.AMB.CodiTipus: Object_1236; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1237, Object_1237
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1237 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1237; Hotlink and Element ID: Object_1237; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1237; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1237; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1237_; 109.AMB.CodiTipus: Object_1237; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426586 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1237 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1238, Object_1238
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1238; Hotlink and Element ID: Object_1238; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1238; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1238; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1238 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1238_; 109.AMB.CodiTipus: Object_1238; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426586 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1238 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1239, Object_1239
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1239; Hotlink and Element ID: Object_1239; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1239; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1239; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1239 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1239_; 109.AMB.CodiTipus: Object_1239; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426586 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1239 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_124, Object_124
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_124; Hotlink and Element ID: Object_124; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_124; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_124; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_124 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_124_; 109.AMB.CodiTipus: Object_124; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426575 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_124 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1240, Object_1240
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1240; Hotlink and Element ID: Object_1240; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1240; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1240; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1240 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426586 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1240_; 109.AMB.CodiTipus: Object_1240; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1240 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg

# IfcBuildingElementProxy: Rhino_Object_1241, Object_1241
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1241_; 109.AMB.CodiTipus: Object_1241; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1241 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1241; Hotlink and Element ID: Object_1241; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1241; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1241; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426587 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
AC_Equantity_Rhino_Object_1241 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_1242, Object_1242
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1242; Hotlink and Element ID: Object_1242; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1242; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1242; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1242 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1242_; 109.AMB.CodiTipus: Object_1242; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1242 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1243, Object_1243
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1243; Hotlink and Element ID: Object_1243; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1243; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1243; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1243 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1243_; 109.AMB.CodiTipus: Object_1243; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
AC_Equantity_Rhino_Object_1243 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m

# IfcBuildingElementProxy: Rhino_Object_1244, Object_1244
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1244; Hotlink and Element ID: Object_1244; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1244; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1244; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1244 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1244_; 109.AMB.CodiTipus: Object_1244; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1244 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1245, Object_1245
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1245; Hotlink and Element ID: Object_1245; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1245; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1245; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1245 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1245_; 109.AMB.CodiTipus: Object_1245; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
AC_Equantity_Rhino_Object_1245 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m

# IfcBuildingElementProxy: Rhino_Object_1246, Object_1246
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1246 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1246_; 109.AMB.CodiTipus: Object_1246; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1246; Hotlink and Element ID: Object_1246; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1246; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1246; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1246 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426589 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2

# IfcBuildingElementProxy: Rhino_Object_1247, Object_1247
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
