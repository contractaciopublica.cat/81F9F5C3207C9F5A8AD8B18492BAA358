Properties of the parts of a building model (IFC2X3), part 6 of 99

# IfcBuildingElementProxy: Concrete 20-5-5 300, S2
ArchiCADProperties - Reference Plane Location: Top; Element ID: S2; Hotlink and Element ID: S2; Layer: 00_PAVIMENTOS; Building Material / Composite / Profile / Fill: Concrete 20-5-5; Composite Structure: Concrete 20-5-5; Colliding Zones: Instal·lacions; Lavabo; Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Composite; Parent ID: S2; Building Materials (All): Stone - Finish; Insulation - Mineral Hard; Concrete - Structural; Surfaces (All): Stone - Marble Carrara White; Concrete - Architecture; Insulation - Cellulose; Concrete - Bush hammered; Cover Fill: Grid 20x20; Number of Openings: 0; Top Surface: Concrete - Architecture; Edge Surface: Concrete - Architecture; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 40.20.20.20 Paviments; 104.AMB.ClassificacioCodi: 40.20.20.20; 105.AMB.ClassificacioDescripcio: Paviments; 107.AMB.NomTipus: S2_SoleraFormigo; 109.AMB.CodiTipus: S2; 111.AMB.DescripcioTipus: Solera de formigó en banys amb acabat de terratzo fet in situ i juntes de llautó; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40; AUX_107.NomTipus: SoleraFormigo
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Elevation Bottom: 0.7 m; Surface Area of the Slab Top (Conditional): 11.1815 m2; Surface Area of the Slab Bottom (Gross): 11.1854 m2; Surface Area of the Slab Bottom (Gross, with holes): 11.1854 m2; Surface Area of the Slab Edges (Gross): 4.08189 m2; Surface Area of the Slab Edges (Gross, with holes): 4.08189 m2; Surface Area of the Slab Top (Gross): 11.1854 m2; Surface Area of the Slab Top (Gross, with holes): 11.1854 m2; Holes Surface Area: 0.00393035 m2; Elevation Top: 1 m; Area: 11.1815 m2; Height: 0.3 m; Volume (Net): 3.35444 m3; Elevation to Project Zero: 1 m; Elevation to 1st Reference Level: 1 m; Elevation to 2nd Reference Level: 1 m; Elevation to Sea Level: 10.34 m; Elevation to Linked/Home Story: 1 m; Home Offset: 1 m; Surface Area: 11.1815 m2; Thickness: 0.3 m; Volume (Conditional): 3.35444 m3; Volume (Gross): 3.35562 m3; Floor Plan Perimeter: 13.6063 m; Floor Plan Holes Perimeter: 0 m; Top Elevation To First Reference Level: 1 m; Top Elevation To Home Story: 1 m; Top Elevation To Project Zero: 1 m; Top Elevation To Sea Level: 10.34 m; Top Elevation To Second Reference Level: 1 m; Bottom Elevation To First Reference Level: 0.7 m; Bottom Elevation To Home Story: 0.7 m; Bottom Elevation To Project Zero: 0.7 m; Bottom Elevation To Sea Level: 10.04 m; Bottom Elevation To Second Reference Level: 0.7 m; Top Surface Area (Net): 11.1815 m2; Top Surface Area (Conditional): 11.1815 m2; Edge Surface Area (Net): 3.1025 m2; Bottom Surface Area (Net): 11.1815 m2; Bottom Surface Area (Conditional): 11.1815 m2; Bottom Surface Area (Gross): 11.1854 m2; Edge Surface Area (Gross): 4.08189 m2; Top Surface Area (Gross): 11.1854 m2
5 AMB.Geometria - 503.AMB.Altura: 0.3 m; 504.AMB.Gruix: 0.3 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Concrete 29 (2)
In: planta coberta
Classification: 30.20.10 Cobertes (GuBIMclass CA); Material: Concrete
ArchiCADProperties - Geometry Method: Single-plane; Pitch: -14.4 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: Cu1; Hotlink and Element ID: Cu1; Layer: 00_CUBIERTA; Building Material / Composite / Profile / Fill: Concrete; Building Material: Concrete; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Roof; Structure Type: Basic; Parent ID: Cu1; Building Materials (All): Concrete; Surfaces (All): Concrete - Architecture; Cover Fill: Roof Tile 01; Edge Surface: Concrete - Architecture; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 107.AMB.NomTipus: Cu1_CobertaInclinadaR60; 109.AMB.CodiTipus: Cu1; 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.0289606 m; Vertical Thickness: 0.0299 m; Height: 0.0289606 m
5 AMB.Geometria - 503.AMB.Altura: 0.0289606 m; 504.AMB.Gruix: 0.0289606 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete, Component Thickness: 0.0289606 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: CobertaInclinadaR60
Name | Concrete, Embodied Carbon | Concrete, Embodied Energy (MJ) | Surface Area of the Roof Bottom (Gross) (m2) = Surface Area of the Roof Top (Gross) (m2) = Surface Area of the Roof Bottom (Net) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Concrete, Mass (kg) | Concrete, Projected Component Area (Net) (m2) = Concrete, Projected Component Area (Gross) (m2) | Concrete, Component Volume (Net) (m3) = Concrete, Component Volume (Gross) (m3)
Cu1 | 99.9353 (kgCO₂) | 691.141 | 17.9166 | 1.24322 | 6.29306 | 15.6331 | 1.79306 | 4.86328 | 0.363284 | 14.2033 | 4.60942 | 0.109423 | 13.9494 | 933.975 | 18.0647 | 0.518875
Cu1 | 128.067 (kgCO₂) | 885.699 | 22.9601 | 1.31449 | 6.2936 | 15.6336 | 1.7936 | 4.91431 | 0.414311 | 14.2543 | 4.60996 | 0.109958 | 13.95 | 1196.89 | 23.1157 | 0.664939

# IfcBuildingElementProxy: Concrete 30, Cu5
In: planta baixa
Classification: 30.20.10 Cobertes (GuBIMclass CA); Material: Concrete
ArchiCADProperties - Geometry Method: Single-plane; Pitch: -17.48 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: Cu5; Hotlink and Element ID: Cu5; Layer: 00_CUBIERTA; Building Material / Composite / Profile / Fill: Concrete; Building Material: Concrete; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Roof; Structure Type: Basic; Parent ID: Cu5; Building Materials (All): Concrete; Surfaces (All): Concrete - Architecture; Cover Fill: Roof Tile 01; Edge Surface: Concrete - Architecture; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 107.AMB.NomTipus: Cu5_CobertaInclinadaR60; 109.AMB.CodiTipus: Cu5; 111.AMB.DescripcioTipus: Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: CobertaInclinadaR60
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Concrete, Embodied Carbon: 76.1413 (kgCO₂); Concrete, Embodied Energy: 526.584 MJ
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Surface Area of the Roof Bottom (Gross): 13.1778 m2; Surface Area of the Roof Edges (Gross): 0.838128 m2; Surface Area of the Roof Top (Gross): 13.1778 m2; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Surface Area of the Roof Bottom (Net): 13.1778 m2; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.03 m; Vertical Thickness: 0.0314524 m; Height: 0.03 m; Elevation to Project Zero: 7.73943 m; Elevation to 1st Reference Level: 7.73943 m; Elevation to 2nd Reference Level: 7.73943 m; Elevation to Sea Level: 17.0794 m; Elevation to Linked/Home Story: 7.73943 m; Home Offset: 7.73943 m; Top Elevation To First Reference Level: 7.77089 m; Top Elevation To Home Story: 7.77089 m; Top Elevation To Project Zero: 7.77089 m; Top Elevation To Sea Level: 17.1109 m; Top Elevation To Second Reference Level: 7.77089 m; Bottom Elevation To First Reference Level: 7.41768 m; Bottom Elevation To Home Story: 7.41768 m; Bottom Elevation To Project Zero: 7.41768 m; Bottom Elevation To Sea Level: 16.7577 m; Bottom Elevation To Second Reference Level: 7.41768 m
5 AMB.Geometria - 503.AMB.Altura: 0.03 m; 504.AMB.Gruix: 0.03 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete, Mass: 711.601 kg; Concrete, Projected Component Area (Net): 13.294 m2; Concrete, Projected Component Area (Gross): 13.294 m2; Concrete, Component Thickness: 0.03 m; Concrete, Component Volume (Net): 0.395334 m3; Concrete, Component Volume (Gross): 0.395334 m3

# IfcBuildingElementProxy: Concrete 30-16 300 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Stone - Wall; Outside Face Surface: Stone - Wall; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: SW - 052; Hotlink and Element ID: SW - 052; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: Concrete 30-16; Composite Structure: Concrete 30-16; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Composite; Parent ID: SW - 052; Building Materials (All): Stone - Structural; Surfaces (All): Stone - Wall; Slant Angle: 90 deg; ID of Connected Openings: OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; Number of Openings: 14; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SW - 052_; 109.AMB.CodiTipus: SW - 052; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Stone - Structural, Component Type: Finish
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 1.62866 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 1.62866 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 1.62866 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0.3 m; Wall Component Thickness on the Outside Face: 0.3 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 4.81888 m2; Analytic Surface Area of Openings on the Outside Face: 4.81888 m2; Analytic Volume of the Openings: 1.44567 m3; End Thickness of the Wall: 0.3 m; Surface Area of Empty Openings in the Wall: 0 m2; Height: 1.62866 m; Width: 0.3 m; Elevation to Project Zero: 4.53993 m; Elevation to 1st Reference Level: 4.53993 m; Elevation to 2nd Reference Level: 4.53993 m; Elevation to Sea Level: 13.8799 m; Elevation to Linked/Home Story: 4.53993 m; Home Offset: 4.53993 m; Top Offset: 0 m; Thickness: 0.3 m; Insulation Skin Thickness: 0 m; Top Elevation To First Reference Level: 6.16859 m; Top Elevation To Home Story: 6.16859 m; Top Elevation To Project Zero: 6.16859 m; Top Elevation To Sea Level: 15.5086 m; Top Elevation To Second Reference Level: 6.16859 m; Bottom Elevation To First Reference Level: 4.53993 m; Bottom Elevation To Home Story: 4.53993 m; Bottom Elevation To Project Zero: 4.53993 m; Bottom Elevation To Sea Level: 13.8799 m; Bottom Elevation To Second Reference Level: 4.53993 m
5 AMB.Geometria - 502.AMB.Amplada: 0.3 m; 503.AMB.Altura: 1.62866 m; 504.AMB.Gruix: 0.3 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Component Thickness: 0.3 m; Stone - Structural, Rectangular Component Height: 1.62866 m; Stone - Structural, Rectangular Component Width: 0.3 m; Stone - Structural, Component Cross Section Area: 0.488598 m2
Name | Stone - Structural, Embodied Carbon | Stone - Structural, Embodied Energy (MJ) | Wall Component Volume on the Inside Face (Net) (m3) = Wall Component Volume on the Outside Face (Net) (m3) = Volume (Net) (m3) = Stone - Structural, Component Volume (Net) (m3) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) = Length of the Wall on the Inside Face (m) | Surface Area of the Wall Inside Face (Conditional) (m2) = Surface Area of the Wall Inside Face (Gross) (m2) | Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) | Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area of the Wall Outside Face (Gross) (m2) | Volume of the Wall Inside Face Component (Conditional) (m3) = Volume of the Wall Outside Face Component (Conditional) (m3) = Volume (Conditional) (m3) = Volume (Gross) (m3) = Stone - Structural, Component Volume (Gross) (m3) | Area (m2) = Top Surface Area (Net) (m2) | 3D Length (m) | Floor Plan Perimeter (m) | Edge Surface Area (Net) (m2) | Stone - Structural, Mass (kg) | Stone - Structural, Projected Component Area (Net) (m2) | Stone - Structural, Projected Component Area (Gross) (m2)
SW - 052 | 2024.4 (kgCO₂) | 33740 | 10.2242 | 22.7901 | 34.0809 | 34.0806 | 23.9111 | 22.7908 | 38.8998 | 22.7894 | 38.8995 | 11.6699 | 7.17353 | 23.928 | 46.1811 | 14.3445 | 22493.3 | 34.1062 | 38.9251
SW - 052 | 1915.53 (kgCO₂) | 31925.5 | 9.67438 | 21.7171 | 32.2447 | 32.2512 | 22.8415 | 21.7151 | 37.0636 | 21.719 | 37.0701 | 11.1201 | 6.85187 | 22.8595 | 44.0354 | 13.5834 | 21283.6 | 32.2804 | 37.0993

# IfcBuildingElementProxy: Concrete 320, F6
In: planta baixa
Classification: 30.10.10.10 Façanes in situ (GuBIMclass CA); Material: Concrete
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Concrete - Architecture; Outside Face Surface: Concrete - Architecture; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F6; Hotlink and Element ID: F6; Layer: 00_ACERO VIGAS; Building Material / Composite / Profile / Fill: Concrete; Building Material: Concrete; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F6; Building Materials (All): Concrete; Surfaces (All): Concrete - Architecture; Concrete - Bush hammered; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Concrete - Architecture; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
Pset_BuildingElementProxyCommon - Status: NEW
5 AMB.Geometria - 501.AMB.Longitud: 7.9469 m; 502.AMB.Amplada: 0.32 m; 503.AMB.Altura: 0.226022 m; 504.AMB.Gruix: 0.32 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete, Mass: 1033.39 kg; Concrete, Projected Component Area (Net): 1.79617 m2; Concrete, Projected Component Area (Gross): 1.79617 m2; Concrete, Component Thickness: 0.32 m; Concrete, Rectangular Component Height: 0.226022 m; Concrete, Rectangular Component Width: 0.32 m; Concrete, Component Cross Section Area: 0.072327 m2; Concrete, Component Volume (Net): 0.574106 m3; Concrete, Component Volume (Gross): 0.574106 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.10 Façanes in situ; 104.AMB.ClassificacioCodi: 30.10.10.10; 105.AMB.ClassificacioDescripcio: Façanes in situ; 107.AMB.NomTipus: F6_Mur_350_Mao; 109.AMB.CodiTipus: F6; 111.AMB.DescripcioTipus: Mur de fàbrica de maó massís manual armat amb morter de calç 3,5 HL; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 0.226022 m; Minimum Height of the Wall: 0.191199 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Average length of the Wall: 7.9469 m; Surface Area of the Wall Inside Face (Net): 1.79617 m2; Surface Area of the Wall Outside Face (Net): 1.78841 m2; Analytic Volume of the Openings: 0 m3; Length of Reference Line: 7.9469 m; Length of the Wall Inside Face (Conditional): 7.9469 m; Surface Area of the Wall Inside Face (Conditional): 1.79617 m2; Length of the Wall Outside Face (Conditional): 7.9469 m; Surface Area of the Wall Outside Face (Conditional): 1.78841 m2; Surface Area of the Wall Inside Face (Gross): 1.79617 m2; Surface Area of the Wall Outside Face (Gross): 1.79617 m2; End Thickness of the Wall: 0.32 m; Length of the Wall at the Center: 7.9469 m; Length of the Wall on the Inside Face: 7.9469 m; Length of the Wall on the Outside Face: 7.9469 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 2.54301 m2; Height: 0.226022 m; Volume (Net): 0.574106 m3; Width: 0.32 m; Elevation to Project Zero: 9.78536 m; Elevation to 1st Reference Level: 9.78536 m; Elevation to 2nd Reference Level: 9.78536 m; Elevation to Sea Level: 19.1254 m; Elevation to Linked/Home Story: 9.78536 m; Home Offset: 9.78536 m; Top Offset: 0 m; Surface Area: 1.78841 m2; 3D Length: 7.9469 m; Thickness: 0.32 m; Volume (Conditional): 0.574106 m3; Volume (Gross): 0.574776 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 16.5338 m; Top Elevation To First Reference Level: 10.0114 m; Top Elevation To Home Story: 10.0114 m; Top Elevation To Project Zero: 10.0114 m; Top Elevation To Sea Level: 19.3514 m; Top Elevation To Second Reference Level: 10.0114 m; Bottom Elevation To First Reference Level: 9.78536 m; Bottom Elevation To Home Story: 9.78536 m; Bottom Elevation To Project Zero: 9.78536 m; Bottom Elevation To Sea Level: 19.1254 m; Bottom Elevation To Second Reference Level: 9.78536 m; Top Surface Area (Net): 2.54301 m2; Edge Surface Area (Net): 5.20601 m2; Bottom Surface Area (Net): 1.78841 m2
Component Properties - Concrete, Embodied Carbon: 110.573 (kgCO₂); Concrete, Embodied Energy: 764.71 MJ
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Mur_350_Mao

# IfcBuildingElementProxy: Concrete 350, F6
In: planta coberta
Classification: 30.10.10.10 Façanes in situ (GuBIMclass CA); Material: Concrete
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Concrete - Architecture; Outside Face Surface: Concrete - Architecture; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F6; Hotlink and Element ID: F6; Layer: 00_ACERO VIGAS; Building Material / Composite / Profile / Fill: Concrete; Building Material: Concrete; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F6; Building Materials (All): Concrete; Surfaces (All): Concrete - Architecture; Concrete - Bush hammered; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Concrete - Architecture; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.10 Façanes in situ; 104.AMB.ClassificacioCodi: 30.10.10.10; 105.AMB.ClassificacioDescripcio: Façanes in situ; 107.AMB.NomTipus: F6_Mur_350_Mao; 109.AMB.CodiTipus: F6; 111.AMB.DescripcioTipus: Mur de fàbrica de maó massís manual armat amb morter de calç 3,5 HL; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Mur_350_Mao
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Concrete, Embodied Carbon: 282.663 (kgCO₂); Concrete, Embodied Energy: 1954.87 MJ
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 0.396852 m; Minimum Height of the Wall: 0.24799 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Average length of the Wall: 12.2781 m; Surface Area of the Wall Inside Face (Net): 4.86308 m2; Surface Area of the Wall Outside Face (Net): 3.51931 m2; Analytic Volume of the Openings: 0 m3; Length of Reference Line: 12.2781 m; Length of the Wall Inside Face (Conditional): 12.2781 m; Surface Area of the Wall Inside Face (Conditional): 4.86308 m2; Length of the Wall Outside Face (Conditional): 12.2781 m; Surface Area of the Wall Outside Face (Conditional): 3.51931 m2; Surface Area of the Wall Inside Face (Gross): 4.8726 m2; Surface Area of the Wall Outside Face (Gross): 3.51931 m2; End Thickness of the Wall: 0.35 m; Length of the Wall at the Center: 12.2781 m; Length of the Wall on the Inside Face: 12.2781 m; Length of the Wall on the Outside Face: 12.2781 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 4.29734 m2; Height: 0.459677 m; Volume (Net): 1.46762 m3; Width: 0.35 m; Elevation to Project Zero: 7.14105 m; Elevation to 1st Reference Level: 7.14105 m; Elevation to 2nd Reference Level: 7.14105 m; Elevation to Sea Level: 16.481 m; Elevation to Linked/Home Story: 2.64105 m; Home Offset: 2.64105 m; Top Offset: 0 m; Surface Area: 3.51931 m2; 3D Length: 12.2781 m; Thickness: 0.35 m; Volume (Conditional): 1.46762 m3; Volume (Gross): 1.46858 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 25.2562 m; Top Elevation To First Reference Level: 7.5379 m; Top Elevation To Home Story: 3.0379 m; Top Elevation To Project Zero: 7.5379 m; Top Elevation To Sea Level: 16.8779 m; Top Elevation To Second Reference Level: 7.5379 m; Bottom Elevation To First Reference Level: 7.14105 m; Bottom Elevation To Home Story: 2.64105 m; Bottom Elevation To Project Zero: 7.14105 m; Bottom Elevation To Sea Level: 16.481 m; Bottom Elevation To Second Reference Level: 7.14105 m; Top Surface Area (Net): 4.29734 m2; Edge Surface Area (Net): 9.03932 m2; Bottom Surface Area (Net): 3.51931 m2
5 AMB.Geometria - 501.AMB.Longitud: 12.2781 m; 502.AMB.Amplada: 0.35 m; 503.AMB.Altura: 0.459677 m; 504.AMB.Gruix: 0.35 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete, Mass: 2641.71 kg; Concrete, Projected Component Area (Net): 4.87184 m2; Concrete, Projected Component Area (Gross): 4.87184 m2; Concrete, Component Thickness: 0.35 m; Concrete, Rectangular Component Height: 0.459677 m; Concrete, Rectangular Component Width: 0.35 m; Concrete, Component Cross Section Area: 0.160887 m2; Concrete, Component Volume (Net): 1.46762 m3; Concrete, Component Volume (Gross): 1.46762 m3

# IfcBuildingElementProxy: Concrete 40-00 400 (21)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Stone - Wall; Outside Face Surface: Stone - Wall; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: Concrete 40-00; Composite Structure: Concrete 40-00; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Composite; Building Materials (All): Stone - Structural; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0.4 m; Wall Component Thickness on the Outside Face: 0.4 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; End Thickness of the Wall: 0.4 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.4 m; Elevation to Project Zero: -0.958082 m; Elevation to 1st Reference Level: -0.958082 m; Elevation to 2nd Reference Level: -0.958082 m; Elevation to Sea Level: 8.38192 m; Elevation to Linked/Home Story: -0.958082 m; Home Offset: -0.958082 m; Top Offset: 0 m; Thickness: 0.4 m; Insulation Skin Thickness: 0 m; Bottom Elevation To First Reference Level: -0.958082 m; Bottom Elevation To Home Story: -0.958082 m; Bottom Elevation To Project Zero: -0.958082 m; Bottom Elevation To Sea Level: 8.38192 m; Bottom Elevation To Second Reference Level: -0.958082 m
5 AMB.Geometria - 502.AMB.Amplada: 0.4 m; 504.AMB.Gruix: 0.4 m; 506.AMB.Profunditat: 0 m
Component Properties - Stone - Structural, Component Type: Finish
Component Quantities - Stone - Structural, Component Thickness: 0.4 m; Stone - Structural, Rectangular Component Width: 0.4 m
Name | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Colliding Zones | Surfaces (All) | ID of Connected Openings | Number of Openings | 107.AMB.NomTipus | Maximum Height of the Wall Skin on the Inside Face (m) = Maximum Height of the Wall (m) = Maximum Height of the Wall Skin on the Outside Face (m) = Height (m) = 503.AMB.Altura (m) = Stone - Structural, Rectangular Component Height (m) | Minimum Height of the Wall Skin on the Inside Face (m) = Minimum Height of the Wall (m) = Minimum Height of the Wall Skin on the Outside Face (m) | Wall Component Volume on the Inside Face (Net) (m3) = Wall Component Volume on the Outside Face (Net) (m3) = Volume (Net) (m3) = Stone - Structural, Component Volume (Net) (m3) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) = Length of the Wall on the Inside Face (m) | Surface Area of the Wall Inside Face (Conditional) (m2) | Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) | Surface Area of the Wall Outside Face (Conditional) (m2) | Volume of the Wall Inside Face Component (Conditional) (m3) = Volume of the Wall Outside Face Component (Conditional) (m3) = Volume (Conditional) (m3) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Stone - Structural, Embodied Carbon | Stone - Structural, Embodied Energy (MJ) | Stone - Structural, Mass (kg) | Stone - Structural, Projected Component Area (Net) (m2) | Stone - Structural, Projected Component Area (Gross) (m2) | Stone - Structural, Component Cross Section Area (m2) | Stone - Structural, Component Volume (Gross) (m3)
F1 | F1 | Nau Santa Eulàlia | Concrete - Bush hammered; Stone - Wall | OP - 003; OP - 003; OP - 003; OP - 003; OP - 003 | 5 | F1_ | 5.267 | 1.22808 | 41.8868 | 8.46497 | 8.46497 | 21.494 | 104.529 | 104.744 | 3.38599 | 21.494 | 21.494 | 106.736 | 21.494 | 106.951 | 42.7696 | 113.209 | 113.209 | 8.5976 | 21.494 | 45.2836 | 43.788 | 4.30892 | 13.6489 | 21.4088 | 8293.59 (kgCO₂) | 138227 | 92151 | 104.744 | 113.209 | 2.1068 | 45.2836
F1 | F1 | Nau Santa Eulàlia | Concrete - Bush hammered; Stone - Wall | OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003 | 14 | F1_ | 5.49801 | 0 | 47.5085 | 12.6202 | 12.6202 | 23.511 | 118.251 | 118.84 | 5.04808 | 23.9106 | 23.1113 | 130.871 | 23.9106 | 131.461 | 52.5565 | 131.471 | 131.461 | 9.56462 | 23.9332 | 52.5863 | 48.1532 | 4.53993 | 13.8799 | 19.1292 | 9406.68 (kgCO₂) | 156778 | 104519 | 118.965 | 131.585 | 2.1992 | 52.5863
F1 | F1 | Nau Santa Eulàlia | Stone - Wall |  | 0 | F1_ | 6.21511 | 0 | 3.45817 | -7.63833e-14 | 0 | 1.07347 | 8.82696 | 9.4701 | 1.97464e-08 | 1.622 | 1.22129 | 8.82696 | 0.92566 | 9.4701 | 3.45817 | 11.9183 | 10.0809 | 0.568097 | 1.622 | 4.39984 | 3.04433 | 5.25703 | 14.597 | 3.56311 | 684.718 (kgCO₂) | 11412 | 7607.98 | 9.83315 | 9.83315 | 2.48604 | 3.45817
SW - 052 | SW - 052 | Nau Santa Eulàlia | Stone - Wall |  | 0 | SW - 052_ | 6.21492 | 6.21492 | 3.99495 | 0 | 0 | 1.607 | 9.98737 | 9.98737 | 0 | 1.607 | 1.607 | 9.98737 | 1.607 | 9.98737 | 3.99495 | 9.98737 | 9.98737 | 0.6428 | 1.607 | 3.99495 | 4.014 | 5.25683 | 14.5968 | 6.25753 | 791 (kgCO₂) | 13183.3 | 8788.89 | 9.98737 | 9.98737 | 2.48597 | 3.99495
F1 | F1 | Nau Santa Eulàlia | Concrete - Bush hammered; Stone - Wall |  | 0 | F1_ | 6.79999 | 0 | 4.08104 | 0 | 0 | 1.70486 | 9.91559 | 10.3287 | 0 | 1.92 | 1.48972 | 9.91559 | 1.92 | 10.3287 | 4.08104 | 12.3351 | 12.5338 | 0.601731 | 1.51893 | 4.97379 | 4.39721 | 5.84191 | 15.1819 | 3.92346 | 808.046 (kgCO₂) | 13467.4 | 8978.29 | 10.3287 | 10.3287 | 2.72 | 4.09177
F1 | F1 | Nau Santa Eulàlia | Stone - Wall |  | 0 | F1_ | 7.12667 | 0 | 5.07229 | 0 | 0 | 1.97969 | 12.7661 | 12.5954 | 0 | 2.16808 | 1.79131 | 12.7661 | 2.16808 | 12.5954 | 5.07229 | 14.9692 | 14.7985 | 0.711734 | 1.79131 | 5.95355 | 4.90889 | 6.16859 | 15.5086 | 4.27414 | 1004.31 (kgCO₂) | 16738.6 | 11159 | 12.7661 | 12.7661 | 2.85067 | 5.07229
F1 | F1 | Nau Santa Eulàlia | Stone - Wall |  | 0 | F1_ | 7.12667 | 0 | 4.88748 | 0 | 0 | 1.91477 | 12.1449 | 12.2925 | 0 | 2.1254 | 1.70414 | 12.1449 | 2.1254 | 12.2925 | 4.88748 | 14.347 | 14.4947 | 0.685802 | 1.72487 | 5.76834 | 4.81046 | 6.16859 | 15.5086 | 4.22227 | 967.721 (kgCO₂) | 16128.7 | 10752.5 | 12.2925 | 12.2925 | 2.85067 | 4.88748
F1 | F1 | Nau Santa Eulàlia | Stone - Wall | OP - 003 | 1 | F1_ | 6.21511 | 0 | 3.4498 | 1.58789 | 1.58789 | 1.56703 | 9.09767 | 8.15136 | 0.635154 | 1.56703 | 1.56703 | 10.6856 | 1.56703 | 9.73924 | 4.08496 | 10.6856 | 9.73924 | 0.780923 | 2.33759 | 4.08496 | 3.93405 | 5.25703 | 14.597 | 1.40773 | 683.061 (kgCO₂) | 11384.4 | 7589.57 | 9.09767 | 10.6856 | 2.48604 | 4.08496
SW - 052 | SW - 052 | Nau Santa Eulàlia | Brick - Aged Natural; Stone - Wall | OP - 003 | 1 | SW - 052_ | 6.64355 | 1.03692 | 2.66252 | 4.88356 | 4.88356 | 1.737 | 6.65629 | 6.65629 | 1.95342 | 1.737 | 1.737 | 6.65629 | 1.737 | 6.65629 | 4.61594 | 11.5399 | 11.5399 | 0.6948 | 1.737 | 4.61594 | 4.274 | 5.68547 | 15.0255 | 6.70444 | 527.178 (kgCO₂) | 8786.31 | 5857.54 | 6.65629 | 11.5399 | 2.65742 | 4.61594
F1 | F1 | Nau Santa Eulàlia | Stone - Wall | OP - 003 | 1 | F1_ | 6.10808 | 2.59755 | 3.21056 | 1.58789 | 1.58789 | 1.57403 | 8.02639 | 8.02639 | 0.635154 | 1.57403 | 1.57403 | 9.61428 | 1.57403 | 9.61428 | 3.84571 | 9.61428 | 9.61428 | 0.62961 | 1.57403 | 3.84571 | 3.94805 | 5.15 | 14.49 | 6.14569 | 635.69 (kgCO₂) | 10594.8 | 7063.23 | 8.02639 | 9.61428 | 2.44323 | 3.84571
Tr3 | Tr3 | Nau Santa Eulàlia | Stone - Wall |  | 0 | Tr3_ | 6.10808 | 6.10808 | 3.97025 | 0 | 0 | 1.625 | 9.92563 | 9.92563 | 0 | 1.625 | 1.625 | 9.92563 | 1.625 | 9.92563 | 3.97025 | 9.92563 | 9.92563 | 0.65 | 1.625 | 3.97025 | 4.05 | 5.15 | 14.49 | 6.18647 | 786.11 (kgCO₂) | 13101.8 | 8734.56 | 9.92563 | 9.92563 | 2.44323 | 3.97025
SW - 052 | SW - 052 | Nau Santa Eulàlia | Brick - Aged Natural; Stone - Wall | OP - 003 | 1 | SW - 052_ | 6.52499 | 1.02808 | 2.65713 | 4.69109 | 4.69109 | 1.737 | 6.64281 | 6.64281 | 1.87644 | 1.737 | 1.737 | 6.64281 | 1.737 | 6.64281 | 4.53356 | 11.3339 | 11.3339 | 0.6948 | 1.737 | 4.53356 | 4.274 | 5.56691 | 14.9069 | 6.60959 | 526.111 (kgCO₂) | 8768.52 | 5845.68 | 6.64281 | 11.3339 | 2.61 | 4.53356
F1 | F1 | Nau Santa Eulàlia | Stone - Wall | OP - 003 | 1 | F1_ | 6.64355 | 1.05694 | 2.6922 | 4.43208 | 4.432 | 1.74455 | 6.73049 | 6.73046 | 1.77281 | 1.74455 | 1.74455 | 6.73049 | 1.74455 | 6.73046 | 4.46501 | 11.59 | 11.59 | 0.69782 | 1.74455 | 4.63601 | 4.2891 | 5.68547 | 15.0255 | 5.35545 | 533.055 (kgCO₂) | 8884.25 | 5922.83 | 6.73049 | 11.1626 | 2.65742 | 4.46501
F1 | F1 | Nau Santa Eulàlia | Stone - Wall |  | 0 | F1_ | 6.09656 | 6.09656 | 4.2237 | 0 | 0 | 1.732 | 10.5592 | 10.5592 | 0 | 1.732 | 1.732 | 10.5592 | 1.732 | 10.5592 | 4.2237 | 10.5592 | 10.5592 | 0.6928 | 1.732 | 4.2237 | 4.264 | 5.13848 | 14.4785 | 6.26285 | 836.292 (kgCO₂) | 13938.2 | 9292.13 | 10.5592 | 10.5592 | 2.43862 | 4.2237
SW - 052 | SW - 052 | Nau Santa Eulàlia | Concrete - Bush hammered; Stone - Wall |  | 0 | SW - 052_ | 6.9 | 0 | 4.21391 | 0 | 0 | 1.73098 | 10.4251 | 10.4836 | 0 | 1.92 | 1.54197 | 10.4251 | 1.92 | 10.4836 | 4.21391 | 12.8423 | 12.6863 | 0.612266 | 1.54197 | 5.10572 | 4.41234 | 5.94192 | 15.2819 | 3.98453 | 834.355 (kgCO₂) | 13905.9 | 9270.61 | 10.6396 | 10.6396 | 2.76 | 4.22464
F6 | F6 | Nau Santa Eulàlia | Stone - Wall | OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003 | 8 | F6_ | 5.26705 | 3.20155 | 7.06623 | 0.261 | 0.261 | 3.40353 | 17.6656 | 17.6656 | 0.1044 | 3.40353 | 3.40353 | 17.9266 | 3.40353 | 17.9266 | 7.17063 | 17.9266 | 17.9266 | 1.36141 | 3.40353 | 7.17063 | 7.60707 | 4.30897 | 13.649 | 6.93646 | 1399.11 (kgCO₂) | 23318.6 | 15545.7 | 17.6656 | 17.9266 | 2.10682 | 7.17063
SW - 052 | SW - 052 | Espai públic; Nau Santa Eulàlia | Stone - Wall | OP - 003 | 1 | SW - 052_ | 6.21492 | 2.59755 | 3.33027 | 1.58789 | 1.58789 | 1.59513 | 8.32569 | 8.32569 | 0.635154 | 1.59513 | 1.59513 | 9.91357 | 1.59513 | 9.91357 | 3.96543 | 9.91357 | 9.91357 | 0.63805 | 1.59513 | 3.96543 | 3.99025 | 5.25683 | 14.5968 | 6.24803 | 659.394 (kgCO₂) | 10989.9 | 7326.6 | 8.32569 | 9.91357 | 2.48597 | 3.96543
SW - 052 | SW - 052 | Espai públic; Nau Santa Eulàlia | Stone - Wall | OP - 003 | 1 | SW - 052_ | 6.09656 | 2.59755 | 3.18742 | 1.58789 | 1.58789 | 1.56751 | 7.96854 | 7.96854 | 0.635154 | 1.56751 | 1.56751 | 9.55643 | 1.56751 | 9.55643 | 3.82257 | 9.55643 | 9.55643 | 0.627005 | 1.56751 | 3.82257 | 3.93502 | 5.13848 | 14.4785 | 6.13126 | 631.109 (kgCO₂) | 10518.5 | 7012.32 | 7.96854 | 9.55643 | 2.43862 | 3.82257
F1 | F1 | Nau Santa Eulàlia | Concrete - Bush hammered; Stone - Wall | OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003 | 14 | F1_ | 5.49801 | 0 | 45.1395 | 12.6202 | 12.6202 | 22.4393 | 112.088 | 112.97 | 5.04807 | 22.8428 | 22.0358 | 124.708 | 22.8428 | 125.59 | 50.1876 | 125.561 | 125.59 | 9.13608 | 22.8668 | 50.2303 | 46.0156 | 4.53993 | 13.8799 | 18.2722 | 8937.63 (kgCO₂) | 148960 | 99307 | 113.102 | 125.722 | 2.1992 | 50.2303
SW - 052 | SW - 052 | Nau Santa Eulàlia | Stone - Wall | OP - 003 | 1 | SW - 052_ | 6.64355 | 0.962367 | 2.63928 | 4.43967 | 4.43982 | 1.74559 | 6.5982 | 6.59819 | 1.7759 | 1.74559 | 1.74559 | 6.5982 | 1.74559 | 6.59819 | 4.41518 | 11.597 | 11.597 | 0.698238 | 1.74559 | 4.63878 | 4.29119 | 5.68547 | 15.0255 | 6.71132 | 522.577 (kgCO₂) | 8709.62 | 5806.41 | 6.5982 | 11.0385 | 2.65742 | 4.41518
F1 | F1 | Nau Santa Eulàlia | Stone - Wall | OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003 | 8 | F1_ | 5.26705 | 0 | 31.9444 | 9.38434 | 9.38434 | 16.762 | 80.1527 | 80.1591 | 3.75374 | 17.1455 | 16.9995 | 83.2791 | 16.5245 | 83.2855 | 33.195 | 92.8075 | 90.306 | 6.79979 | 17.1455 | 36.6227 | 34.5449 | 4.30897 | 13.649 | 15.6114 | 6324.99 (kgCO₂) | 105417 | 70277.7 | 80.7424 | 90.1267 | 2.10682 | 35.6981

# IfcBuildingElementProxy: Concrete 40-20 (2) 160 (24)
In: planta baixa
Classification: 40.10.10.30 Extradossats (GuBIMclass CA); Material: Insulation - Mineral Soft
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Paint - Anthracite; Outside Face Surface: Insulation - Cellulose; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Layer: 00_TABIQUE; Building Material / Composite / Profile / Fill: Concrete 40-20 (2); Composite Structure: Concrete 40-20 (2); Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Composite; Building Materials (All): Insulation - Mineral Soft; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 40.10.10.30 Extradossats; 104.AMB.ClassificacioCodi: 40.10.10.30; 105.AMB.ClassificacioDescripcio: Extradossats; 107.AMB.NomTipus: T6_Extradossat_190; 109.AMB.CodiTipus: T6; 111.AMB.DescripcioTipus: Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40; AUX_107.NomTipus: Extradossat_190
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Insulation - Mineral Soft, Component Type: Core
ArchiCADQuantities - Number of Holes (Number of Empty Openings): 0; Number of Columns: 0; Volume of the Columns: 0 m3; Air Skin Thickness: 0 m; Wall Component Thickness on the Inside Face: 0.16 m; Wall Component Thickness on the Outside Face: 0.16 m; End Thickness of the Wall: 0.16 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.16 m; Elevation to Project Zero: 0.27 m; Elevation to 1st Reference Level: 0.27 m; Elevation to 2nd Reference Level: 0.27 m; Elevation to Sea Level: 9.61 m; Elevation to Linked/Home Story: 0.27 m; Home Offset: 0.27 m; Top Offset: 0 m; Thickness: 0.16 m; Insulation Skin Thickness: 0.16 m; Bottom Elevation To First Reference Level: 0.27 m; Bottom Elevation To Home Story: 0.27 m; Bottom Elevation To Project Zero: 0.27 m; Bottom Elevation To Sea Level: 9.61 m; Bottom Elevation To Second Reference Level: 0.27 m
5 AMB.Geometria - 502.AMB.Amplada: 0.16 m; 504.AMB.Gruix: 0.16 m; 506.AMB.Profunditat: 0 m
Component Quantities - Insulation - Mineral Soft, Component Thickness: 0.16 m; Insulation - Mineral Soft, Rectangular Component Width: 0.16 m
Name | Element ID = Hotlink and Element ID = Parent ID | Surfaces (All) | Number of Openings | Insulation - Mineral Soft, Embodied Carbon | Insulation - Mineral Soft, Embodied Energy (MJ) | Number of Doors | Number of Windows | Maximum Height of the Wall Skin on the Inside Face (m) = Maximum Height of the Wall (m) = Maximum Height of the Wall Skin on the Outside Face (m) | Minimum Height of the Wall Skin on the Inside Face (m) = Minimum Height of the Wall (m) = Minimum Height of the Wall Skin on the Outside Face (m) | Area of the Doors (m2) | Combined Width of Doors (m) | Area of the Windows (m2) | Combined Width of Windows (m) | Wall Component Volume on the Inside Face (Net) (m3) = Wall Component Volume on the Outside Face (Net) (m3) = Volume (Net) (m3) = Insulation - Mineral Soft, Component Volume (Net) (m3) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Surface Area of the Wall Inside Face (Conditional) (m2) | Length of the Wall Outside Face (Conditional) (m) | Surface Area of the Wall Outside Face (Conditional) (m2) | Volume of the Wall Inside Face Component (Conditional) (m3) = Volume of the Wall Outside Face Component (Conditional) (m3) = Volume (Conditional) (m3) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = 503.AMB.Altura (m) = Insulation - Mineral Soft, Rectangular Component Height (m) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Insulation - Mineral Soft, Mass (kg) | Insulation - Mineral Soft, Projected Component Area (Net) (m2) | Insulation - Mineral Soft, Projected Component Area (Gross) (m2) | Insulation - Mineral Soft, Component Cross Section Area (m2) | Insulation - Mineral Soft, Component Volume (Gross) (m3)
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 30.2826 (kgCO₂) | 400.964 | 1 | 0 | 5.38222 | 0 | 4.50372 | 1.39052 | 0 | 0 | 0.700986 | 4.42746 | 4.42746 | 1.74455 | 4.5675 | 4.38262 | 0.708393 | 1.74455 | 1.74455 | 4.5675 | 1.74455 | 4.38262 | 1.40938 | 8.99516 | 8.99959 | 1.74455 | 1.74455 | 0.0575874 | 5.41547 | 1.74455 | 1.43958 | 3.8091 | 5.65222 | 14.9922 | 1.48182 | 28.0394 | 4.57193 | 8.99939 | 0.866476 | 1.40938
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 31.5596 (kgCO₂) | 417.873 | 0 | 1 | 4.62218 | 0 | 0 | 0 | 1.58789 | 0.929675 | 0.730547 | 1.58789 | 1.58789 | 1.56703 | 5.08752 | 3.90945 | 0.254062 | 1.56703 | 1.56703 | 6.67541 | 1.56703 | 5.49733 | 0.984609 | 7.06199 | 7.01269 | 1.56703 | 1.56703 | 0.227902 | 4.98703 | 1.48351 | 1.12597 | 3.45405 | 4.89218 | 14.2322 | 0.655413 | 29.2219 | 5.08752 | 6.67541 | 0.797925 | 0.984609
F6 | F6 | Paint - Anthracite; Insulation - Cellulose | 0 | 37.8291 (kgCO₂) | 500.885 | 0 | 1 | 4.67393 | 4.0413 | 0 | 0 | 1.58789 | 0.929675 | 0.875673 | 1.58789 | 1.58789 | 1.57403 | 5.51686 | 5.42969 | 0.254062 | 1.57403 | 1.57403 | 7.10475 | 1.57403 | 7.01757 | 1.12973 | 7.11794 | 7.07526 | 1.57403 | 1.57403 | 0.251844 | 4.88 | 1.57403 | 1.13546 | 3.46805 | 4.94393 | 14.2839 | 1.88593 | 35.0269 | 5.51686 | 7.10475 | 0.7808 | 1.12973
F6 | F6 | Paint - Anthracite; Insulation - Cellulose | 0 | 93.0056 (kgCO₂) | 1231.46 | 0 | 0 | 4.4191 | 0 | 0 | 0 | 0 | 0 | 2.15291 | 0 | 0 | 3.05945 | 13.8296 | 13.0837 | 0 | 3.38286 | 3.12995 | 13.8296 | 2.98894 | 13.0837 | 2.15291 | 17.1284 | 16.3517 | 3.12995 | 2.98894 | 0.489512 | 4.49332 | 3.12995 | 2.67825 | 6.49217 | 4.6891 | 14.0291 | 1.69847 | 86.1163 | 13.8296 | 13.8296 | 0.718931 | 2.15291
F1 | F1 | Paint - Anthracite; Metal - Stainless Steel; Insulation - Cellulose | 0 | 34.0494 (kgCO₂) | 450.839 | 1 | 0 | 5.45087 | 4.90434 | 4.7376 | 1.41 | 0 | 0 | 0.78818 | 4.94986 | 4.7376 | 2.12257 | 6.04324 | 6.24896 | 0.970192 | 2.12257 | 0.712571 | 6.04324 | 0.712571 | 6.24896 | 1.75837 | 10.9931 | 10.9866 | 2.12257 | 2.12257 | 0.059856 | 5.45087 | 2.12257 | 1.75837 | 4.56514 | 5.72087 | 15.0609 | 1.53116 | 31.5272 | 6.2555 | 10.9931 | 0.872139 | 1.75837
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 316.009 (kgCO₂) | 4184.19 | 1 | 2 | 4.43851 | 4.44089e-16 | 6.24 | 2.4 | 1.10428 | 0.844371 | 7.31501 | 7.34428 | 7.34428 | 12.1798 | 46.373 | 45.3782 | 1.17508 | 12.3393 | 9.75327 | 47.4773 | 9.80641 | 46.4825 | 8.4901 | 58.086 | 56.606 | 12.1533 | 12.2064 | 1.54586 | 4.48787 | 12.1533 | 9.17513 | 24.6883 | 4.70851 | 14.0485 | 4.2449 | 292.601 | 46.3731 | 53.9318 | 0.71806 | 8.52442
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 54.3321 (kgCO₂) | 719.397 | 0 | 0 | 5.78822 | 4.44089e-16 | 0 | 0 | 0 | 0 | 1.25769 | -0.00000116845 | -0.00000117686 | 1.48388 | 7.82815 | 7.89294 | -1.99921e-07 | 1.92 | 1.47803 | 7.82815 | 1.48972 | 7.89294 | 1.25769 | 10.0488 | 10.1123 | 1.47803 | 1.48972 | 0.23742 | 5.89859 | 1.48972 | 1.61289 | 3.28818 | 6.05822 | 15.3982 | 1.26186 | 50.3075 | 7.89579 | 8.11029 | 0.943774 | 1.29201
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 30.6062 (kgCO₂) | 405.248 | 1 | 0 | 5.40722 | 0 | 4.50372 | 1.39052 | 0 | 0 | 0.708476 | 4.42874 | 4.42874 | 1.74559 | 4.42982 | 4.42613 | 0.708599 | 1.74559 | 1.74559 | 4.42982 | 1.74559 | 4.42613 | 1.41708 | 9.04815 | 9.04444 | 1.74559 | 1.74559 | 0.0569875 | 5.41547 | 1.74559 | 1.44741 | 3.81119 | 5.67722 | 15.0172 | 2.00349 | 28.339 | 4.42991 | 8.85866 | 0.866476 | 1.41708
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 38.7171 (kgCO₂) | 512.643 | 0 | 1 | 4.65514 | 4.0413 | 0 | 0 | 1.58789 | 0.929675 | 0.896229 | 1.58789 | 1.58789 | 1.59513 | 5.64206 | 5.54362 | 0.254062 | 1.59513 | 1.59513 | 7.22995 | 1.59513 | 7.1315 | 1.15029 | 7.22995 | 7.17746 | 1.59513 | 1.59513 | 0.25522 | 4.98683 | 1.59513 | 1.15259 | 3.51025 | 4.92514 | 14.2651 | 1.92273 | 35.8491 | 5.64206 | 7.22995 | 0.797893 | 1.15029
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 38.013 (kgCO₂) | 503.32 | 0 | 1 | 4.86848 | 4.0413 | 0 | 0 | 1.58789 | 0.929675 | 0.87993 | 1.58789 | 1.58789 | 1.56751 | 5.53069 | 5.46495 | 0.254062 | 1.56751 | 1.56751 | 7.11858 | 1.56751 | 7.05283 | 1.13399 | 7.11858 | 7.10559 | 1.56751 | 1.56751 | 0.250802 | 4.86848 | 1.56751 | 1.13779 | 3.45502 | 5.13848 | 14.4785 | 1.97833 | 35.1972 | 5.55949 | 7.14737 | 0.778957 | 1.13399
F1 | F1 | Paint - Anthracite; Metal - Stainless Steel; Insulation - Cellulose | 0 | 25.2608 (kgCO₂) | 334.472 | 1 | 0 | 5.44445 | 4.99918 | 4.7376 | 1.41 | 0 | 0 | 0.584741 | 4.9113 | 4.7376 | 1.737 | 4.159 | 4.33671 | 0.866828 | 1.737 | 0.327 | 4.159 | 0.327 | 4.33671 | 1.45157 | 9.0703 | 9.07431 | 1.737 | 1.737 | 0.027468 | 5.44445 | 1.737 | 1.45157 | 3.794 | 5.71445 | 15.0545 | 1.44939 | 23.3896 | 4.33671 | 9.07431 | 0.871113 | 1.45157
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 42.3662 (kgCO₂) | 560.96 | 0 | 0 | 4.95963 | 0 | 0 | 0 | 0 | 0 | 0.980699 | 0 | 0 | 1.27841 | 6.43848 | 5.81959 | 0 | 1.60757 | 1.34494 | 6.43848 | 1.21188 | 5.81959 | 0.980699 | 9.73163 | 9.13604 | 1.34494 | 1.21188 | 0.204545 | 4.98683 | 1.34494 | 1.50947 | 2.92491 | 5.22963 | 14.5696 | 1.2091 | 39.2279 | 6.43848 | 6.43848 | 0.797893 | 0.980699
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 46.6958 (kgCO₂) | 618.287 | 0 | 0 | 5.0015 | 0 | 0 | 0 | 0 | 0 | 1.08092 | 0 | 0 | 1.40145 | 7.05631 | 6.45439 | 0 | 1.73268 | 1.46664 | 7.05631 | 1.33625 | 6.45439 | 1.08092 | 10.3293 | 9.7532 | 1.46664 | 1.33625 | 0.224232 | 5.0015 | 1.46664 | 1.60667 | 3.1693 | 5.2715 | 14.6115 | 1.25579 | 43.2369 | 7.05956 | 7.05956 | 0.80024 | 1.08092
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 57.0616 (kgCO₂) | 755.537 | 0 | 0 | 5.78041 | 4.44089e-16 | 0 | 0 | 0 | 0 | 1.32087 | -1.8985e-07 | -1.8985e-07 | 1.54649 | 8.28036 | 8.23051 | -2.89057e-08 | 1.92 | 1.55101 | 8.28036 | 1.54197 | 8.23051 | 1.32087 | 10.456 | 10.4068 | 1.55101 | 1.54197 | 0.247439 | 5.78041 | 1.55101 | 1.66903 | 3.41324 | 6.05041 | 15.3904 | 1.3042 | 52.8348 | 8.28278 | 8.49728 | 0.924866 | 1.35519
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 64.3672 (kgCO₂) | 852.27 | 0 | 0 | 5.80098 | 0 | 0 | 0 | 0 | 0 | 1.48998 | -9.50522e-08 | -9.50522e-08 | 1.7 | 9.28998 | 9.33479 | -1.52083e-08 | 2.1254 | 1.69585 | 9.28998 | 1.70414 | 9.33479 | 1.48998 | 11.2488 | 11.2936 | 1.69585 | 1.70414 | 0.272 | 5.89859 | 1.70414 | 1.8034 | 3.72021 | 6.07098 | 15.411 | 1.39134 | 59.5993 | 9.33806 | 9.33806 | 0.943774 | 1.48998
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 13 | 832.407 (kgCO₂) | 11021.7 | 0 | 14 | 5.84206 | 0 | 0 | 0 | 12.1628 | 7.11586 | 19.2687 | 12.1628 | 12.1628 | 23.1117 | 119.949 | 120.91 | 1.94606 | 23.9106 | 23.1121 | 132.112 | 23.1113 | 133.073 | 21.2147 | 138.676 | 139.653 | 23.1121 | 23.1113 | 3.75763 | 5.93498 | 23.4893 | 22.2663 | 46.5438 | 6.11206 | 15.4521 | 7.52611 | 770.747 | 120.962 | 133.725 | 0.949596 | 21.3107 | ArchiCADProperties - ID of Connected Openings: OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003; OP - 003
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 147.39 (kgCO₂) | 1951.55 | 0 | 2 | 4.43676 | 4.39496 | 0 | 0 | 1.10277 | 0.842647 | 3.4118 | 1.10277 | 1.10277 | 5.07864 | 21.4281 | 21.2195 | 0.176444 | 5.07864 | 5.07864 | 22.5309 | 5.07864 | 22.3222 | 3.58825 | 22.5309 | 22.3222 | 5.07864 | 5.07864 | 0.812582 | 4.48787 | 5.07864 | 3.58825 | 10.4773 | 4.70676 | 14.0468 | 3.0646 | 136.472 | 21.4281 | 22.5309 | 0.71806 | 3.58825
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 67.9415 (kgCO₂) | 899.595 | 0 | 0 | 5.80019 | 0 | 0 | 0 | 0 | 0 | 1.57272 | -0.00000116638 | -0.00000117478 | 1.7961 | 9.85519 | 9.80379 | -1.70871e-07 | 2.16808 | 1.80089 | 9.85519 | 1.79131 | 9.80379 | 1.57272 | 11.8148 | 11.7634 | 1.80089 | 1.79131 | 0.287376 | 5.89859 | 1.80089 | 1.88625 | 3.91248 | 6.07019 | 15.4102 | 1.41855 | 62.9088 | 9.85935 | 9.85935 | 0.943774 | 1.57272
F6 | F6 | Paint - Anthracite; Insulation - Cellulose | 0 | 31.7828 (kgCO₂) | 420.828 | 0 | 0 | 4.90742 | 0 | 0 | 0 | 0 | 0 | 0.735713 | 0 | 0 | 1.07988 | 5.02607 | 4.49253 | 0 | 1.24049 | 1.05311 | 5.02607 | 1.10665 | 4.49253 | 0.735713 | 9.23059 | 8.28528 | 1.05311 | 1.10665 | 0.153832 | 5.01749 | 1.05311 | 1.40141 | 2.48848 | 5.17742 | 14.5174 | 1.09759 | 29.4285 | 5.02607 | 5.02607 | 0.802798 | 0.735713
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 42.2127 (kgCO₂) | 558.927 | 0 | 0 | 4.93515 | 0 | 0 | 0 | 0 | 0 | 0.977146 | 0 | 0 | 1.28041 | 6.3775 | 5.83612 | 0 | 1.622 | 1.33954 | 6.3775 | 1.22129 | 5.83612 | 0.977146 | 9.51112 | 8.99262 | 1.33954 | 1.22129 | 0.204866 | 4.98703 | 1.33954 | 1.48035 | 2.91978 | 5.20515 | 14.5452 | 1.2058 | 39.0858 | 6.38075 | 6.38075 | 0.797925 | 0.977146
F6 | F6 | Paint - Anthracite; Insulation - Cellulose | 0 | 93.4389 (kgCO₂) | 1237.2 | 0 | 0 | 4.43604 | 4.39452 | 0 | 0 | 0 | 0 | 2.16294 | 0 | 0 | 3.06172 | 13.5812 | 13.4555 | 0 | 3.06172 | 3.06172 | 13.5812 | 3.06172 | 13.4555 | 2.16294 | 13.5812 | 13.4555 | 3.06172 | 3.06172 | 0.489876 | 4.46934 | 3.06172 | 2.16294 | 6.44345 | 4.70604 | 14.046 | 2.40853 | 86.5175 | 13.5812 | 13.5812 | 0.715094 | 2.16294
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 21.7617 (kgCO₂) | 288.141 | 0 | 0 | 4.4356 | 0 | 0 | 0 | 0 | 0 | 0.503742 | 0 | 0 | 0.830419 | 3.54556 | 2.86072 | 0 | 1.01682 | 0.799352 | 3.54556 | 0.861486 | 2.86072 | 0.503742 | 7.22589 | 6.39023 | 0.799352 | 0.861486 | 0.114077 | 4.46934 | 0.799352 | 1.0891 | 1.99248 | 4.7056 | 14.0456 | 0.938263 | 20.1497 | 3.54556 | 3.54556 | 0.715094 | 0.503742
