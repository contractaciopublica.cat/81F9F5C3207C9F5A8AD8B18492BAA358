Properties of the parts of a building model (IFC2X3), part 29 of 99

# IfcBuildingElementProxy: Rhino_Object_1191, Object_1191
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1191; Hotlink and Element ID: Object_1191; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1191; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1191; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1191 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1191_; 109.AMB.CodiTipus: Object_1191; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1191 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1192, Object_1192
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Equantity_Rhino_Object_1192 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1192_; 109.AMB.CodiTipus: Object_1192; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1192 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1192; Hotlink and Element ID: Object_1192; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1192; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1192; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1193, Object_1193
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1193; Hotlink and Element ID: Object_1193; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1193; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1193; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1193 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1193_; 109.AMB.CodiTipus: Object_1193; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1193 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2

# IfcBuildingElementProxy: Rhino_Object_1194, Object_1194
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1194; Hotlink and Element ID: Object_1194; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1194; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1194; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1194 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1194_; 109.AMB.CodiTipus: Object_1194; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426578 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
AC_Equantity_Rhino_Object_1194 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m

# IfcBuildingElementProxy: Rhino_Object_1195, Object_1195
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1195 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1195; Hotlink and Element ID: Object_1195; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1195; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1195; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1195_; 109.AMB.CodiTipus: Object_1195; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426578 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1195 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Rhino_Object_1196, Object_1196
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1196 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426578 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1196_; 109.AMB.CodiTipus: Object_1196; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1196 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1196; Hotlink and Element ID: Object_1196; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1196; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1196; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1197, Object_1197
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1197; Hotlink and Element ID: Object_1197; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1197; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1197; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1197 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1197_; 109.AMB.CodiTipus: Object_1197; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426578 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1197 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Rhino_Object_1198, Object_1198
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1198; Hotlink and Element ID: Object_1198; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1198; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1198; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1198 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1198_; 109.AMB.CodiTipus: Object_1198; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426578 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1198 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1199, Object_1199
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1199; Hotlink and Element ID: Object_1199; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1199; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1199; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1199 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1199_; 109.AMB.CodiTipus: Object_1199; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
AC_Equantity_Rhino_Object_1199 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426579 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_120, Object_120
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_120; Hotlink and Element ID: Object_120; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_120; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_120; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_120 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_120_; 109.AMB.CodiTipus: Object_120; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426576 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_120 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1200, Object_1200
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1200; Hotlink and Element ID: Object_1200; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1200; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1200; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1200 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1200_; 109.AMB.CodiTipus: Object_1200; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426579 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
AC_Equantity_Rhino_Object_1200 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m

# IfcBuildingElementProxy: Rhino_Object_1201, Object_1201
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1201; Hotlink and Element ID: Object_1201; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1201; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1201; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1201 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426579 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1201 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1201_; 109.AMB.CodiTipus: Object_1201; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1202, Object_1202
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1202; Hotlink and Element ID: Object_1202; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1202; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1202; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1202 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1202_; 109.AMB.CodiTipus: Object_1202; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426579 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1202 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1203, Object_1203
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1203 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426579 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1203_; 109.AMB.CodiTipus: Object_1203; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1203 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1203; Hotlink and Element ID: Object_1203; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1203; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1203; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1204, Object_1204
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1204 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1204_; 109.AMB.CodiTipus: Object_1204; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Pset_Rhino_Object_1204 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1204; Hotlink and Element ID: Object_1204; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1204; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1204; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1205, Object_1205
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1205; Hotlink and Element ID: Object_1205; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1205; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1205; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
