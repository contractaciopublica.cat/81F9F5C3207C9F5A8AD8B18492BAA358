Properties of the parts of a building model (IFC2X3), part 3 of 99

# IfcBuildingElementProxy: Arch Top Window 27 (4)
AC_Equantity_Arch_Top_Window_27 - Z Dimension: 1 m; Bottom Level: 1 m; Top Level: 0 m; Transom Height (gs_transom_height): 0.6 m; New Wall Fill Width Right: 0.15 m; New Wall Fill Width Left: 0.15 m; Maximal Tolerance: 0.1 m; Tolerance Side (gs_tolerance): 0 m; Tolerance Side (gs_tolerance_left): 0 m; Tolerance Right: 0 m; Tolerance Upper: 0 m; Tolerance Lower: 0 m; Frame Thickness: 0.05 m; Frame Width: 0.05 m; Rebate Depth: 0.025 m; Rebate Width: 0.025 m; Transom Height (gs_UTrans_w): 0.1 m; Horizontal Division Height Main Sash: 0.56 m; Sash Frame Thickness: 0.05 m; Sash Frame Width: 0.05 m; Grill Width: 0.02 m; Grill Thickness: 0.025 m; Glass Thickness: 0.02 m; Louvers Thickness: 0.01 m; Louvers Width: 0.05 m; Left Opening Oversize: 0 m; Right Opening Oversize: 0 m; Upper Opening Oversize: 0 m; Lower Opening Oversize: 0 m; Width Side (gs_tw_right_out): 0.1 m; Width Side (gs_tw_left_out): 0.1 m; Width Top (gs_tw_top_out): 0.1 m; Width Bottom (gs_tw_bottom_out): 0.1 m; Thickness on Wall (gs_trim_thk_out): 0.025 m; Offset (gs_trim_offs_out): 0 m; Width Side (gs_tw_right_in): 0.1 m; Width Side (gs_tw_left_in): 0.1 m; Width Top (gs_tw_top_in): 0.1 m; Width Bottom (gs_tw_bottom_in): 0.1 m; Thickness on Wall (gs_trim_thk_in): 0.025 m; Offset (gs_trim_offs_in): 0 m; Nosing (gs_trim_jambext_nosing_in): 0.03 m; Width of Sill: 0 m; Sill Top Width: 0.01 m; Sill Top Height: 0.01 m; Sill Thickness: 0.025 m; Sill Front Side Thickness: 0.015 m; Sill Elevation: 0.005 m; Sill Drip Overlap: 0.02 m; Sill Drip Width: 0.03 m; Sill Nosing: 0.03 m; Sill Overhang Left: 0 m; Sill Overhang Right: 0 m; Sill Slip-in Depth: 0.02 m; Sill Slip from Wall: 0 m; Rear Hole Depth (gs_sill_holeDepthBehind): 0 m; Brick Thickness (gs_brick_sill_br_thk): 0.065 m; Mortar Thickness (gs_brick_sill_mort_thk): 0.015 m; Board Thickness: 0.025 m; Board Nosing: 0.03 m; Board Overhang Left: 0 m; Board Overhang Right: 0 m; Board Slip-in Depth: 0 m; Profile Height: 0.065 m; Profile Thickness: 0.11 m; Panel Height: 1.5 m; Inner Offset: 0.02 m; Closing Depth: 0 m; Extra Frame Width: 0.04 m; Extra Frame Thickness: 0.03 m; Rail Width: 0.03 m; Hanging Stick Length: 0.02 m; Hanging Stick Radius: 0.005 m; Panel Distance: 0.006 m; Outside Overhang: 0 m; Inner Panel Width: 0.12 m; 3D Opening Length: 1.5 m; 3D Closed Length: 0 m; 3D Opening Length 1: 0.56 m; 3D Opening Length 2: 0.14 m; 3D Opening Height: 1.5 m; 3D Closed Height: 0 m; Panel Thickness: 0.05 m; Panel Frame Width: 0.05 m; Frame Width Bottom: 0.05 m; Panel Width: 0 m; Panel Fill Thickness: 0.01 m; Louver Thickness: 0.01 m; Louver Width: 0.04 m; Horizontal Frame Divider Width: 0.05 m; Vertical Frame Divider Width: 0.05 m; Hole Radius: 0.01 m; Vertical Board Width: 0.1 m; Z Frame Width: 0.05 m; Z Frame Thickness: 0.025 m; Vertical Boards Thickness: 0.025 m; Horizontal Boards Thickness: 0.025 m; Vertical Boards Approximate Width: 0.08 m; Horizontal Boards Approximate Width: 0.115 m; Box Height (gs_shutRoll_boxHeight): 0.2 m; Box Depth (gs_shutRoll_boxWidth): 0.15 m; Box Left Offset: 0 m; Box Right Offset: 0 m; Depth of Rails: 0.0725 m; Distance from Wall (gs_shutRoll_distFromWall): 0 m; Distance from Header (gs_shutRoll_distFromHead): 0 m; Slat Width: 0.05 m; Box Height (gs_shutLam_boxHeight): 0.2 m; Box Depth (gs_shutLam_boxWidth): 0.15 m; Cover Width: 0 m; Distance from Wall (gs_shutLam_distFromWall): 0 m; Distance from Header (gs_shutLam_distFromHead): 0 m; Segment Width (gs_shutLam_segmentWidth): 0.06 m; Box Height (gs_shutLam2_boxHeight): 0.06 m; Box Width: 0.06 m; Distance from Window: 0.06 m; Distance from Header (gs_shutLam2_distFromHead): 0.06 m; Box Axis Height from Header: 0 m; Segment Width (gs_shutLam2_segmentWidth): 0.06 m; Distance between Arch and Window: 0 m; Masonry Arch Overhang Left: 0 m; Masonry Arch Overhang Right: 0 m; Masonry Arch Rise: 0.03 m; Masonry Arch Projection: 0 m; Masonry Arch Height: 0.25 m; Masonry Arch Depth: 0.12 m; Rear Hole Depth (gs_masonry_arch_rearHoleDepth): 0 m; Brick Thickness (gs_masonry_arch_brick_thk): 0.065 m; Mortar Thickness (gs_masonry_arch_mort_thk): 0.01 m; Keystone Width: 0.1 m; Keystone Oversize: 0 m; Keystone Projection: 0.01 m; Jamb Depth Side 2: 0.06 m; Jamb Depth: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_splayed_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_splayed_innerRight): 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_double_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_double_innerRight): 0.06 m; Head Jamb Depth: 0.06 m; Sill Jamb Depth: 0.06 m; Inner Head Depth (gs_reveal_splayed_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_splayed_innerBottom): 0.06 m; Inner Head Depth (gs_reveal_double_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_double_innerBottom): 0.06 m; Outer Jamb Depth: 0.08 m; Plaster Thickness Limit: 0.04 m; Distance of Skin from Closer: 0 m; Closer Width: 0.038 m; Closer Thickness: 0.1 m; Strip Thickness: 0.025 m; Profile Width: 0.075 m; Custom Thickness: 0.015 m; Skin Overhang to Frame Depth: 0 m; Depth of Inset: 0.05 m; Parapet Width: 1 m; Overhang Side 1: 0 m; Overhang Side 2: 0 m; Parapet Height: 0.9 m; Bottom Overhang: 0 m; Opening Distance 1 Main Sash: 0 m; Opening Distance 2 Main Sash: 0 m; Opening Distance 1 Transom Sash Side 2: 0 m; Opening Distance 2 Transom Sash Side 2: 0 m; Opening Length in 2D: 0 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
Name | Reveal Dimensions = Wallhole Dimensions = Unit Dimensions = Nominal W x H Size | Nominal W x H x T Size | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Home Story Name = 115.AMB.Nivell | Home Story Number | Wall Direction Type | Outside Bottom Casing = Cover Outer Wall Surface | Curve Resolution | Total Glazed Area (gs_list_glassarea) | 107.AMB.NomTipus | W/D Opening Opening Volume (m3) | W/D Opening Nominal Volume (m3) | W/D Opening Surface Area (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | W/D Opening Nominal Surface Area (m2) = Nominal W/D Opening Surface Area on the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | W/D Opening Width on the Reveal Side (m) = W/D Opening Width on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Width on the Reveal Side (m) = Nominal W/D Opening Width on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Width (m) = AC_Equantity_Arch_Top_Window_27, Width (m) = Wallhole Width (m) = Reveal Width (m) = Unit Width (m) = 502.AMB.Amplada (m) | W/D Opening Height on the Reveal Side (m) = W/D Opening Height on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Height on the Reveal Side (m) = Nominal W/D Opening Height on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Height (m) = AC_Equantity_Arch_Top_Window_27, Height (m) = Wallhole Height (m) = Reveal Height (m) = Unit Height (m) = 503.AMB.Altura (m) | W/D Opening Surface Area on the Reveal Side (m2) = W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | Sill/Header Value (m) = W/D Nominal Sill Height (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) = Sill Height to Current Story (m) | W/D Sill Height on the Reveal Side (m) = W/D Sill Height on the Side Opposite to the Reveal Side (m) | W/D Nominal Head Height (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | W/D Head Height on the Reveal Side (m) = W/D Head Height on the Side Opposite to the Reveal Side (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Elevation to Linked/Home Story (m) | Top Elevation To Sea Level (m) | Reveal to Wall Core (m) = Reveal Depth (gs_wido_sill) (m) = Reveal Depth (AC_wido_sill) (m) | Shoulder Height (m) | Thickness in Wallhole (gs_trim_width_out) (m) | Nosing (gs_trim_jambext_nosing_out) (m) | Thickness in Wallhole (gs_trim_width_in) (m) | Board Width (m) | AUX_107.NomTipus
V204 | 1.599,2×3.094,8 | 1.599,2×3.094,8×80,0 | V204 | planta coberta | 1 | 0 | yes | 50 | 4.62286 | V204_FinestraTipusG | 0.389008 | 0.395939 | 17.4622 | 4.94924 | 1.59919 | 3.09484 | 4.8626 | 3.2226 | 1.40834 | 6.31744 | 4.50318 | 0.0386325 | 12.5626 | -1.2774 | 15.6574 | -0.3 | 2.93893 | 0.025 | 0.05 | 0.005 | 0.36 | FinestraTipusG
V203 | 1.599,2×4.599,0 | 1.599,2×4.599,0×80,0 | V203 | planta baixa | 0 | 0 | yes | 80 | 6.87785 | V203_FinestraTipusH | 0.581861 | 0.588371 | 25.4736 | 7.35464 | 1.59919 | 4.59898 | 7.27326 | 1.71425 | 0 | 6.31323 | 4.49898 | 0.159591 | 11.0543 | 1.71425 | 15.6532 | -0.3 | 4.44727 | 0.025 | 0.05 | 0.03 | 0.36 | FinestraTipusH
V201 | 1.724,0×2.413,6 | 1.724,0×2.413,6×80,0 | V201 | planta baixa | 0 | 1 | no | 50 | 3.98084 | V201_FinestraTipusG | 0.326096 | 0.332874 | 12.5515 | 4.16092 | 1.72397 | 2.41357 | 4.07619 | 2.66699 | 0.852742 | 5.08056 | 3.26631 | 0.0281881 | 12.007 | 2.66699 | 14.4206 | -0.15 | 2.27266 | 0.005 | 0.03 | 0.005 | 0.21 | FinestraTipusG
V202 | 1.724,0×2.413,6 | 1.724,0×2.413,6×80,0 | V202 | planta baixa | 0 | 1 | no | 50 | 3.98084 | V202_FinestraTipusG | 0.326096 | 0.332874 | 12.5515 | 4.16092 | 1.72397 | 2.41357 | 4.07619 | 2.66699 | 0.852742 | 5.08056 | 3.26631 | 0.0281881 | 12.007 | 2.66699 | 14.4206 | -0.15 | 2.27266 | 0.005 | 0.03 | 0.005 | 0.21 | FinestraTipusG

# IfcBuildingElementProxy: Battens for Roof Tiles 27 (8)
In: planta baixa
Material: Timber - Roof
ArchiCADProperties - Surface: Rhino - 011; Layer: 00_ENRASTRELADO; Library Part Name: Battens for Roof Tiles 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Building Materials (All): Timber - Roof; Surfaces (All): Wood - Pine Grained Horizontal; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Battens_for_Roof_Tiles_27 - 3D Detail Level: 2; 1st Cutting Angle: 90 deg; 2nd Cutting Angle: 90 deg; Building Material: Timber - Roof; Override Surfaces: no; Surface: Wood - Pine Grained Horizontal; Override Cut Fill Pens: 0; Cut Fill Foreground Pen: Beams - Cut Structural; Cut Fill Background Pen: Beams - Fill Backgrounds; Shadow: yes; Cut Line Pen: Objects - Cut Structural; Show 2D Hotspots in 3D: no; Contour Line Type: 4; Contour Pen: Objects - General; Floor Plan Display (AC_symb_display_option): 2; Show Projection (AC_symb_show_projection_to): 3; Floor Plan Display (gs_symb_display_option): Projected with Overhead; Use 3D View Attributes: no; Show Projection (gs_symb_show_projection_to): Entire Element; Contours Only: no; Fill Type: Background; Fill Pen: Stairs/Railings - Outlines; Fill Background Pen: Transparent; Cut Lines: 1; Uncut Line Pen: 2D Elements - General; Overhead Lines: 21; Overhead Line Pen: Annotation Text - General; 2D Symbol: no; 2D Projection Type: 0; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30
Pset_BuildingElementProxyCommon - Status: NEW
1 AMB.Identificacio - 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
AC_Equantity_Battens_for_Roof_Tiles_27 - Batten Height: 0.03 m; Batten Width: 0.04 m; Batten Space: 0.3 m; Bottom Level: 1 m; Top Level: 0 m; Height of the Cut Plane: 0 m; Height of the Top Cut Plane: 0 m; Height of the Bottom Cut Plane: 0 m; Profile Thickness: 0.04 m; Profile Height: 0.03 m
Name | Classification | Rotation Angle (deg) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Roof Pitch (deg) | Timber - Roof, Embodied Carbon | Timber - Roof, Embodied Energy (MJ) | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | Length (A) (m) = Dimension 1 (m) = Lumber Size (m) | Area (m2) = Top Surface Area (Net) (m2) | ArchiCADQuantities, Height (m) = 503.AMB.Altura (m) = AC_Equantity_Battens_for_Roof_Tiles_27, Height (m) | Volume (Net) (m3) = Timber - Roof, Component Volume (Net) (m3) = Timber - Roof, Component Volume (Gross) (m3) | Width (m) = 502.AMB.Amplada (m) = Dimension 2 (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Surface Area (m2) = Bottom Surface Area (Net) (m2) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Survey Coordinate X (m) | Survey Coordinate Y (m) | Timber - Roof, Mass (kg) | Length (m) | Structural Length (m)
Cu1 | 30.20.20 Fusteria de cobertes (GuBIMclass CA) | 197.066 | Cu1 | 14.4 | 101.315 (kgCO₂) | 2814.31 | 30.20.20 Fusteria de cobertes | 30.20.20 | Fusteria de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | 20.3936 | 135.308 | 1.70354 | 0.562862 | 6.63484 | 4.63796 | 13.978 | 65.7225 | 6.31832 | 15.6583 | 426588 | 4579800 | 281.431 | 5.911 | 6.85005 | GENERAL PROPERTIES - AUX_107.NomTipus: CobertaR60
Cu1 | 30.20.20 Fusteria de cobertes (GuBIMclass CA) | 17.0568 | Cu1 | 18 | 3.31776 (kgCO₂) | 92.16 | 30.20.20 Fusteria de cobertes | 30.20.20 | Fusteria de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | 3.84 | 3.76643 | 0.318695 | 0.018432 | 0.980841 | 4.16358 | 13.5036 | 2.16 | 4.48258 | 13.8226 | 426534 | 4579776 | 9.216 | 1.03132 | 1.03132 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
Cu1 | 30.20.20 Fusteria de cobertes (GuBIMclass CA) | 197.057 | Cu1 | 18 | 3.31776 (kgCO₂) | 92.16 | 30.20.20 Fusteria de cobertes | 30.20.20 | Fusteria de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | 3.84 | 3.76643 | 0.318695 | 0.018432 | 0.980841 | 4.16358 | 13.5036 | 2.16 | 4.48258 | 13.8226 | 426534 | 4579777 | 9.216 | 1.03132 | 1.03132 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.20 Fusteria de cobertes (GuBIMclass CA) | 197.066 | Cu1 | 14.4 | 105.321 (kgCO₂) | 2925.59 | 30.20.20 Fusteria de cobertes | 30.20.20 | Fusteria de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | 21.1999 | 140.658 | 1.70354 | 0.585118 | 6.63484 | 4.638 | 13.978 | 68.3189 | 6.31836 | 15.6584 | 426558 | 4579791 | 292.559 | 5.911 | 6.85005 | GENERAL PROPERTIES - AUX_107.NomTipus: CobertaR60
Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 103.334 | Cu5 | 17.48 | 33.9993 (kgCO₂) | 944.426 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_ | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | 7.87022 | 43.2811 | 1.73183 | 0.188885 | 5.49935 | 8.65055 | 17.9905 | 22.0846 | 10.4033 | 19.7433 | 426531 | 4579811 | 94.4426 | 4.00827 | 5.76559
Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 193.548 | Cu3 | 36.5 | 6.00661 (kgCO₂) | 166.85 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | 2.78084 | 6.24596 | 1.662 | 0.03337 | 2.24607 | 4.74116 | 14.0812 | 3.91717 | 6.39509 | 15.7351 | 426529 | 4579798 | 16.685 | 3.22755 | 2.79412 | GENERAL PROPERTIES - AUX_107.NomTipus: Coberta inclinada
Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 13.5915 | Cu3 | 36.5 | 6.00661 (kgCO₂) | 166.85 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | 2.78084 | 6.24596 | 1.662 | 0.03337 | 2.24607 | 4.74116 | 14.0812 | 3.91717 | 6.39509 | 15.7351 | 426530 | 4579794 | 16.685 | 3.22755 | 2.79412 | GENERAL PROPERTIES - AUX_107.NomTipus: Coberta inclinada
Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 103.334 | Cu5 | 17.48 | 37.5897 (kgCO₂) | 1044.16 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_ | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | 12.4305 | 47.5238 | 1.20397 | 0.208832 | 3.82317 | 7.47913 | 16.8191 | 24.3973 | 8.69121 | 18.0312 | 426534 | 4579817 | 104.416 | 4.00827 | 4.00827

# IfcBuildingElementProxy: Brick (6)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Brick
ArchiCADProperties - Cast Shadow: yes; Receive Shadow: yes; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Morph; Building Materials (All): Brick; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Name | Surface = Surfaces (All) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Layer | Colliding Zones | Brick, Embodied Carbon | Brick, Embodied Energy (MJ) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Brick, Component Volume (Net) (m3) = Brick, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Surface Area (m2) = Bottom Surface Area (Net) (m2) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Brick, Mass (kg) | 107.AMB.NomTipus | 117.AMB.Localitzacio
2 x MORPH-003 | Brick - Aged Natural | MORPH-003 | 00_ORNAMENTOS PLANTA | Espai públic; Nau Lateral | 54.6283 (kgCO₂) | 682.854 | 0.128386 | 0.151745 | 2.47665 | 11.8166 | 7.08977 | 5.23544 | 5.50683 | 14.8468 | 227.618 | MORPH-003_ | Nau Lateral
Object_3586 | Brick - Aged Natural | Object_3586 | 00_ORNAMENTOS PLANTA | Espai públic; Nau Annexa | 359.839 (kgCO₂) | 4497.98 | 0.560831 | 0.999552 | 1.93422 | 11.2742 | 13.2072 | 4.4419 | 6.21897 | 15.559 | 1499.33 | Object_3586_ | Annex
MORPH-010 | Brick - Aged Natural | MORPH-010 | 00_ORNAMENTOS PLANTA | Espai públic; Nau Lateral | 0 (kgCO₂) | 0 | 0.140218 | 0 | 1.097 | 10.437 | 8.3011 | 5.70871 | 5.26996 | 14.61 | 0 | MORPH-010_ | Nau Lateral
Object_3522 | Paint - Light Gray | Object_3522 | 00_ENCABALLADA | Nau Lateral; Sala de reunions | 0 (kgCO₂) | 0 | 2.53588 | 0 | 4.41095 | 13.751 | 17.7655 | 48.0297 | 5.25237 | 14.5924 | 0 | Object_3522_ | Nau Lateral
MORPH-004 | Brick - Aged Natural | MORPH-004 | 00_ORNAMENTOS PLANTA | Espai públic; Nau Lateral | 286.279 (kgCO₂) | 3578.49 | 0.48278 | 0.795221 | 1.71425 | 11.0543 | 35.966 | 19.4112 | 7.14105 | 16.481 | 1192.83 | MORPH-004_ | Nau Lateral

# IfcBuildingElementProxy: Brick 110, F6
In: planta baixa
Classification: 30.10.10.10 Façanes in situ (GuBIMclass CA); Material: Brick
Component Properties - Brick, Embodied Carbon: 332.344 (kgCO₂); Brick, Embodied Energy: 4154.3 MJ
Pset_BuildingElementProxyCommon - Status: NEW
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Mur_350_Mao
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.10 Façanes in situ; 104.AMB.ClassificacioCodi: 30.10.10.10; 105.AMB.ClassificacioDescripcio: Façanes in situ; 107.AMB.NomTipus: F6_Mur_350_Mao; 109.AMB.CodiTipus: F6; 111.AMB.DescripcioTipus: Mur de fàbrica de maó massís manual armat amb morter de calç 3,5 HL; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Brick - Aged Natural; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F6; Hotlink and Element ID: F6; Layer: 00_CUBIERTA; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F6; Building Materials (All): Brick; Surfaces (All): Brick - Aged Natural; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 0.66084 m; Minimum Height of the Wall: 0.66084 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Average length of the Wall: 12.6998 m; Surface Area of the Wall Inside Face (Net): 8.39253 m2; Surface Area of the Wall Outside Face (Net): 8.39253 m2; Analytic Volume of the Openings: 0 m3; Length of Reference Line: 12.6998 m; Length of the Wall Inside Face (Conditional): 12.6998 m; Surface Area of the Wall Inside Face (Conditional): 8.39253 m2; Length of the Wall Outside Face (Conditional): 12.6998 m; Surface Area of the Wall Outside Face (Conditional): 8.39253 m2; Surface Area of the Wall Inside Face (Gross): 8.39253 m2; Surface Area of the Wall Outside Face (Gross): 8.39253 m2; End Thickness of the Wall: 0.11 m; Length of the Wall at the Center: 12.6998 m; Length of the Wall on the Inside Face: 12.6998 m; Length of the Wall on the Outside Face: 12.6998 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 1.39698 m2; Height: 0.66084 m; Volume (Net): 0.923178 m3; Width: 0.11 m; Elevation to Project Zero: 10.0114 m; Elevation to 1st Reference Level: 10.0114 m; Elevation to 2nd Reference Level: 10.0114 m; Elevation to Sea Level: 19.3514 m; Elevation to Linked/Home Story: 10.0114 m; Home Offset: 10.0114 m; Top Offset: 0 m; Surface Area: 8.39253 m2; 3D Length: 12.6998 m; Thickness: 0.11 m; Volume (Conditional): 0.923178 m3; Volume (Gross): 0.923178 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 25.6196 m; Top Elevation To First Reference Level: 10.6722 m; Top Elevation To Home Story: 10.6722 m; Top Elevation To Project Zero: 10.6722 m; Top Elevation To Sea Level: 20.0122 m; Top Elevation To Second Reference Level: 10.6722 m; Bottom Elevation To First Reference Level: 10.0114 m; Bottom Elevation To Home Story: 10.0114 m; Bottom Elevation To Project Zero: 10.0114 m; Bottom Elevation To Sea Level: 19.3514 m; Bottom Elevation To Second Reference Level: 10.0114 m; Top Surface Area (Net): 1.39698 m2; Edge Surface Area (Net): 2.93934 m2; Bottom Surface Area (Net): 8.39253 m2
Component Quantities - Brick, Mass: 1384.77 kg; Brick, Projected Component Area (Net): 8.39253 m2; Brick, Projected Component Area (Gross): 8.39253 m2; Brick, Component Thickness: 0.11 m; Brick, Rectangular Component Height: 0.66084 m; Brick, Rectangular Component Width: 0.11 m; Brick, Component Cross Section Area: 0.0726924 m2; Brick, Component Volume (Net): 0.923178 m3; Brick, Component Volume (Gross): 0.923178 m3
5 AMB.Geometria - 501.AMB.Longitud: 12.6998 m; 502.AMB.Amplada: 0.11 m; 503.AMB.Altura: 0.66084 m; 504.AMB.Gruix: 0.11 m; 506.AMB.Profunditat: 0 m
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Brick 140 (3)
Material: Brick
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Locked: no; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Building Materials (All): Brick; Slant Angle: 90 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.14 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.14 m; Top Offset: 0 m; Thickness: 0.14 m; Insulation Skin Thickness: 0 m
5 AMB.Geometria - 502.AMB.Amplada: 0.14 m; 504.AMB.Gruix: 0.14 m; 506.AMB.Profunditat: 0 m
Component Quantities - Brick, Component Thickness: 0.14 m; Brick, Rectangular Component Width: 0.14 m
Name | In | Classification | Inside Face Surface = Outside Face Surface = Edge Surface | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Layer | Home Story Name = 115.AMB.Nivell | Home Story Number | Surfaces (All) | Renovation Status | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 117.AMB.Localitzacio | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | Status | AUX_104.AMB.ClassificacioCodiCateg | Brick, Embodied Carbon | Brick, Embodied Energy (MJ) | Maximum Height of the Wall (m) | Minimum Height of the Wall (m) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) = Length of the Wall on the Inside Face (m) | Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = 503.AMB.Altura (m) = Brick, Rectangular Component Height (m) | Volume (Net) (m3) = Volume (Conditional) (m3) = Brick, Component Volume (Net) (m3) = Brick, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To Home Story (m) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Brick, Mass (kg) | Brick, Projected Component Area (Net) (m2) = Brick, Projected Component Area (Gross) (m2) | Brick, Component Cross Section Area (m2) | 111.AMB.DescripcioTipus | 402.AMB.DBSIResistenciaFoc | 201.AMB.EsEstructural | AUX_107.NomTipus
F3 | planta baixa | 00.20 Preexistències (GuBIMclass CA) | Brick - Red Herringbone | F3 | 00_ORNAMENTOS PLANTA | planta baixa | 0 | Brick - Red Herringbone | Existing | 00.20 Preexistències | 00.20 | Preexistències | F3_ | Annex | Preexistències | EXISTING | 00 | 336.339 (kgCO₂) | 4204.24 | 2.54942 | 2.54942 | 2.61761 | 6.67339 | 6.67339 | 2.61761 | 2.61761 | 2.61761 | 6.67339 | 6.67339 | 0.366465 | 2.54942 | 0.934275 | 1.99569 | 11.3357 | 1.99569 | 2.61761 | 0.934275 | 5.51521 | 4.54511 | 4.54511 | 13.8851 | 1.44677 | 1401.41 | 6.67339 | 0.356919 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Annexa
F9 | planta coberta | 30.20.10.10 Cobertes in-situ (GuBIMclass CA) | Brick - Red Herringbone | F9 | 00_MURO LADRILLO | planta coberta | 1 | Brick - Red Herringbone; Brick - Aged Natural | New | 30.20.10.10 Cobertes in-situ | 30.20.10.10 | Cobertes in-situ | F9_Mur_140_Mao | Nau Lateral | Obra | NEW | 30 | 1048.98 (kgCO₂) | 13112.3 | 4.99174 | 0 | 4.93901 | 20.8135 | 20.8129 | 5.15895 | 4.93907 | 4.93895 | 23.0074 | 23.0068 | 0.691462 | 5.24525 | 2.91385 | 5.65425 | 14.9943 | 1.15425 | 4.93907 | 3.22099 | 10.158 | 10.646 | 6.146 | 19.986 | 1.4164 | 4370.77 | 20.8135 | 0.734335 | Ampit de maó massís manual armat amb morter de calç 3,5 HL | R60 | No | Mur_140_Mao
F8 | planta coberta | 30.20.10.50 Remats de cobertes (GuBIMclass CA) | Brick - Aged Natural | F8 | 00_MURO LADRILLO | planta coberta | 1 | Brick - Aged Natural | New | 30.20.10.50 Remats de cobertes | 30.20.10.50 | Remats de cobertes | F8_Mur_220_Mao | Nau Lateral | Obra | NEW | 30 | 176.191 (kgCO₂) | 2202.39 | 0.904721 | 0 | 3.92808 | 3.55382 | 3.41213 | 4.36808 | 3.92808 | 3.92808 | 3.9519 | 3.79434 | 0.549932 | 0.904721 | 0.48942 | 9.78536 | 19.1254 | 5.28536 | 3.92821 | 0.544241 | 8.13617 | 10.6901 | 6.19008 | 20.0301 | 1.12165 | 734.129 | 3.55393 | 0.126661 | Ampit de maó massís manual armat amb morter de calç 3,5 HL | R60 | No | Mur_220_Mao

# IfcBuildingElementProxy: Brick 140 x 253 (2)
In: planta coberta
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Brick
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Brick - Aged Natural; Left Side Surface: Brick - Aged Natural; Right Side Surface: Brick - Aged Natural; Beam Slant Angle: 0 deg; Element ID: BMR - 006; Hotlink and Element ID: BMR - 006; Layer: 00_ORNAMENTOS; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Beam; Structure Type: Basic; Parent ID: BMR - 006; Building Materials (All): Brick; Surfaces (All): Brick - Aged Natural; Cover Fill: Background; Slant Angle: 0 deg; Number of Openings: 0; Top Surface: Brick - Aged Natural; Bottom Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: BMR - 006_; 109.AMB.CodiTipus: BMR - 006; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Component Properties - Brick, Embodied Carbon: 33.3194 (kgCO₂); Brick, Embodied Energy: 416.492 MJ; Brick, Component Type: Core
ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0707165 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.661099 m2; Length Left: 2.6176 m; Length Right: 2.6176 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.661099 m2; Area: 0.366465 m2; Height: 0.252559 m; Volume (Net): 0.0925538 m3; Width: 0.14 m; Elevation to Project Zero: 4.67139 m; Elevation to 1st Reference Level: 4.67139 m; Elevation to 2nd Reference Level: 4.67139 m; Elevation to Sea Level: 14.0114 m; Elevation to Linked/Home Story: 0.171393 m; Home Offset: 0.171393 m; Surface Area: 2.12584 m2; 3D Length: 2.6176 m; Volume (Conditional): 0.0925538 m3; Volume (Gross): 0.0925538 m3; Top Elevation To First Reference Level: 4.79767 m; Top Elevation To Home Story: 0.297672 m; Top Elevation To Project Zero: 4.79767 m; Top Elevation To Sea Level: 14.1377 m; Top Elevation To Second Reference Level: 4.79767 m; Bottom Elevation To First Reference Level: 4.54511 m; Bottom Elevation To Home Story: 0.0451137 m; Bottom Elevation To Project Zero: 4.54511 m; Bottom Elevation To Sea Level: 13.8851 m; Bottom Elevation To Second Reference Level: 4.54511 m; Cross Section Height at Top/End (perpendicular): 0.252559 m; Cross Section Height at Bottom/Start (perpendicular): 0.252559 m; Cross Section Width at Top/End (perpendicular): 0.14 m; Cross Section Width at Bottom/Start (perpendicular): 0.14 m; Cross Section Height at Top/End (cut): 0.252559 m; Cross Section Height at Bottom/Start (cut): 0.252559 m; Cross Section Width at Top/End (cut): 0.14 m; Cross Section Width at Bottom/Start (cut): 0.14 m; Cross Section Area at Bottom/Start: 0.0353582 m2; Cross Section Area at Top/End: 0.0353582 m2; Number of Segments: 1; Top Surface Area (Net): 0.366465 m2; Bottom Surface Area (Net): 0.366465 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.14 m; 503.AMB.Altura: 0.252559 m; 506.AMB.Profunditat: 0 m
Component Quantities - Brick, Mass: 138.831 kg; Brick, Projected Component Area (Net): 0.661099 m2; Brick, Projected Component Area (Gross): 0.661099 m2; Brick, Component Thickness: 0.14 m; Brick, Rectangular Component Height: 0.252559 m; Brick, Rectangular Component Width: 0.14 m; Brick, Component Cross Section Area: 0.0353582 m2; Brick, Component Volume (Net): 0.0925538 m3; Brick, Component Volume (Gross): 0.0925538 m3
Pset_BuildingElementProxyCommon - Status: EXISTING
Name | Colliding Zones
BMR - 006 | Espai públic; Nau Annexa
BMR - 006 | Instal·lacions; Nau Annexa

# IfcBuildingElementProxy: Brick 196 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Brick
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Red Herringbone; Outside Face Surface: Brick - Red Herringbone; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F3; Hotlink and Element ID: F3; Layer: 00_ORNAMENTOS PLANTA; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F3; Building Materials (All): Brick; Surfaces (All): Brick - Red Herringbone; Brick - Aged Natural; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Red Herringbone; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: F3_; 109.AMB.CodiTipus: F3; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 3.13 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.196 m; Surface Area of Empty Openings in the Wall: 0 m2; Height: 3.13 m; Width: 0.196 m; Elevation to Project Zero: 1.99569 m; Elevation to 1st Reference Level: 1.99569 m; Elevation to 2nd Reference Level: 1.99569 m; Elevation to Sea Level: 11.3357 m; Elevation to Linked/Home Story: 1.99569 m; Home Offset: 1.99569 m; Top Offset: 0 m; Thickness: 0.196 m; Insulation Skin Thickness: 0 m; Top Elevation To First Reference Level: 5.12569 m; Top Elevation To Home Story: 5.12569 m; Top Elevation To Project Zero: 5.12569 m; Top Elevation To Sea Level: 14.4657 m; Top Elevation To Second Reference Level: 5.12569 m; Bottom Elevation To First Reference Level: 1.99569 m; Bottom Elevation To Home Story: 1.99569 m; Bottom Elevation To Project Zero: 1.99569 m; Bottom Elevation To Sea Level: 11.3357 m; Bottom Elevation To Second Reference Level: 1.99569 m
5 AMB.Geometria - 502.AMB.Amplada: 0.196 m; 503.AMB.Altura: 3.13 m; 504.AMB.Gruix: 0.196 m; 506.AMB.Profunditat: 0 m
Component Quantities - Brick, Component Thickness: 0.196 m; Brick, Rectangular Component Height: 3.13 m; Brick, Rectangular Component Width: 0.196 m; Brick, Component Cross Section Area: 0.61348 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
Name | Brick, Embodied Carbon | Brick, Embodied Energy (MJ) | Minimum Height of the Wall (m) | Average length of the Wall (m) = Length of Reference Line (m) = Length of the Wall Inside Face (Conditional) (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall at the Center (m) = Length of the Wall on the Inside Face (m) = Length of the Wall on the Outside Face (m) = 3D Length (m) = 501.AMB.Longitud (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area of the Wall Inside Face (Gross) (m2) = Surface Area of the Wall Outside Face (Gross) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) = Brick, Projected Component Area (Net) (m2) = Brick, Projected Component Area (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Brick, Component Volume (Net) (m3) = Brick, Component Volume (Gross) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Edge Surface Area (Net) (m2) | Brick, Mass (kg)
F3 | 212.85 (kgCO₂) | 2660.62 | 2.95636 | 0.970204 | 3.01644 | 3.03674 | 0.19016 | 0.591249 | 0.5952 | 2.33241 | 1.52801 | 886.874
F3 | 213.227 (kgCO₂) | 2665.34 | 2.9575 | 0.971844 | 3.02177 | 3.04187 | 0.190481 | 0.592297 | 0.596207 | 2.33569 | 1.56259 | 888.445

# IfcBuildingElementProxy: Brick 200, SW - 052
In: planta coberta
Classification: 20.20.20.20 Jàsseres (GuBIMclass CA); Material: Brick
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Brick - Aged Natural; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: SW - 052; Hotlink and Element ID: SW - 052; Layer: 00_ACERO VIGAS; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: SW - 052; Building Materials (All): Brick; Surfaces (All): Brick - Aged Natural; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 20.20.20.20 Jàsseres; 104.AMB.ClassificacioCodi: 20.20.20.20; 105.AMB.ClassificacioDescripcio: Jàsseres; 107.AMB.NomTipus: SW - 052_; 109.AMB.CodiTipus: SW - 052; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Si
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 20
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Brick, Embodied Carbon: 351.176 (kgCO₂); Brick, Embodied Energy: 4389.69 MJ
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 0.349615 m; Minimum Height of the Wall: 0.286632 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Average length of the Wall: 15.3319 m; Surface Area of the Wall Inside Face (Net): 5.36026 m2; Surface Area of the Wall Outside Face (Net): 4.39461 m2; Analytic Volume of the Openings: 0 m3; Length of Reference Line: 15.3319 m; Length of the Wall Inside Face (Conditional): 15.3319 m; Surface Area of the Wall Inside Face (Conditional): 5.36026 m2; Length of the Wall Outside Face (Conditional): 15.3319 m; Surface Area of the Wall Outside Face (Conditional): 4.39461 m2; Surface Area of the Wall Inside Face (Gross): 5.36026 m2; Surface Area of the Wall Outside Face (Gross): 4.39461 m2; End Thickness of the Wall: 0.2 m; Length of the Wall at the Center: 15.3319 m; Length of the Wall on the Inside Face: 15.3319 m; Length of the Wall on the Outside Face: 15.3319 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 3.06638 m2; Height: 0.6 m; Volume (Net): 0.975488 m3; Width: 0.2 m; Elevation to Project Zero: 7.14105 m; Elevation to 1st Reference Level: 7.14105 m; Elevation to 2nd Reference Level: 7.14105 m; Elevation to Sea Level: 16.481 m; Elevation to Linked/Home Story: 2.64105 m; Home Offset: 2.64105 m; Top Offset: 0 m; Surface Area: 4.39461 m2; 3D Length: 15.3319 m; Thickness: 0.2 m; Volume (Conditional): 0.975488 m3; Volume (Gross): 0.975488 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 31.0638 m; Top Elevation To First Reference Level: 7.49066 m; Top Elevation To Home Story: 2.99066 m; Top Elevation To Project Zero: 7.49066 m; Top Elevation To Sea Level: 16.8307 m; Top Elevation To Second Reference Level: 7.49066 m; Bottom Elevation To First Reference Level: 7.14105 m; Bottom Elevation To Home Story: 2.64105 m; Bottom Elevation To Project Zero: 7.14105 m; Bottom Elevation To Sea Level: 16.481 m; Bottom Elevation To Second Reference Level: 7.14105 m; Top Surface Area (Net): 3.06638 m2; Edge Surface Area (Net): 6.40846 m2; Bottom Surface Area (Net): 4.39461 m2
5 AMB.Geometria - 501.AMB.Longitud: 15.3319 m; 502.AMB.Amplada: 0.2 m; 503.AMB.Altura: 0.6 m; 504.AMB.Gruix: 0.2 m; 506.AMB.Profunditat: 0 m
Component Quantities - Brick, Mass: 1463.23 kg; Brick, Projected Component Area (Net): 5.36026 m2; Brick, Projected Component Area (Gross): 5.36026 m2; Brick, Component Thickness: 0.2 m; Brick, Rectangular Component Height: 0.6 m; Brick, Rectangular Component Width: 0.2 m; Brick, Component Cross Section Area: 0.12 m2; Brick, Component Volume (Net): 0.975488 m3; Brick, Component Volume (Gross): 0.975488 m3

# IfcBuildingElementProxy: Brick 220 (3)
In: planta coberta
Classification: 30.20.10.10 Cobertes in-situ (GuBIMclass CA); Material: Brick
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Red Herringbone; Outside Face Surface: Brick - Red Herringbone; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F8; Hotlink and Element ID: F8; Layer: 00_MURO LADRILLO; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F8; Building Materials (All): Brick; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Red Herringbone; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10.10 Cobertes in-situ; 104.AMB.ClassificacioCodi: 30.20.10.10; 105.AMB.ClassificacioDescripcio: Cobertes in-situ; 107.AMB.NomTipus: F8_Mur_220_Mao; 109.AMB.CodiTipus: F8; 111.AMB.DescripcioTipus: Ampit de maó massís manual armat amb morter de calç 3,5 HL; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Mur_220_Mao
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.22 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.22 m; Elevation to Project Zero: 5.65425 m; Elevation to 1st Reference Level: 5.65425 m; Elevation to 2nd Reference Level: 5.65425 m; Elevation to Sea Level: 14.9943 m; Elevation to Linked/Home Story: 1.15425 m; Home Offset: 1.15425 m; Top Offset: 0 m; Thickness: 0.22 m; Insulation Skin Thickness: 0 m; Bottom Elevation To First Reference Level: 5.65425 m; Bottom Elevation To Home Story: 1.15425 m; Bottom Elevation To Project Zero: 5.65425 m; Bottom Elevation To Sea Level: 14.9943 m; Bottom Elevation To Second Reference Level: 5.65425 m
5 AMB.Geometria - 502.AMB.Amplada: 0.22 m; 504.AMB.Gruix: 0.22 m; 506.AMB.Profunditat: 0 m
Component Quantities - Brick, Component Thickness: 0.22 m; Brick, Rectangular Component Width: 0.22 m
Name | Surfaces (All) | Brick, Embodied Carbon | Brick, Embodied Energy (MJ) | Number of Columns | Maximum Height of the Wall (m) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) = Length of the Wall on the Inside Face (m) | Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = 503.AMB.Altura (m) = Brick, Rectangular Component Height (m) | Volume (Net) (m3) = Volume (Conditional) (m3) = Brick, Component Volume (Net) (m3) = Brick, Component Volume (Gross) (m3) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Brick, Mass (kg) | Brick, Projected Component Area (Net) (m2) = Brick, Projected Component Area (Gross) (m2) | Brick, Component Cross Section Area (m2)
F8 | Brick - Red Herringbone; Brick - Aged Natural | 1659.49 (kgCO₂) | 20743.7 | 0 | 5.03583 | 5.08191 | 20.9528 | 20.9536 | 5.30191 | 5.08191 | 5.08191 | 22.2795 | 22.2795 | 1.11802 | 5.03583 | 4.6097 | 5.08191 | 4.90149 | 10.6038 | 10.6901 | 6.19008 | 20.0301 | 2.45839 | 6914.55 | 20.9536 | 1.10788
F8 | Brick - Red Herringbone; Brick - Aged Natural | 1658.05 (kgCO₂) | 20725.7 | 0 | 5.03583 | 5.18832 | 20.9354 | 20.9346 | 5.29832 | 5.07832 | 5.29832 | 22.2614 | 22.2614 | 1.11723 | 5.03583 | 4.60571 | 5.07832 | 4.89751 | 10.9078 | 10.6901 | 6.19008 | 20.0301 | 2.45681 | 6908.56 | 20.9354 | 1.10788
F8 | Brick - Red Herringbone | 1176.95 (kgCO₂) | 14711.8 | 1 | 3.43662 | 4.25818 | 15.0118 | 14.7091 | 4.36818 | 4.14818 | 4.36818 | 15.0118 | 14.7091 | 0.961 | 4.88971 | 3.2693 | 4.36818 | 3.2693 | 9.04749 | 9.09087 | 4.59087 | 18.4309 | 2.71696 | 4903.95 | 15.0118 | 1.07574

# IfcBuildingElementProxy: Brick 250 (56)
In: planta coberta
Classification: 30.10.10.10 Façanes in situ (GuBIMclass CA); Material: Brick
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Brick - Aged Natural; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F6; Hotlink and Element ID: F6; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F6; Building Materials (All): Brick; Surfaces (All): Brick - Aged Natural; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.10 Façanes in situ; 104.AMB.ClassificacioCodi: 30.10.10.10; 105.AMB.ClassificacioDescripcio: Façanes in situ; 107.AMB.NomTipus: F6_Mur_350_Mao; 109.AMB.CodiTipus: F6; 111.AMB.DescripcioTipus: Mur de fàbrica de maó massís manual armat amb morter de calç 3,5 HL; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Santa Eulalia
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Mur_350_Mao
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.25 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.25 m; Top Offset: 0 m; Thickness: 0.25 m; Insulation Skin Thickness: 0 m
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Component Quantities - Brick, Component Thickness: 0.25 m; Brick, Rectangular Component Width: 0.25 m
5 AMB.Geometria - 502.AMB.Amplada: 0.25 m; 504.AMB.Gruix: 0.25 m; 506.AMB.Profunditat: 0 m
