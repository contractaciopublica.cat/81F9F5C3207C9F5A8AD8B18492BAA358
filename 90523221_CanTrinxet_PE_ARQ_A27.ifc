Properties of the parts of a building model (IFC2X3), part 96 of 99

# IfcBuildingElementProxy: Window 27 (42)
AC_Pset_Window_27 - Hotspots 0-None,1-2D,2-3D,3-All: 3; Hole Position Angle: 0 deg; Hole has Wall's Side Surface: yes; Hole Surface's Split is Curved in Curved Walls: no; Show 2D Hotspots in 3D: yes; Wall Type: 1; Corner Window Debug Function: no; Placement Type (1=CW,0=W): no; Flip: no; Demolition / New construction: 1; New Wall Fill Type: Masonry Block; New Wall Fill Pen: General - General; New Wall Fill Background Pen: Backgrounds - color 1; Show new construction on Wall: no; Demolition line type: 4; Show Demolition/New parameter: no; Corner Window Function: yes; Corner Angle: 90 deg; Diff. Conn. Wall Thickness: no; Corner Column: no; Corner 2: no; Corner Angle 2: 90 deg; Diff. Conn. Wall Thickness 2: no; Corner 1: no; Corner Angle 1: 90 deg; Diff. Conn. Wall Thickness 1: no; Corner Connection Type 1: 1; Corner Connection Type 2: 1; Fully Editable: yes; 2D Detail Level: 2; Show Reveal on Symbol: 1; 3D Detail Level: 2; Nominal Size: 0; Set Wallhole Size as Nominal Size: yes; Set Reveal Size as Nominal Size: no; Set Unit Size as Nominal Size: no; Transfer Current Nominal Size to Selection: no; Panes Horizontal: 1; Uniform Frame Width: yes; Upper Transom: no; Divided Upper Transom: no; Lower Transom: no; Divided Lower Transom: no; Panes Vertical: 3; Uniform Sashes: no; Fixed Glass Direction (FixGlassDir): By Opening Direction; Fixed Glass Direction (FixGlassDir_m): 1; Opening Type (gs_optype_m_03): 1; Opening Type (gs_optype_m_02): 1; Sash Type (MullionStyle_00): No Grid; Sash Type (iMullionStyle_00): 1; Sash Type Main Sash: No Grid; Sash Type (iMullionStyle_01): 1; Sash Type (iMullionStyle_03): 1; Sash Type (iMullionStyle_02): 1; Mirrored Custom Panel (gs_bMirr_cust_panel_01): no; Mirrored Custom Panel (gs_bMirr_cust_panel2_01): no; Mirrored Custom Panel (gs_bMirr_cust_panel_03): no; Mirrored Custom Panel (gs_bMirr_cust_panel2_03): no; Mirrored Custom Panel (gs_bMirr_cust_panel_02): no; Mirrored Custom Panel (gs_bMirr_cust_panel2_02): no; Hotspot Grill Editing: yes; Grid Position (MullionPosition): Throughout; Grid Position (iMullionPosition): 3; Panes Number Vertically Main Sash: 3; Panes Number Horizontally Main Sash: 4; Panes Number Vertically 2 Main Sash: 3; Panes Number Horizontally 2 Main Sash: 4; Panes Number Vertically Lower Sash: 1; Panes Number Horizontally Lower Sash: 4; Panes Number Vertically 2 Lower Sash: 1; Panes Number Horizontally 2 Lower Sash: 4; Panes Number Vertically Transom Sash: 1; Panes Number Horizontally Transom Sash: 4; Panes Number Vertically 2 Transom Sash: 1; Panes Number Horizontally 2 Transom Sash: 4; Louvers Style (iLouverStyle): 1; Opening Angle of Louvers: 0 deg; Window Handle: no; Window Handle Type (gs_handle_type_win): Style 1; Window Handle Type (gs_handle_type_win_m): 1; Casing Type Outside (gs_trimtype_out): Simple; Casing Type Outside (gs_trimtype_out_int): 1; Outside Casing Head Type: 1; Architrave Capital: yes; Architrave Capital Type: 1; Outside Bottom Casing: yes; Cover Outer Wall Surface: no; Uniform Casing Widths (gs_trim_outside_uniform): yes; Casing Type Inside (gs_trimtype_in): Simple; Casing Type Inside (gs_trimtype_in_int): 1; Sill (gs_sill_outside): no; Sill Oversize: no; Type of the Sill: 1; Sill Angle: 3 deg; Sill is Curved in Curved Walls: yes; Insulation below Sill: yes; Use Wall Insulation Skin: no; Brick Sill 3D Detail Level: 1; Board (gs_board_inside): no; Board Angle: 0 deg; Board is Curved in Curved Walls: yes; Board in Polygonal Walls: 1; Natural Ventilation: no; Natural Ventilation Type: 2; Main Sash: yes; Lower Sash: no; Transom Sash: no; Sunshade: no; Sunshade Type: 6; Enabled Sunshade Types: 126; Number of Panels: 2; Number of Panels 2: 1; Panel Position (gs_shutter_panelPos): Symmetrical; Panel Position (gs_shutter_iPanelPos): 1; Automatic Shutter Height: yes; Extra Frame: no; Cover Type (gs_slidingShutter_cover): Z-Profile; Cover Type (gs_slidingShutter_iCover): 1; Stacking Direction (gs_foldingShutter_stacking): Inside; Stacking Direction (gs_foldingShutter_iStacking): 1; Open in 3D: yes; 3D Opening Angle: 180 deg; Show 2D Symbol: yes; Show Opening Lines on Symbol: no; Panel Type (gs_shutPanel_type): Style 1; Panel Type (gs_shutPanel_iType): 1; Different Bottom Frame Width: no; Automatic Shutter Width: yes; Louver Angle: 30 deg; Holes Number Horizontal: 5; Holes Number Vertical: 8; Rolling Shutter Placement (gs_shutRoll_placement): Behind Facade; Rolling Shutter Placement (gs_shutRoll_iPlacement): 3; Box Type (gs_shutRoll_boxType): Rectangular; Box Type (gs_shutRoll_iBoxType): 1; Rail Position (gs_shutRoll_railPos): On Casing; Rail Position (gs_shutRoll_iRailPos): 1; Show Casing behind Sunshade (gs_shutRoll_showCasingBehind): no; Insulation behind Box (gs_shutRoll_cutWallBehind): no; Include Height in Wallhole Height: no; Box Top Angle: 10 deg; Box Default Width (gs_shutRoll_boxDefaultSize): To Reveal Width; Box Default Width (gs_shutRoll_iBoxDefaultSize): 1; Venetian Blinds Placement (gs_shutLam_placement): Fixed on Facade; Venetian Blinds Placement (gs_shutLam_iPlacement): 1; Insulation behind Box (gs_shutLam_cutWallBehind): no; Opened Box: yes; Rail: yes; Rail Position (gs_shutLam_railPos): On Casing; Rail Position (gs_shutLam_iRailPos): 1; Show Casing behind Sunshade (gs_shutLam_showCasingBehind): no; Rotation Angle of Slats (gs_shutLam_rotation): 45 deg; Rotation Angle of Slats (gs_shutLam2_rotation): 45 deg; Masonry Arch (bMasonryArch): no; Masonry Arch (gs_masonry_arch_int): 2; Masonry Arch Type (gs_masonry_arch_structure): Stucco Arch; Masonry Arch Type (gs_masonry_arch_structure_int): 1; Arch on Header: yes; Niche below Arch: yes; Skewback Angle: 75 deg; Custom Niche Surface: no; Bottom Reveal Type (gs_reveal_type_bottom): Uniform; Bottom Reveal Type (gs_reveal_type_bottom_int): 1; Outer Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleOuterTypeInt): 0; Inner Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleInnerTypeInt): 0; Uniform Jamb Depth: yes; Angle Side 2: 20 deg; Angle Side: 20 deg; Upper Side Angle: 20 deg; Bottom Side Angle: 20 deg; Use Wall Finish Component: no; Auto Turn Inside Face Plaster: yes; Turn Inside Face Plaster: 0; Auto Turn Outside Face Plaster: yes; Turn Outside Face Plaster: 0; Dimensionable on 2D: no; Show in 3D: no; Closure Type (gs_closure_type): No Closure; Closure Type (gs_closure_type_int): 1; Turn Skin on Side (gs_cavity_side): Both; Turn Skin on Side (iCavityClosureSide): 1; Number of Skins to Turn: 1; Number from (gs_nTurnDir): Outside Face; Number from (iCavityClosureTurnDir): 1; Place Closer on Side 2: yes; Place Closer on Side 1: yes; Place Closer on Top: no; Place Closer on Bottom: no; Place Closer to Skin: 1; Place Closer from Side (gs_cc_dutch_ClosureToSide): 1; Gap at Outside Skin: yes; Turn Skin to Closer: no; Insert Insulation Strip: yes; Show Insulation Strip: yes; Contour Pen (gs_penJoint): Openings - Cut Non-Structural; Contour Line Type (gs_ltJoint): 1; Fill Type (gs_fillJoint): Rigid Insulation; Fill Pen (gs_penJointFg): General - General; Fill Background Pen (gs_penJointBg): 2D Elements - Drafting; Custom Surface: no; Surface: Wood - Pine Grained Horizontal; Contour Pen (gs_penPlug): Openings - Cut Non-Structural; Contour Line Type (gs_ltPlug): 1; Fill Type (gs_fillPlug): Rigid Insulation; Fill Pen (gs_penPlugFg): General - General; Fill Background Pen (gs_penPlugBg): 2D Elements - Drafting; Edited Jamb Side: 1; Edited Wall Side: 1; Edited Skin Number: 1; Turn-in Skin: no; Consider Skin as Plaster: no; Turn-in Thickness: 1; Hatch Orientation: 1; Separating Line at Turn-in: no; Separating Line Pen: General - General; Last Selected Side: no; Closure Method Changed Automatically: no; Connection on the Left: no; Connection on the Right: no; Connection on the Top: no; Connection on the Bottom: no; Wall Inset: no; Wall Inset Sizes (gs_parapet_sizes_st): Automatic; Wall Inset Sizes (iParapetSize): 1; Auto Width and Height Dimensions: yes; Wall Inset Bottom at (gs_parapet_bottom_st): Current Story; Wall Inset Bottom at (iParapetBottom): 1; Show Hidden Parapet: yes; Hidden Parapet Line Type: 1; Opening Angle of Main Sash (openingAngle_01): 0 deg; Opening Angle of Main Sash (openingAngle2_01): 0 deg; Opening Angle of Lower Sash (openingAngle_03): 0 deg; Opening Angle of Lower Sash (openingAngle2_03): 0 deg; Opening Angle of Transom Sash (openingAngle_02): 0 deg; Opening Angle of Transom Sash (openingAngle2_02): 0 deg; Override MVO for 2D Symbolic Display: no; Opening Line Type: 1; Opening Line Shape (or_SwingType): Curved; Opening Line Shape (or_iSwingType): 1; Opening Line Shape (or_iSlidingType): 0; Opening Line Pen in 2D/3D (or_opLinePen): Roofs/Shells - Outlines and Cover Fills; Opening Line Pen in 2D/3D (or_iOpLinePen): 92; Override MVO for 3D Projections: yes; Show Opening Line: yes; Line Type Opening Side (or_opLineType3dIn): Dashed; Line Type Opening Side (or_iOpLineType3dIn): 1; Line Type Opposite Side (or_opLineType3dOut): Dashed; Line Type Opposite Side (or_iOpLineType3dOut): 1; Line Orientation (or_oplineStyle): Handle; Line Orientation (or_iOplineStyle): 1; Cut Line Pen: Openings - Cut Structural; Wall Contour Line (gs_wcont_line): Both Sides; Wall Contour Line (iWallContourLine): 4; Wall Contour Line Type Inside: 1; Wall Contour Line Type Outside: 1; Use Fills: yes; Frame Fill Type: Background; Frame Fill Pen: Openings - Cut Fills; Frame Fill Background Pen: Backgrounds - color 1; Sash Fill Type: Air Space; Sash Fill Pen: Openings - Cut Fills; Sash Fill Background Pen: Backgrounds - color 1; Uncut Fill Type: Background; Uncut Fill Pen: Openings - Cut Fills; Uncut Fill Background Pen: Backgrounds - color 1; Plan Symbol Fill Type: Air Space; Plan Symbol Fill Pen: Transparent; Plan Symbol Fill Background Pen: Transparent; Sill 3D and Uncut Pen: General - General; Sill Section Contour Pen: General - General; Sill Section Fill Type: Air Space; Sill Section Fill Pen: Backgrounds - color 1; Sill Section Fill Bkg. Pen: Backgrounds - color 1; Section Insulation Contour Pen: General - General; Section Insulation Fill Type: Rigid Insulation; Section Insulation Fill Pen: General - General; Section Insulation Fill Background Pen: Backgrounds - color 1; Board 3D and Uncut Pen: General - General; Board Section Contour Pen: General - General; Board Section Fill Type: Air Space; Board Section Fill Pen: Backgrounds - color 1; Board Section Fill Bkg. Pen: Backgrounds - color 1; Casing Fill Type Inside: Air Space; Casing Fill Pen Inside: Backgrounds - color 1; Casing Fill Background Pen Inside: Backgrounds - color 1; Casing Fill Type Outside: Air Space; Casing Fill Pen Outside: Backgrounds - color 1; Casing Fill Background Pen Outside: Backgrounds - color 1; Arch Section Fill Type: Background; Arch Section Fill Pen: Backgrounds - color 1; Arch Section Fill Bkg. Pen: Backgrounds - color 1; Ventilation Profile Section Fill Type: Air Space; Ventilation Profile Section Fill Pen: Backgrounds - color 1; Ventilation Profile Section Fill Background Pen: Backgrounds - color 1; Sunshade Symbol Line Type: 1; Sunshade Cut Line Pen: General - General; 3D/Section Uncut Line Pen: General - General; Sunshade Cut Fill Type: Background; Sunshade Cut Fill Pen: General - General; Sunshade Cut Fill Background Pen: Window Background; Sunshade Insulation Fill Type: Batt Insulation; Sunshade Insulation Fill Pen: General - General; Sunshade Insulation Background Pen: Window Background; Frame Element Joinery: 2; Frame Pen: Openings - General; Sash Pen: Openings - General; Glass Pen: Openings - Cut Non-Structural; Masonry Arch Pen: Walls/Curtain Walls - General; Shadow: yes; Uniform Window Surfaces: yes; Frame Outside: Metal - Aluminium; Frame Inside: Metal - Aluminium; Sash Outside: Metal - Aluminium; Sash Inside: Metal - Aluminium; Louvers: Wood - Pine Grained Horizontal; Glass: Glass - Clear Fast; Grid Outside: Metal - Aluminium; Grid Inside: Metal - Aluminium; Solid Panel Outside: Metal - Aluminium; Solid Panel Inside: Metal - Aluminium; Handle: Metal - Stainless Steel; Uniform Casing Surfaces: yes; Interior Casing: Wood - Pine Grained Horizontal; Exterior Casing: Wood - Pine Grained Horizontal; Ventilation Profile: Metal - Aluminium; Shutter Panel: Wood - Pine Grained Horizontal; Shutter Panel Frame: Wood - Pine Grained Horizontal; Rolling Shutter Box: Metal - Stainless Steel; Rolling Shutter Blades: Paint - Glossy White; Rolling Shutter Rail: Paint - Glossy White; Venetian Blinds Box: Metal - Stainless Steel; Venetian Blinds Segments: Paint - Glossy White; Sliding Shutter Rail: Metal - Stainless Steel; Sill (gs_sill_mat): Wood - Pine Grained Horizontal; Brick Sill Mortar: Stucco - White Rough; Board (gs_board_mat): Wood - Pine Grained Horizontal; Masonry Arch Brick: Brick - Running Bond; Masonry Arch Mortar: Stucco - White Rough; Masonry Arch Keystone: Stone - Sandstone 01; Niche: Paint - Lead Oxide Yellow; Corner Column Surface: Wood - Pine Grained Horizontal; Display as Transom: no; Wall End Line Pen: General - General; Wall End Line Line Type: 21; Head Depth on Symbol: no; Head Depth Symbol Line Type: 21; Head Depth Symbol Pen: Annotation Text - General; Window belongs to the Zone into which it opens: no; Cost: 0; Total Glazed Area (gs_list_glassarea_tmp): 0; Override Glazed Area: no; Total Glass Perimeter: 0; Free Air Performance (mm2/l/m): 0; Group Type (FM_Type): Default Objects; Group Type (iFMType): 1; Object Weight: 0; Object Weight Unit: kg; Window Orientation Definition: 0; IFC Operation (ifc_optypestr): Single; IFC Operation (ifc_optype): 1; Shutter Opening Angle: 180 deg; Opening Line Style: 1
AC_Equantity_Window_27 - Z Dimension: 1 m; Bottom Level: 1 m; Top Level: 0 m; New Wall Fill Width Right: 0.15 m; New Wall Fill Width Left: 0.15 m; Connecting Wall Thickness: 0 m; Corner Column Width: 0 m; Corner Column Thickness: 0 m; Corner Column Projection: 0 m; Maximal Tolerance: 0.1 m; Tolerance: 0 m; Tolerance Left: 0 m; Tolerance Right: 0 m; Tolerance Upper: 0 m; Tolerance Lower: 0 m; Side Pane Width: 0 m; Frame Thickness: 0.05 m; Frame Width: 0.035 m; Frame Width Side 2: 0.05 m; Upper Frame Width: 0.035 m; Bottom Frame Width: 0.05 m; Rebate Depth: 0.025 m; Rebate Width: 0.025 m; Upper Division Width: 0.1 m; Height of Upper Horiz. Divisions: 0.16 m; Lower Division Width: 0.1 m; Height of Lower Horiz. Divisions: 0.16 m; Mullion Width Side 1: 0.1 m; Mullion Width Side 2: 0.1 m; Horizontal Division Height Main Sash: 0.16 m; Horizontal Division Height Lower Sash: 0.9 m; Horizontal Division Height Transom Sash: 0.9 m; Sash Frame Thickness: 0.04 m; Sash Frame Width: 0.05 m; Grill Width: 0.02 m; Grill Thickness: 0.025 m; Glass Thickness: 0.02 m; Louvers Thickness: 0.01 m; Louvers Width: 0.05 m; Left Opening Oversize: 0 m; Right Opening Oversize: 0 m; Upper Opening Oversize: 0 m; Lower Opening Oversize: 0 m; Architrave Capital Width: 0.02 m; Width Side 1 (gs_tw_right_out): 0.1 m; Width Side 2 (gs_tw_left_out): 0.1 m; Width Top (gs_tw_top_out): 0.1 m; Width Bottom (gs_tw_bottom_out): 0.1 m; Thickness on Wall (gs_trim_thk_out): 0.025 m; Thickness in Wallhole (gs_trim_width_out): 0.005 m; Offset (gs_trim_offs_out): 0 m; Top Overhang (gs_trimov_top_left_out): 0.1 m; Top Overhang (gs_trimov_top_right_out): 0.1 m; Bottom Overhang (gs_trimov_bot_left_out): 0.1 m; Bottom Overhang (gs_trimov_bot_right_out): 0.1 m; Bottom Overhang (casingOverhangBottomSideOut): 0.05 m; Width Side 1 (gs_tw_right_in): 0.1 m; Width Side 2 (gs_tw_left_in): 0.1 m; Width Top (gs_tw_top_in): 0.1 m; Width Bottom (gs_tw_bottom_in): 0.1 m; Thickness on Wall (gs_trim_thk_in): 0.025 m; Offset (gs_trim_offs_in): 0 m; Top Overhang (gs_trimov_top_left_in): 0.1 m; Top Overhang (gs_trimov_top_right_in): 0.1 m; Bottom Overhang (gs_trimov_bot_left_in): 0.1 m; Bottom Overhang (gs_trimov_bot_right_in): 0.1 m; Width of Sill: 0 m; Sill Top Width: 0.01 m; Sill Top Height: 0.01 m; Sill Thickness: 0.025 m; Sill Front Side Thickness: 0.015 m; Sill Elevation: 0.005 m; Sill Drip Overlap: 0.02 m; Sill Drip Width: 0.03 m; Sill Nosing: 0.03 m; Sill Overhang Left: 0 m; Sill Overhang Right: 0 m; Sill Slip-in Depth: 0.02 m; Sill Slip from Wall: 0 m; Rear Hole Depth (gs_sill_holeDepthBehind): 0 m; Brick Thickness (gs_brick_sill_br_thk): 0.065 m; Mortar Thickness (gs_brick_sill_mort_thk): 0.015 m; Board Thickness: 0.025 m; Board Nosing: 0.03 m; Board Overhang Left: 0 m; Board Overhang Right: 0 m; Board Slip-in Depth: 0 m; Profile Height: 0.065 m; Profile Thickness: 0.11 m; Panel Height: 1.71 m; Inner Offset: 0.02 m; Closing Depth: 0 m; Extra Frame Width: 0.04 m; Extra Frame Thickness: 0.03 m; Rail Width: 0.03 m; Hanging Stick Length: 0.02 m; Hanging Stick Radius: 0.005 m; Panel Distance: 0.006 m; Outside Overhang: 0 m; Inner Panel Width: 0.12 m; 3D Opening Length: 1.5 m; 3D Closed Length: 0 m; 3D Opening Length 1 (gs_shutter_opLength_1): 0.56 m; 3D Opening Length 1 (gs_shutter_opLength_2): 0.14 m; 3D Opening Height: 1.5 m; 3D Closed Height: 0 m; Panel Thickness: 0.05 m; Panel Frame Width: 0.05 m; Frame Width Bottom: 0.05 m; Panel Width: 0.6 m; Panel Fill Thickness: 0.01 m; Louver Thickness: 0.01 m; Louver Width: 0.04 m; Horizontal Frame Divider Width: 0.05 m; Vertical Frame Divider Width: 0.05 m; Hole Radius: 0.01 m; Vertical Board Width: 0.1 m; Z Frame Width: 0.05 m; Z Frame Thickness: 0.025 m; Vertical Boards Thickness: 0.025 m; Horizontal Boards Thickness: 0.025 m; Vertical Boards Approximate Width: 0.08 m; Horizontal Boards Approximate Width: 0.115 m; Box Height (gs_shutRoll_boxHeight): 0.2 m; Box Depth (gs_shutRoll_boxWidth): 0.15 m; Box Left Offset: 0 m; Box Right Offset: 0 m; Depth of Rails: 0 m; Distance from Wall (gs_shutRoll_distFromWall): 0 m; Distance from Header (gs_shutRoll_distFromHead): 0 m; Slat Width: 0.05 m; Box Height (gs_shutLam_boxHeight): 0.2 m; Box Depth (gs_shutLam_boxWidth): 0.15 m; Cover Width: 0 m; Distance from Wall (gs_shutLam_distFromWall): 0 m; Distance from Header (gs_shutLam_distFromHead): 0 m; Segment Width (gs_shutLam_segmentWidth): 0.06 m; Box Height (gs_shutLam2_boxHeight): 0.06 m; Box Width: 0.06 m; Distance from Window: 0.06 m; Distance from Header (gs_shutLam2_distFromHead): 0.06 m; Box Axis Height from Header: 0 m; Segment Width (gs_shutLam2_segmentWidth): 0.06 m; Distance between Arch and Window: 0 m; Masonry Arch Overhang Left: 0 m; Masonry Arch Overhang Right: 0 m; Masonry Arch Rise: 0.03 m; Masonry Arch Projection: 0 m; Masonry Arch Height: 0.25 m; Masonry Arch Depth: 0.12 m; Rear Hole Depth (gs_masonry_arch_rearHoleDepth): 0 m; Brick Thickness (gs_masonry_arch_brick_thk): 0.065 m; Mortar Thickness (gs_masonry_arch_mort_thk): 0.01 m; Keystone Width: 0.1 m; Keystone Oversize: 0 m; Keystone Projection: 0.01 m; Jamb Depth Side 2: 0.06 m; Jamb Depth: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_splayed_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_splayed_innerRight): 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_double_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_double_innerRight): 0.06 m; Head Jamb Depth: 0.06 m; Sill Jamb Depth: 0.06 m; Inner Head Depth (gs_reveal_splayed_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_splayed_innerBottom): 0.06 m; Inner Head Depth (gs_reveal_double_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_double_innerBottom): 0.06 m; Outer Jamb Depth: 0.08 m; Plaster Thickness Limit: 0.04 m; Distance of Skin from Closer: 0 m; Closer Width: 0.038 m; Closer Thickness: 0.1 m; Strip Thickness: 0.025 m; Profile Width: 0.075 m; Custom Thickness: 0.015 m; Skin Overhang to Frame Depth: 0 m; Depth of Inset: 0.05 m; Parapet Width: 1 m; Overhang Side 1: 0 m; Overhang Side 2: 0 m; Parapet Height: 0.9 m; Bottom Overhang (gs_parapet_botelev): 0 m; Opening Distance 1 Main Sash: 0 m; Opening Distance 2 Main Sash: 0 m; Opening Distance 1 Lower Sash: 0 m; Opening Distance 2 Lower Sash: 0 m; Opening Distance 1 Transom Sash: 0 m; Opening Distance 2 Transom Sash: 0 m; Opening Length in 2D: 0 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
Name | Reveal Dimensions = Wallhole Dimensions = Unit Dimensions = Nominal W x H Size | Nominal W x H x T Size | Wall Structure | Marker Text | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Colliding Zones | Home Story Name = 115.AMB.Nivell | Home Story Number = Wall Contours (0-None,1-Full,2-Side,3-Length) | Parent ID | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_107.NomTipus | W/D Opening Opening Volume (m3) | W/D Opening Nominal Volume (m3) | W/D Opening Surface Area (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | W/D Opening Nominal Surface Area (m2) = W/D Opening Surface Area on the Reveal Side (m2) = W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | W/D Opening Width on the Reveal Side (m) = W/D Opening Width on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Width on the Reveal Side (m) = Nominal W/D Opening Width on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Width (m) = AC_Equantity_Window_27, Width (m) = Wallhole Width (m) = Reveal Width (m) = Unit Width (m) = 502.AMB.Amplada (m) | W/D Opening Height on the Reveal Side (m) = W/D Opening Height on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Height on the Reveal Side (m) = Nominal W/D Opening Height on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Height (m) = AC_Equantity_Window_27, Height (m) = Wallhole Height (m) = Reveal Height (m) = Unit Height (m) = 503.AMB.Altura (m) | Sill/Header Value (m) = W/D Nominal Sill Height (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) = Sill Height to Current Story (m) | W/D Sill Height on the Reveal Side (m) = W/D Sill Height on the Side Opposite to the Reveal Side (m) | W/D Nominal Head Height (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | W/D Head Height on the Reveal Side (m) = W/D Head Height on the Side Opposite to the Reveal Side (m) | Wall Thickness (m) = Connected Wall Thickness 2 (m) = Connected Wall Thickness 1 (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Elevation to Linked/Home Story (m) | Top Elevation To Sea Level (m) | Floor Plan Display Option | Wall Direction Type | Reveal Anchor Position | Opening Type Main Sash | Opening Type (gs_optype_m_01) | Casing Outside = Cover Inner Wall Surface = Uniform Casing Widths (gs_trim_inside_uniform) | Casing Inside | Reveal Type (gs_reveal_type_new) | Reveal Type (gs_reveal_type_int) | Opening Angle in 2D (deg) | Uncut Line Pen = Casing Cut Line Pen on Both Sides = Wall Contour Line Pen | Hidden Wall Contour Line Type Inside = Hidden Wall Contour Line Type Outside | Opening Direction | Total Glazed Area (gs_list_glassarea) | Reveal to Wall Core (m) = Reveal Depth (gs_wido_sill) (m) = Reveal Depth (AC_wido_sill) (m) | Middle Pane Width (m) | Nosing (gs_trim_jambext_nosing_out) (m) | Thickness in Wallhole (gs_trim_width_in) (m) | Nosing (gs_trim_jambext_nosing_in) (m) | Board Width (m)
V013 | 929,7×1.708,0 | 929,7×1.708,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V013 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V013_FinestraTipusC | Finestra oscil·lan | Nau Santa Eulalia | FinestraTipusC | 0.254062 | 0.254062 | 5.32726 | 1.58789 | 0.929675 | 1.708 | 1.63947 | 1.26947 | 3.34747 | 2.97747 | 0.16 | 0.0126656 | 10.9795 | 1.63947 | 12.6875 | 3 | 0 | 2 | Fixed Glass | 1 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 1.40815 | 0.11 | 0.464838 | 0.03 | 0.025 | 0.05 | 0.03
V018 | 929,7×1.708,0 | 929,7×1.708,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V018 | Nau Santa Eulàlia | planta baixa | 0 | F6 | V018_FinestraTipusC | Finestra oscil·lan | Nau Santa Eulalia | FinestraTipusC | 0.254062 | 0.254062 | 5.32726 | 1.58789 | 0.929675 | 1.708 | 1.63947 | 1.26947 | 3.34747 | 2.97747 | 0.16 | 0.0126656 | 10.9795 | 1.63947 | 12.6875 | 3 | 0 | 2 | Fixed Glass | 1 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 1.40815 | 0.11 | 0.464838 | 0.03 | 0.025 | 0.05 | 0.03
V022 | 542,7×1.549,0 | 542,7×1.549,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V022 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V022_FinestraTipusE | Finestra practicable | Nau Santa Eulalia | FinestraTipusE | 0.134495 | 0.134495 | 3.90938 | 0.840591 | 0.542667 | 1.549 | 1.72847 | 1.35847 | 3.27747 | 2.90747 | 0.16 | 0.0152948 | 11.0685 | 1.72847 | 12.6175 | 3 | 0 | 1 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.603991 | 0.11 | 0.271334 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V023 | 301,7×874,0 | 301,7×874,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V023 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V023_FinestraTipusD | Finestra fixa | Nau Santa Eulalia | FinestraTipusD | 0.0421903 | 0.0421903 | 1.48006 | 0.263689 | 0.301704 | 0.874 | 2.40347 | 2.03347 | 3.27747 | 2.90747 | 0.16 | 0.00550195 | 11.7435 | 2.40347 | 12.6175 | 3 | 0 | 1 | Fixed Glass | 1 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 0.18629 | 0.11 | 0.150852 | 0.03 | 0.025 | 0.05 | 0.03
V102 | 527,9×938,2 | 527,9×938,2×165,0 | Tr1 Plywood | <Custom Text> | V102 | Nau Annexa | planta coberta | 1 | F3 | V102_FinestraTipusF | Finestra doble oscil·lan | Annex | FinestraTipusF | 0.0817277 | 0.0817278 | 2.12391 | 0.49532 | 0.527944 | 0.938204 | 4.06081 | 2.96081 | 4.99902 | 3.89902 | 0.165 | 0.00946111 | 13.4008 | -0.439186 | 14.339 | 1 | 0 | 2 | Bottom Hung | 7 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 0.333782 | 0.068 | 0.263972 | 0 | 0.025 | 0.05 | 0.077
V102 | 527,9×938,2 | 527,9×938,2×165,0 | Tr1 Plywood | <Custom Text> | V102 | Nau Annexa | planta coberta | 1 | F3 | V102_FinestraTipusF | Finestra doble oscil·lan | Annex | FinestraTipusF | 0.0817278 | 0.0817278 | 2.12391 | 0.49532 | 0.527944 | 0.938204 | 4.06081 | 2.96081 | 4.99902 | 3.89902 | 0.165 | 0.00946111 | 13.4008 | -0.439186 | 14.339 | 1 | 0 | 2 | Bottom Hung | 7 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 0.333782 | 0.068 | 0.263972 | 0 | 0.025 | 0.05 | 0.077
V019 | 929,7×1.708,0 | 929,7×1.708,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V019 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V019_FinestraTipusC | Finestra oscil·lan | Nau Santa Eulalia | FinestraTipusC | 0.254062 | 0.254062 | 5.32726 | 1.58789 | 0.929675 | 1.708 | 1.63947 | 1.26947 | 3.34747 | 2.97747 | 0.16 | 0.0126656 | 10.9795 | 1.63947 | 12.6875 | 3 | 0 | 2 | Fixed Glass | 1 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 1.40815 | 0.11 | 0.464838 | 0.03 | 0.025 | 0.05 | 0.03
V024 | 929,7×1.708,0 | 929,7×1.708,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V024 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V024_FinestraTipusC | Finestra oscil·lan | Nau Santa Eulalia | FinestraTipusC | 0.254062 | 0.254062 | 5.32726 | 1.58789 | 0.929675 | 1.708 | 1.63947 | 1.26947 | 3.34747 | 2.97747 | 0.16 | 0.0126656 | 10.9795 | 1.63947 | 12.6875 | 3 | 0 | 2 | Fixed Glass | 1 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 1.40815 | 0.11 | 0.464838 | 0.03 | 0.025 | 0.05 | 0.03
2 x V001 | 452,6×1.833,4 | 452,6×1.833,4×160,0 | Concrete 40-20 (2) |  | V001 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V001_FinestraTipusA | Finestra triple. 2 practicables, 1 fixa | Nau Santa Eulalia | FinestraTipusA | 0.132782 | 0.132782 | 4.09794 | 0.82989 | 0.452644 | 1.83343 | 1.49422 | 1.12422 | 3.32765 | 2.95765 | 0.16 | 0.0167819 | 10.8342 | 1.49422 | 12.6676 | 3 | 1 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.569961 | 0.11 | 0.226322 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V002 | 550,0×1.833,4 | 550,0×1.833,4×160,0 | Concrete 40-20 (2) |  | V002 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V002_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161341 | 0.161341 | 4.56007 | 1.00838 | 0.55 | 1.83343 | 1.49138 | 1.12138 | 3.32481 | 2.95481 | 0.16 | 0.0175267 | 10.8314 | 1.49138 | 12.6648 | 3 | 1 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.736772 | 0.11 | 0.275 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V003 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) | <Custom Text> | V003 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V003_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.736038 | 0.11 | 0.275 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V002 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) | <Custom Text> | V002 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V002_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.736038 | 0.11 | 0.275 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V004 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) | <Custom Text> | V004 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V004_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.736038 | 0.11 | 0.275 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V003 | 550,0×1.833,4 | 550,0×1.833,4×160,0 | Concrete 40-20 (2) |  | V003 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V003_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161341 | 0.161341 | 4.56007 | 1.00838 | 0.55 | 1.83343 | 1.49138 | 1.12138 | 3.32481 | 2.95481 | 0.16 | 0.0175267 | 10.8314 | 1.49138 | 12.6648 | 3 | 1 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.736772 | 0.11 | 0.275 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V004 | 550,0×1.833,4 | 550,0×1.833,4×160,0 | Concrete 40-20 (2) |  | V004 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V004_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161341 | 0.161341 | 4.56007 | 1.00838 | 0.55 | 1.83343 | 1.49138 | 1.12138 | 3.32481 | 2.95481 | 0.16 | 0.0175267 | 10.8314 | 1.49138 | 12.6648 | 3 | 1 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.736772 | 0.11 | 0.275 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V005 | 550,0×1.833,4 | 550,0×1.833,4×160,0 | Concrete 40-20 (2) |  | V005 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V005_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161341 | 0.161341 | 4.56007 | 1.00838 | 0.55 | 1.83343 | 1.49138 | 1.12138 | 3.32481 | 2.95481 | 0.16 | 0.0175267 | 10.8314 | 1.49138 | 12.6648 | 3 | 1 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.736772 | 0.11 | 0.275 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
2 x V006 | 452,6×1.833,4 | 452,6×1.833,4×160,0 | Concrete 40-20 (2) |  | V006 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V006_FinestraTipusA | Finestra triple. 2 practicables, 1 fixa | Nau Santa Eulalia | FinestraTipusA | 0.132782 | 0.132782 | 4.09794 | 0.82989 | 0.452644 | 1.83343 | 1.49422 | 1.12422 | 3.32765 | 2.95765 | 0.16 | 0.0167819 | 10.8342 | 1.49422 | 12.6676 | 3 | 1 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.569961 | 0.11 | 0.226322 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V006 | 452,6×861,6 | 452,6×861,6×160,0 | Concrete 40-20 (2) | <Custom Text> | V006 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V006_FinestraTipusA | Finestra triple. 2 practicables, 1 fixa | Nau Santa Eulalia | FinestraTipusA | 0.0623982 | 0.0623982 | 1.84624 | 0.389989 | 0.452644 | 0.861579 | 2.46436 | 2.09436 | 3.32594 | 2.95594 | 0.16 | 0.0061807 | 11.8044 | 2.46436 | 12.6659 | 3 | 1 | 2 | Fixed Glass | 1 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 0.302893 | 0.11 | 0.226322 | 0.03 | 0.025 | 0.05 | 0.03
V001 | 452,6×861,6 | 452,6×861,6×160,0 | Concrete 40-20 (2) | <Custom Text> | V001 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V001_FinestraTipusA | Finestra triple. 2 practicables, 1 fixa | Nau Santa Eulalia | FinestraTipusA | 0.0623982 | 0.0623982 | 1.84624 | 0.389989 | 0.452644 | 0.861579 | 2.46436 | 2.09436 | 3.32594 | 2.95594 | 0.16 | 0.0061807 | 11.8044 | 2.46436 | 12.6659 | 3 | 1 | 2 | Fixed Glass | 1 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 0.302893 | 0.11 | 0.226322 | 0.03 | 0.025 | 0.05 | 0.03
V005 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) | <Custom Text> | V005 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V005_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.736038 | 0.11 | 0.275 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V020 | 300,0×874,0 | 300,0×874,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V020 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V020_FinestraTipusD | Finestra fixa | Nau Santa Eulalia | FinestraTipusD | 0.0419492 | 0.0419492 | 1.47563 | 0.262182 | 0.29998 | 0.874 | 2.40347 | 2.03347 | 3.27747 | 2.90747 | 0.16 | 0.0054935 | 11.7435 | 2.40347 | 12.6175 | 3 | 0 | 1 | Fixed Glass | 1 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 0.184904 | 0.11 | 0.14999 | 0.03 | 0.025 | 0.05 | 0.03
V021 | 542,7×1.549,0 | 542,7×1.549,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V021 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V021_FinestraTipusE | Finestra practicable | Nau Santa Eulalia | FinestraTipusE | 0.134495 | 0.134495 | 3.90938 | 0.840591 | 0.542667 | 1.549 | 1.72847 | 1.35847 | 3.27747 | 2.90747 | 0.16 | 0.0152948 | 11.0685 | 1.72847 | 12.6175 | 3 | 0 | 1 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.603991 | 0.11 | 0.271334 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: R; AC_Pset_Window_27 - Window Orientation: R
V017 | 301,7×874,0 | 301,7×874,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V017 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V017_FinestraTipusD | Finestra fixa | Nau Santa Eulalia | FinestraTipusD | 0.0421903 | 0.0421903 | 1.48006 | 0.263689 | 0.301704 | 0.874 | 2.40347 | 2.03347 | 3.27747 | 2.90747 | 0.16 | 0.00550195 | 11.7435 | 2.40347 | 12.6175 | 3 | 0 | 2 | Fixed Glass | 1 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 0.18629 | 0.11 | 0.150852 | 0.03 | 0.025 | 0.05 | 0.03
V016 | 548,0×1.542,5 | 548,0×1.542,5×160,0 | Concrete 40-20 (2) | <Custom Text> | V016 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V016_FinestraTipusE | Finestra practicable | Nau Santa Eulalia | FinestraTipusE | 0.135243 | 0.135243 | 3.91743 | 0.845268 | 0.547999 | 1.54246 | 1.72847 | 1.35847 | 3.27093 | 2.90093 | 0.16 | 0.0152855 | 11.0685 | 1.72847 | 12.6109 | 3 | 0 | 1 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.608813 | 0.11 | 0.274 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: L; AC_Pset_Window_27 - Window Orientation: L
V015 | 546,7×1.478,0 | 546,7×1.478,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V015 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V015_FinestraTipusE | Finestra practicable | Nau Santa Eulalia | FinestraTipusE | 0.12929 | 0.12929 | 3.77203 | 0.808061 | 0.546726 | 1.478 | 1.79947 | 1.42947 | 3.27747 | 2.90747 | 0.16 | 0.0147827 | 11.1395 | 1.79947 | 12.6175 | 3 | 0 | 2 | Side Hung | 3 | yes | no | No Reveal | 2 | 40 | Objects - General | 21 | 0 | 0.579494 | 0.11 | 0.273363 | 0.03 | 0.025 | 0.05 | 0.03 | ArchiCADProperties - Orientation: L; AC_Pset_Window_27 - Window Orientation: L
V014 | 318,1×874,0 | 318,1×874,0×160,0 | Concrete 40-20 (2) | <Custom Text> | V014 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V014_FinestraTipusD | Finestra fixa | Nau Santa Eulalia | FinestraTipusD | 0.0444868 | 0.0444868 | 1.52223 | 0.278043 | 0.318126 | 0.874 | 2.40347 | 2.03347 | 3.27747 | 2.90747 | 0.16 | 0.00558242 | 11.7435 | 2.40347 | 12.6175 | 3 | 0 | 2 | Fixed Glass | 1 | yes | no | No Reveal | 2 | 30 | Openings - General | 1 | 0 | 0.199494 | 0.11 | 0.159063 | 0.03 | 0.025 | 0.05 | 0.03
2 x V007 | 452,6×1.831,7 | 452,6×1.831,7×160,0 | Concrete 40-20 (2) |  | V007 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V007_FinestraTipusA | Finestra triple. 2 practicables, 1 fixa | Nau Santa Eulalia | FinestraTipusA | 0.132659 | 0.132659 | 4.09454 | 0.829117 | 0.452644 | 1.83172 | 1.49422 | 1.12422 | 3.32594 | 2.95594 | 0.16 | 0.0167689 | 10.8342 | 1.49422 | 12.6659 | 3 | 1 | 2 | Bottom Hung | 7 | no | yes | No Reveal - Edge | 1 | 40 | Objects - General | 21 | 1 | 0.569393 | 0 | 0.226322 | 0.03 | 0.005 | 0.03 | 0.14
2 x V012 | 452,6×1.831,7 | 452,6×1.831,7×160,0 | Concrete 40-20 (2) |  | V012 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V012_FinestraTipusA | Finestra triple. 2 practicables, 1 fixa | Nau Santa Eulalia | FinestraTipusA | 0.132659 | 0.132659 | 4.09454 | 0.829117 | 0.452644 | 1.83172 | 1.49422 | 1.12422 | 3.32594 | 2.95594 | 0.16 | 0.0167689 | 10.8342 | 1.49422 | 12.6659 | 3 | 1 | 2 | Bottom Hung | 7 | no | yes | No Reveal - Edge | 1 | 40 | Objects - General | 21 | 1 | 0.569393 | 0 | 0.226322 | 0.03 | 0.005 | 0.03 | 0.14
V012 | 452,6×861,6 | 452,6×861,6×160,0 | Concrete 40-20 (2) | <Custom Text> | V012 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V012_FinestraTipusA | Finestra triple. 2 practicables, 1 fixa | Nau Santa Eulalia | FinestraTipusA | 0.0623982 | 0.0623982 | 1.84624 | 0.389989 | 0.452644 | 0.861579 | 2.46436 | 2.09436 | 3.32594 | 2.95594 | 0.16 | 0.0061807 | 11.8044 | 2.46436 | 12.6659 | 3 | 1 | 2 | Fixed Glass | 1 | no | yes | No Reveal - Edge | 1 | 30 | Openings - General | 1 | 1 | 0.302893 | 0 | 0.226322 | 0.03 | 0.005 | 0.03 | 0.14
V007 | 457,9×861,6 | 457,9×861,6×160,0 | Concrete 40-20 (2) | <Custom Text> | V007 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V007_FinestraTipusA | Finestra triple. 2 practicables, 1 fixa | Nau Santa Eulalia | FinestraTipusA | 0.0631273 | 0.0631273 | 1.85969 | 0.394546 | 0.457933 | 0.861579 | 2.46436 | 2.09436 | 3.32594 | 2.95594 | 0.16 | 0.00620661 | 11.8044 | 2.46436 | 12.6659 | 3 | 1 | 2 | Fixed Glass | 1 | no | yes | No Reveal - Edge | 1 | 30 | Openings - General | 1 | 1 | 0.30708 | 0 | 0.228966 | 0.03 | 0.005 | 0.03 | 0.14
V008 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) |  | V008 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V008_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Bottom Hung | 7 | no | yes | No Reveal - Edge | 1 | 40 | Objects - General | 21 | 1 | 0.736038 | 0 | 0.275 | 0.03 | 0.005 | 0.03 | 0.14
V009 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) | <Custom Text> | V009 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V009_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Bottom Hung | 7 | no | yes | No Reveal - Edge | 1 | 40 | Objects - General | 21 | 1 | 0.736038 | 0 | 0.275 | 0.03 | 0.005 | 0.03 | 0.14
V009 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) |  | V009 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V009_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Bottom Hung | 7 | no | yes | No Reveal - Edge | 1 | 40 | Objects - General | 21 | 1 | 0.736038 | 0 | 0.275 | 0.03 | 0.005 | 0.03 | 0.14
V008 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) | <Custom Text> | V008 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V008_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Bottom Hung | 7 | no | yes | No Reveal - Edge | 1 | 40 | Objects - General | 21 | 1 | 0.736038 | 0 | 0.275 | 0.03 | 0.005 | 0.03 | 0.14
V010 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) |  | V010 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V010_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Bottom Hung | 7 | no | yes | No Reveal - Edge | 1 | 40 | Objects - General | 21 | 1 | 0.736038 | 0 | 0.275 | 0.03 | 0.005 | 0.03 | 0.14
V010 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) | <Custom Text> | V010 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V010_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Bottom Hung | 7 | no | yes | No Reveal - Edge | 1 | 40 | Objects - General | 21 | 1 | 0.736038 | 0 | 0.275 | 0.03 | 0.005 | 0.03 | 0.14
V011 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) | <Custom Text> | V011 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V011_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Bottom Hung | 7 | no | yes | No Reveal - Edge | 1 | 40 | Objects - General | 21 | 1 | 0.736038 | 0 | 0.275 | 0.03 | 0.005 | 0.03 | 0.14
V011 | 550,0×1.831,7 | 550,0×1.831,7×160,0 | Concrete 40-20 (2) |  | V011 | Nau Santa Eulàlia | planta baixa | 0 | F1 | V011_FinestraTipusB | Finestra doble. 2 practicables | Nau Santa Eulalia | FinestraTipusB | 0.161191 | 0.161191 | 4.55634 | 1.00744 | 0.549999 | 1.83172 | 1.49138 | 1.12138 | 3.3231 | 2.9531 | 0.16 | 0.0175136 | 10.8314 | 1.49138 | 12.6631 | 3 | 1 | 2 | Bottom Hung | 7 | no | yes | No Reveal - Edge | 1 | 40 | Objects - General | 21 | 1 | 0.736038 | 0 | 0.275 | 0.03 | 0.005 | 0.03 | 0.14

# IfcBuildingElementProxy: Windows_Roof-Windows_FAKRO_Flat-roof-access-door-DRL+Loft-ladders-LML_max-room-height-2.8m, L2
In: planta baixa
Classification: 30.20.10.30 Sistemes especials de cobertes (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 103.615 deg; Surface: Paint - Anthracite; Element ID: L2; Hotlink and Element ID: L2; Layer: 00_TRAMPILLA; Library Part Name: Windows_Roof-Windows_FAKRO_Flat-roof-access-door-DRL+Loft-ladders-LML_max-room-height-2.8m; Building Material / Composite / Profile / Fill: Air Space; Fill Type: Air Space; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: L2; Surfaces (All): Paint - Anthracite; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Windows_Roof-Windows_FAKRO_Flat-roof-access-door-DRL+Loft-ladders-LML_max-room-height-2.8m - Show 2D Hotspots in 3D: no; Edge Snapping: yes; Detail Level: 2; Enable Stretching: yes; Rotation Angle (x axis): 1; Custom Angle: 0 deg; Projection Line Pen: Roofs/Shells - Outlines and Cover Fills; Fill Type: Air Space; Fill Pen: Transparent; Fill Background Pen: Transparent; Override Surface: Plastic - FAKRO - RAL9003 - Frame PVC: no; Override Surface: Pinewood - FAKRO - RAL1013 - Box: no; Override Surface: Aluminium - FAKRO - RAL9006 - Actuators: no; Override Surface: None: no; Override Surface: Aluminium - FAKRO - RAL9003 - Handle: no; Override Surface: Aluminium - FAKRO - RAL7022 - Flashing: no; Override Surface: Rubber - FAKRO - RAL9005 - Seal: no; Assembly Code: C2010130; Brand url: http://www.fakro.com/; Description: Metal folding section loft ladders; Design country: Poland; DRL - Air permeability: -; DRL - External fire performance: -; DRL - Impact resistance: -; DRL - Isolation thermique de châssis Uf [W/m²K]: -; DRL - Length with base: 1650; DRL - Load-bearing capacity of safety device: -; DRL - Max window opening angle: 0.00°; DRL - Reaction to fire: -; DRL - Resistance to snow load: -; DRL - Resistance to wind load: -; DRL - Roof angle: -; DRL - Thermal insulation of frame and glazing connection (psi) [W/mK]: -; DRL - Watertightness / unshielded (A): -; DRL - Width with base: 810; DRL - Window acoustic performance Rw [dB]: -; DRL - Window heat transfer coefficient (for dimension window 92x130 cm) Uw [W/m²K]: 0; Edition number: 1; Family Category: Windows; Folded ladder: True; Harmonised technical specification: -; Installation instructions DRL: https://www.fakro.com/att/COMMON/prof/roofer/fitting%20instructions/DRL_FAKRO.pdf; Installation instructions LML: https://www.fakro.com/att/COMMON/prof/roofer/fitting%20instructions/LML_FAKRO.pdf; Length opening: 1200; LML - Box: -; LML - Box height: 0; LML - Distance after ladder unfolding: 0; LML - Distance between treads: 0; LML - Folded ladder height: 0; LML - Hatch colour: -; LML - Hatch thickness: 0; LML - Heat transfer coefficient (ladder) U [W/m²K]: 0; LML - Internal box dimension: -; LML - Ladder: -; LML - Permissible loading: 0.00 kg; LML - Tread length in the ladder: 0; LML - Tread width in the ladder: 0; LML - Treads: -; Manufacturer: FAKRO; Manufacturer country: Poland; Manufacturer name: FAKRO; Material main: Steel; Material secondary: PVC; Max Room height: 2800; Min Room height: 2330; Model: DRL + LML; Nominal height: 0; Nominal length: 0; Nominal width: 0; Obj Type: 1; Product data url: http://bimobject.com/fakro/product/flat_roof_access_door_drl_lml; Product family: Roof access; Product group: Flat roof access; Product SKU: flat_roof_access_door_drl_lml; Product url: http://www.fakro.com/flat-roof-windows/access-door/; QR code: http://bimobject.com/fakro/product/flat_roof_access_door_drl_lml; Region Africa: All; Region Antarctica: All; Region Asia: All; Region Europe: All; Region Middle East: All; Region North America: All; Region Oceania: All; Region South America: All; Room height: 2800; Room_height: 2800; Swing space: 1670; Technical description: http://www.fakro.com/offer/products/catalogues-and-brochures/; Unfolded ladder: False; URL: www.fakro.com; Warning: The present model is for informational-demonstrative purposes only and as such cannot constitute a basis for performance. All dimensions presented in this model should be verified on site. Because of the fact that the model is a schematic one, FAKRO shall; Weight Net (Kg): 0; Width opening: 600; Youtube clip: http://www.fakro.com/roofers/film-installation-instructions/
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10.30 Sistemes especials de cobertes; 104.AMB.ClassificacioCodi: 30.20.10.30; 105.AMB.ClassificacioDescripcio: Sistemes especials de cobertes; 107.AMB.NomTipus: L2_TrampillaEscala; 109.AMB.CodiTipus: L2; 111.AMB.DescripcioTipus: Trampilla Fakro DRL amb escala integrada per accés fàcil a cobertes planes; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: TrampillaEscala
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Length (A): 0.84 m; Area: 1.1928 m2; Height: 0.841872 m; Volume (Net): 0 m3; Width: 1.42 m; Elevation to Project Zero: 4.81238 m; Elevation to 1st Reference Level: 4.81238 m; Elevation to 2nd Reference Level: 4.81238 m; Elevation to Sea Level: 14.1524 m; Elevation to Linked/Home Story: 4.81238 m; Home Offset: 4.81238 m; Surface Area: 24.1787 m2; Top Elevation To First Reference Level: 5.65425 m; Top Elevation To Home Story: 5.65425 m; Top Elevation To Project Zero: 5.65425 m; Top Elevation To Sea Level: 14.9943 m; Top Elevation To Second Reference Level: 5.65425 m; Bottom Elevation To First Reference Level: 4.81238 m; Bottom Elevation To Home Story: 4.81238 m; Bottom Elevation To Project Zero: 4.81238 m; Bottom Elevation To Sea Level: 14.1524 m; Bottom Elevation To Second Reference Level: 4.81238 m; Survey Coordinate X: 426530 m; Survey Coordinate Y: 4579815 m; Survey Coordinate Z: 14.1524 m; Top Surface Area (Net): 1.1928 m2; Bottom Surface Area (Net): 24.1787 m2
5 AMB.Geometria - 502.AMB.Amplada: 1.42 m; 503.AMB.Altura: 0.841872 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: bolardo 438 x 700 (3)
In: planta baixa
Classification: 30.20.10.40 Acabats de cobertes (GuBIMclass CA); Material: Concrete
ArchiCADProperties - Beam Cross Section: Profiled; End Surface: Stone - Rock; Beam Slant Angle: 0 deg; Extrusion Surface: Stone - Rock; Element ID: BMR - 005; Hotlink and Element ID: BMR - 005; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: bolardo; Complex Profile: bolardo; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Complex Profile; Profile Category: bolardo; Parent ID: BMR - 005; Building Materials (All): Concrete; Cover Fill: Background; Slant Angle: 0 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10.40 Acabats de cobertes; 104.AMB.ClassificacioCodi: 30.20.10.40; 105.AMB.ClassificacioDescripcio: Acabats de cobertes; 107.AMB.NomTipus: BMR - 005_; 109.AMB.CodiTipus: BMR - 005; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Concrete, Component Type: Core
ArchiCADQuantities - Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Length Left: 0.481104 m; Length Right: 0.481104 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.421131 m2; Height: 0.700453 m; Width: 0.438386 m; Elevation to Project Zero: 0.00183192 m; Elevation to 1st Reference Level: 0.00183192 m; Elevation to 2nd Reference Level: 0.00183192 m; Elevation to Sea Level: 9.34183 m; Elevation to Linked/Home Story: 0.00183192 m; Home Offset: 0.00183192 m; 3D Length: 0.481104 m; Volume (Gross): 0.13296 m3; Top Elevation To First Reference Level: 0.702285 m; Top Elevation To Home Story: 0.702285 m; Top Elevation To Project Zero: 0.702285 m; Top Elevation To Sea Level: 10.0423 m; Top Elevation To Second Reference Level: 0.702285 m; Bottom Elevation To First Reference Level: 0.00183192 m; Bottom Elevation To Home Story: 0.00183192 m; Bottom Elevation To Project Zero: 0.00183192 m; Bottom Elevation To Sea Level: 9.34183 m; Bottom Elevation To Second Reference Level: 0.00183192 m; Cross Section Height at Top/End (perpendicular): 0.700453 m; Cross Section Height at Bottom/Start (perpendicular): 0.700453 m; Cross Section Width at Top/End (perpendicular): 0.438386 m; Cross Section Width at Bottom/Start (perpendicular): 0.438386 m; Cross Section Height at Top/End (cut): 0.700453 m; Cross Section Height at Bottom/Start (cut): 0.700453 m; Cross Section Width at Top/End (cut): 0.438386 m; Cross Section Width at Bottom/Start (cut): 0.438386 m; Cross Section Area at Top/End: 0.276364 m2; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.438386 m; 503.AMB.Altura: 0.700453 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete, Component Cross Section Area: 0.276708 m2
Name | Surfaces (All) | Concrete, Embodied Carbon | Concrete, Embodied Energy (MJ) | Surface Area of Both Beam Ends (m2) | Surface Area of the Beam Left Side (Net) (m2) | Area (m2) = Bottom Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Concrete, Component Volume (Net) (m3) = Concrete, Component Volume (Gross) (m3) | Surface Area (m2) | Cross Section Area at Bottom/Start (m2) | Top Surface Area (Net) (m2) | Concrete, Mass (kg)
BMR - 005 | Concrete - Bush hammered; Stone - Rock | 25.6079 (kgCO₂) | 177.102 | 0.552727 | 0.308517 | 0.210601 | 0.132959 | 1.57066 | 0.276364 | 0.0491816 | 239.327
BMR - 005 | Concrete - Bush hammered; Stone - Rock | 25.555 (kgCO₂) | 176.736 | 0.551583 | 0 | 0.210209 | 0.132685 | 1.5687 | 0.275219 | 0.0487894 | 238.832
BMR - 005 | Stone - Rock | 25.6081 (kgCO₂) | 177.102 | 0.552727 | 0.336991 | 0.210601 | 0.13296 | 1.57063 | 0.276364 | 0.0491824 | 239.328

# IfcOpeningElement (289)
In: planta baixa
Name | Depth (m) | BaseQuantities, Height (m) | BaseQuantities, Width (m) | BaseQuantities, Area (m2) | Volume (m3) | Classification | Shape | Orientation | Limits | Cut Symbol Name | Uncut Symbol Name | IDs of Cut Elements | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Layer | Colliding Zones | Locked | Home Story Name = 115.AMB.Nivell | Home Story Number = Slant Angle (deg) = 506.AMB.Profunditat (m) = Opening End Surface Area (Net, total) (m2) | Element Type | Parent ID | Surfaces (All) | Design Option Name = Design Option Set Name = Design Option Status = Design Option Set | Position | Renovation Status | Show On Renovation Filter | 001.AMB.ExpedientNumero | 003.AMB.NomProjecte | 004.AMB.FaseProjecte | 007.AMB.ModelDisciplina | 008.AMB.Adreca | 009.AMB.Municipi | 010.AMB.AutorProjecte | 011.AMB.AutorProjecte2 | 012.AMB.AutorProjecte3 | 107.AMB.NomTipus | 117.AMB.Localitzacio | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | Status | 502.AMB.Amplada (m) = ArchiCADQuantities, Width (m) | 503.AMB.Altura (m) = ArchiCADQuantities, Height (m) | Sill Height to Home Story (m) = Sill Height to Project Zero (m) | Header Height to Home Story (m) = Header Height to Project Zero (m) | Total Thickness (m) | Number of Cut Elements | Center Height to Home Story (m) = Center Height to Project Zero (m) | Sill Height to Wall Bottom (m) | Sill Height to Wall Top (m) | Center Height to Wall Bottom (m) | Center Height to Wall Top (m) | Header Height to Wall Bottom (m) | Header Height to Wall Top (m) | Opening Extrusion Surface Area (Net) (m2) = Surface Area (m2) = Edge Surface Area (Net) (m2) = Bottom Surface Area (Net) (m2) | ArchiCADQuantities, Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) | Elevation to Sea Level (m) | Home Offset (m) | 3D Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m)
PI013 | 0.14 | 2.6 | 0.8 | 2.08 | 0.0971757
2 x OP - 003 | 0.4 | 1.549 | 0.542667 | 0.840591 | 0.336237 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.542667 | 1.549 | 1.72847 | 3.27747 | 0.4 | 1 | 2.50297 | 2.68655 | -2.58045 | 3.46105 | -1.80595 | 4.23555 | -1.03145 | 1.67333 | 0.840591 | 0.336237 | 3.27747 | 12.6175 | 1.72847 | 4.18333 | 3.27747 | 12.6175 | 1.72847 | 11.0685 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
