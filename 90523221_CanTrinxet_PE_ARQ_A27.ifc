Properties of the parts of a building model (IFC2X3), part 50 of 99

# IfcBuildingElementProxy: Rhino_Object_1502, Object_1502
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426579 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1502 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1503, Object_1503
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1503; Hotlink and Element ID: Object_1503; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1503; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1503; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1503 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1503_; 109.AMB.CodiTipus: Object_1503; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426579 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1503 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1504, Object_1504
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1504 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1504; Hotlink and Element ID: Object_1504; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1504; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1504; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1504_; 109.AMB.CodiTipus: Object_1504; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1504 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1505, Object_1505
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1505; Hotlink and Element ID: Object_1505; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1505; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1505; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1505 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1505_; 109.AMB.CodiTipus: Object_1505; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1505 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1506, Object_1506
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1506; Hotlink and Element ID: Object_1506; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1506; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1506; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1506 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1506_; 109.AMB.CodiTipus: Object_1506; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1506 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1507, Object_1507
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1507; Hotlink and Element ID: Object_1507; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1507; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1507; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1507 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1507_; 109.AMB.CodiTipus: Object_1507; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426582 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1507 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1508, Object_1508
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1508; Hotlink and Element ID: Object_1508; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1508; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1508; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1508 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1508_; 109.AMB.CodiTipus: Object_1508; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426583 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1508 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1509, Object_1509
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1509; Hotlink and Element ID: Object_1509; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1509; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1509; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1509 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1509_; 109.AMB.CodiTipus: Object_1509; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426583 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1509 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_151, Object_151
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_151 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_151_; 109.AMB.CodiTipus: Object_151; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_151; Hotlink and Element ID: Object_151; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_151; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_151; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426570 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_151 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1510, Object_1510
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1510 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1510_; 109.AMB.CodiTipus: Object_1510; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426584 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1510 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1510; Hotlink and Element ID: Object_1510; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1510; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1510; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1511, Object_1511
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1511; Hotlink and Element ID: Object_1511; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1511; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1511; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1511 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1511_; 109.AMB.CodiTipus: Object_1511; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426585 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1511 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1512, Object_1512
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1512 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1512; Hotlink and Element ID: Object_1512; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1512; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1512; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1512_; 109.AMB.CodiTipus: Object_1512; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426586 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1512 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1513, Object_1513
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1513 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1513; Hotlink and Element ID: Object_1513; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1513; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1513; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471658 m; Area: 0.0603117 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.127872 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42968 m; Top Elevation To Home Story: 4.42968 m; Top Elevation To Project Zero: 4.42968 m; Top Elevation To Sea Level: 13.7697 m; Top Elevation To Second Reference Level: 4.42968 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426585 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0603117 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1513 - Dimension 1: 0.471658 m; Dimension 2: 0.127872 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 0.127872 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1513_; 109.AMB.CodiTipus: Object_1513; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1514, Object_1514
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1514; Hotlink and Element ID: Object_1514; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1514; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1514; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1514 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1514_; 109.AMB.CodiTipus: Object_1514; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15015 m; Area: 0.0147983 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.0985568 m; Elevation to Project Zero: 4.19492 m; Elevation to 1st Reference Level: 4.19492 m; Elevation to 2nd Reference Level: 4.19492 m; Elevation to Sea Level: 13.5349 m; Elevation to Linked/Home Story: 4.19492 m; Home Offset: 4.19492 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25242 m; Top Elevation To Home Story: 4.25242 m; Top Elevation To Project Zero: 4.25242 m; Top Elevation To Sea Level: 13.5924 m; Top Elevation To Second Reference Level: 4.25242 m; Bottom Elevation To First Reference Level: 4.19492 m; Bottom Elevation To Home Story: 4.19492 m; Bottom Elevation To Project Zero: 4.19492 m; Bottom Elevation To Sea Level: 13.5349 m; Bottom Elevation To Second Reference Level: 4.19492 m; Survey Coordinate X: 426569 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 13.5349 m; Top Surface Area (Net): 0.0147983 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1514 - Dimension 1: 0.15015 m; Dimension 2: 0.0985568 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0985568 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1515, Object_1515
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1515; Hotlink and Element ID: Object_1515; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1515; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1515; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1515 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1515_; 109.AMB.CodiTipus: Object_1515; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.10463 m; Area: 0.00898444 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0858688 m; Elevation to Project Zero: 3.97018 m; Elevation to 1st Reference Level: 3.97018 m; Elevation to 2nd Reference Level: 3.97018 m; Elevation to Sea Level: 13.3102 m; Elevation to Linked/Home Story: 3.97018 m; Home Offset: 3.97018 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19492 m; Top Elevation To Home Story: 4.19492 m; Top Elevation To Project Zero: 4.19492 m; Top Elevation To Sea Level: 13.5349 m; Top Elevation To Second Reference Level: 4.19492 m; Bottom Elevation To First Reference Level: 3.97018 m; Bottom Elevation To Home Story: 3.97018 m; Bottom Elevation To Project Zero: 3.97018 m; Bottom Elevation To Sea Level: 13.3102 m; Bottom Elevation To Second Reference Level: 3.97018 m; Survey Coordinate X: 426569 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 13.3102 m; Top Surface Area (Net): 0.00898444 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1515 - Dimension 1: 0.10463 m; Dimension 2: 0.0858688 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0858688 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3

# IfcBuildingElementProxy: Rhino_Object_1516, Object_1516
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0586292 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1516 - Dimension 1: 0.147744 m; Dimension 2: 0.0586292 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
ArchiCADQuantities - Length (A): 0.147744 m; Area: 0.00866213 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0586292 m; Elevation to Project Zero: 3.92949 m; Elevation to 1st Reference Level: 3.92949 m; Elevation to 2nd Reference Level: 3.92949 m; Elevation to Sea Level: 13.2695 m; Elevation to Linked/Home Story: 3.92949 m; Home Offset: 3.92949 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97018 m; Top Elevation To Home Story: 3.97018 m; Top Elevation To Project Zero: 3.97018 m; Top Elevation To Sea Level: 13.3102 m; Top Elevation To Second Reference Level: 3.97018 m; Bottom Elevation To First Reference Level: 3.92949 m; Bottom Elevation To Home Story: 3.92949 m; Bottom Elevation To Project Zero: 3.92949 m; Bottom Elevation To Sea Level: 13.2695 m; Bottom Elevation To Second Reference Level: 3.92949 m; Survey Coordinate X: 426569 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 13.2695 m; Top Surface Area (Net): 0.00866213 m2; Bottom Surface Area (Net): 0.0303692 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1516_; 109.AMB.CodiTipus: Object_1516; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1516 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
