Properties of the parts of a building model (IFC2X3), part 78 of 99

# IfcBuildingElementProxy: Rhino_Object_215, Object_215
ArchiCADQuantities - Length (A): 2.36359 m; Area: 0.623544 m2; Height: 0.591492 m; Volume (Net): 0.00633563 m3; Width: 0.263812 m; Elevation to Project Zero: 3.73569 m; Elevation to 1st Reference Level: 3.73569 m; Elevation to 2nd Reference Level: 3.73569 m; Elevation to Sea Level: 13.0757 m; Elevation to Linked/Home Story: 3.73569 m; Home Offset: 3.73569 m; Surface Area: 0.700057 m2; Top Elevation To First Reference Level: 4.0212 m; Top Elevation To Home Story: 4.0212 m; Top Elevation To Project Zero: 4.0212 m; Top Elevation To Sea Level: 13.3612 m; Top Elevation To Second Reference Level: 4.0212 m; Bottom Elevation To First Reference Level: 3.73569 m; Bottom Elevation To Home Story: 3.73569 m; Bottom Elevation To Project Zero: 3.73569 m; Bottom Elevation To Sea Level: 13.0757 m; Bottom Elevation To Second Reference Level: 3.73569 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.0757 m; Top Surface Area (Net): 0.623544 m2; Bottom Surface Area (Net): 0.700057 m2
AC_Equantity_Rhino_Object_215 - Dimension 1: 2.36359 m; Dimension 2: 0.263812 m; Height: 0.591492 m; Bottom Level: -9.76996e-15 m; Top Level: 0.591492 m
5 AMB.Geometria - 502.AMB.Amplada: 0.263812 m; 503.AMB.Altura: 0.591492 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00633563 m3; Component, Component Volume (Gross): 0.00633563 m3

# IfcBuildingElementProxy: Rhino_Object_216, Object_216
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_216; Hotlink and Element ID: Object_216; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_216; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_216; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_216 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_216_; 109.AMB.CodiTipus: Object_216; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.30563 m; Area: 0.531304 m2; Height: 0.63198 m; Volume (Net): 0.0146995 m3; Width: 0.230437 m; Elevation to Project Zero: 3.67427 m; Elevation to 1st Reference Level: 3.67427 m; Elevation to 2nd Reference Level: 3.67427 m; Elevation to Sea Level: 13.0143 m; Elevation to Linked/Home Story: 3.67427 m; Home Offset: 3.67427 m; Surface Area: 0.769371 m2; Top Elevation To First Reference Level: 3.99953 m; Top Elevation To Home Story: 3.99953 m; Top Elevation To Project Zero: 3.99953 m; Top Elevation To Sea Level: 13.3395 m; Top Elevation To Second Reference Level: 3.99953 m; Bottom Elevation To First Reference Level: 3.67427 m; Bottom Elevation To Home Story: 3.67427 m; Bottom Elevation To Project Zero: 3.67427 m; Bottom Elevation To Sea Level: 13.0143 m; Bottom Elevation To Second Reference Level: 3.67427 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.0143 m; Top Surface Area (Net): 0.531304 m2; Bottom Surface Area (Net): 0.769371 m2
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
5 AMB.Geometria - 502.AMB.Amplada: 0.230437 m; 503.AMB.Altura: 0.63198 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0146995 m3; Component, Component Volume (Gross): 0.0146995 m3
AC_Equantity_Rhino_Object_216 - Dimension 1: 2.30563 m; Dimension 2: 0.230437 m; Height: 0.63198 m; Bottom Level: -9.76996e-15 m; Top Level: 0.63198 m

# IfcBuildingElementProxy: Rhino_Object_217, Object_217
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_217; Hotlink and Element ID: Object_217; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_217; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_217; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_217 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_217_; 109.AMB.CodiTipus: Object_217; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.18017 m; Area: 0.442314 m2; Height: 2.71628 m; Volume (Net): 0.118769 m3; Width: 0.20288 m; Elevation to Project Zero: 1.51416 m; Elevation to 1st Reference Level: 1.51416 m; Elevation to 2nd Reference Level: 1.51416 m; Elevation to Sea Level: 10.8542 m; Elevation to Linked/Home Story: 1.51416 m; Home Offset: 1.51416 m; Surface Area: 4.65039 m2; Top Elevation To First Reference Level: 3.93107 m; Top Elevation To Home Story: 3.93107 m; Top Elevation To Project Zero: 3.93107 m; Top Elevation To Sea Level: 13.2711 m; Top Elevation To Second Reference Level: 3.93107 m; Bottom Elevation To First Reference Level: 1.51416 m; Bottom Elevation To Home Story: 1.51416 m; Bottom Elevation To Project Zero: 1.51416 m; Bottom Elevation To Sea Level: 10.8542 m; Bottom Elevation To Second Reference Level: 1.51416 m; Survey Coordinate X: 426578 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 10.8542 m; Top Surface Area (Net): 0.442314 m2; Bottom Surface Area (Net): 4.65039 m2
AC_Equantity_Rhino_Object_217 - Dimension 1: 2.18017 m; Dimension 2: 0.20288 m; Height: 2.71628 m; Bottom Level: -4.88498e-15 m; Top Level: 2.71628 m
5 AMB.Geometria - 502.AMB.Amplada: 0.20288 m; 503.AMB.Altura: 2.71628 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.118769 m3; Component, Component Volume (Gross): 0.118769 m3

# IfcBuildingElementProxy: Rhino_Object_218, Object_218
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_218 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_218; Hotlink and Element ID: Object_218; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_218; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_218; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_218_; 109.AMB.CodiTipus: Object_218; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
5 AMB.Geometria - 502.AMB.Amplada: 0.263812 m; 503.AMB.Altura: 0.591492 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00633563 m3; Component, Component Volume (Gross): 0.00633563 m3
ArchiCADQuantities - Length (A): 2.36359 m; Area: 0.623544 m2; Height: 0.591492 m; Volume (Net): 0.00633563 m3; Width: 0.263812 m; Elevation to Project Zero: 3.73569 m; Elevation to 1st Reference Level: 3.73569 m; Elevation to 2nd Reference Level: 3.73569 m; Elevation to Sea Level: 13.0757 m; Elevation to Linked/Home Story: 3.73569 m; Home Offset: 3.73569 m; Surface Area: 0.700057 m2; Top Elevation To First Reference Level: 4.0212 m; Top Elevation To Home Story: 4.0212 m; Top Elevation To Project Zero: 4.0212 m; Top Elevation To Sea Level: 13.3612 m; Top Elevation To Second Reference Level: 4.0212 m; Bottom Elevation To First Reference Level: 3.73569 m; Bottom Elevation To Home Story: 3.73569 m; Bottom Elevation To Project Zero: 3.73569 m; Bottom Elevation To Sea Level: 13.0757 m; Bottom Elevation To Second Reference Level: 3.73569 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.0757 m; Top Surface Area (Net): 0.623544 m2; Bottom Surface Area (Net): 0.700057 m2
AC_Equantity_Rhino_Object_218 - Dimension 1: 2.36359 m; Dimension 2: 0.263812 m; Height: 0.591492 m; Bottom Level: -9.76996e-15 m; Top Level: 0.591492 m

# IfcBuildingElementProxy: Rhino_Object_219, Object_219
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_219; Hotlink and Element ID: Object_219; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_219; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_219; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_219 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_219_; 109.AMB.CodiTipus: Object_219; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.30563 m; Area: 0.531304 m2; Height: 0.63198 m; Volume (Net): 0.0146995 m3; Width: 0.230437 m; Elevation to Project Zero: 3.67427 m; Elevation to 1st Reference Level: 3.67427 m; Elevation to 2nd Reference Level: 3.67427 m; Elevation to Sea Level: 13.0143 m; Elevation to Linked/Home Story: 3.67427 m; Home Offset: 3.67427 m; Surface Area: 0.769371 m2; Top Elevation To First Reference Level: 3.99953 m; Top Elevation To Home Story: 3.99953 m; Top Elevation To Project Zero: 3.99953 m; Top Elevation To Sea Level: 13.3395 m; Top Elevation To Second Reference Level: 3.99953 m; Bottom Elevation To First Reference Level: 3.67427 m; Bottom Elevation To Home Story: 3.67427 m; Bottom Elevation To Project Zero: 3.67427 m; Bottom Elevation To Sea Level: 13.0143 m; Bottom Elevation To Second Reference Level: 3.67427 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.0143 m; Top Surface Area (Net): 0.531304 m2; Bottom Surface Area (Net): 0.769371 m2
AC_Equantity_Rhino_Object_219 - Dimension 1: 2.30563 m; Dimension 2: 0.230437 m; Height: 0.63198 m; Bottom Level: -9.76996e-15 m; Top Level: 0.63198 m
5 AMB.Geometria - 502.AMB.Amplada: 0.230437 m; 503.AMB.Altura: 0.63198 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0146995 m3; Component, Component Volume (Gross): 0.0146995 m3

# IfcBuildingElementProxy: Rhino_Object_220, Object_220
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_220; Hotlink and Element ID: Object_220; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_220; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_220; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_220 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_220_; 109.AMB.CodiTipus: Object_220; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_220 - Dimension 1: 2.18017 m; Dimension 2: 0.20288 m; Height: 2.71628 m; Bottom Level: -4.88498e-15 m; Top Level: 2.71628 m
ArchiCADQuantities - Length (A): 2.18017 m; Area: 0.442314 m2; Height: 2.71628 m; Volume (Net): 0.118769 m3; Width: 0.20288 m; Elevation to Project Zero: 1.51416 m; Elevation to 1st Reference Level: 1.51416 m; Elevation to 2nd Reference Level: 1.51416 m; Elevation to Sea Level: 10.8542 m; Elevation to Linked/Home Story: 1.51416 m; Home Offset: 1.51416 m; Surface Area: 4.65039 m2; Top Elevation To First Reference Level: 3.93107 m; Top Elevation To Home Story: 3.93107 m; Top Elevation To Project Zero: 3.93107 m; Top Elevation To Sea Level: 13.2711 m; Top Elevation To Second Reference Level: 3.93107 m; Bottom Elevation To First Reference Level: 1.51416 m; Bottom Elevation To Home Story: 1.51416 m; Bottom Elevation To Project Zero: 1.51416 m; Bottom Elevation To Sea Level: 10.8542 m; Bottom Elevation To Second Reference Level: 1.51416 m; Survey Coordinate X: 426576 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 10.8542 m; Top Surface Area (Net): 0.442314 m2; Bottom Surface Area (Net): 4.65039 m2
Component Quantities - Component, Component Volume (Net): 0.118769 m3; Component, Component Volume (Gross): 0.118769 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.20288 m; 503.AMB.Altura: 2.71628 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_221, Object_221
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_221 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_221_; 109.AMB.CodiTipus: Object_221; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.36359 m; Area: 0.623544 m2; Height: 0.591492 m; Volume (Net): 0.00633563 m3; Width: 0.263812 m; Elevation to Project Zero: 3.73569 m; Elevation to 1st Reference Level: 3.73569 m; Elevation to 2nd Reference Level: 3.73569 m; Elevation to Sea Level: 13.0757 m; Elevation to Linked/Home Story: 3.73569 m; Home Offset: 3.73569 m; Surface Area: 0.700057 m2; Top Elevation To First Reference Level: 4.0212 m; Top Elevation To Home Story: 4.0212 m; Top Elevation To Project Zero: 4.0212 m; Top Elevation To Sea Level: 13.3612 m; Top Elevation To Second Reference Level: 4.0212 m; Bottom Elevation To First Reference Level: 3.73569 m; Bottom Elevation To Home Story: 3.73569 m; Bottom Elevation To Project Zero: 3.73569 m; Bottom Elevation To Sea Level: 13.0757 m; Bottom Elevation To Second Reference Level: 3.73569 m; Survey Coordinate X: 426575 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.0757 m; Top Surface Area (Net): 0.623544 m2; Bottom Surface Area (Net): 0.700057 m2
AC_Equantity_Rhino_Object_221 - Dimension 1: 2.36359 m; Dimension 2: 0.263812 m; Height: 0.591492 m; Bottom Level: -9.76996e-15 m; Top Level: 0.591492 m
5 AMB.Geometria - 502.AMB.Amplada: 0.263812 m; 503.AMB.Altura: 0.591492 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00633563 m3; Component, Component Volume (Gross): 0.00633563 m3
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_221; Hotlink and Element ID: Object_221; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_221; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_221; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_222, Object_222
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_222; Hotlink and Element ID: Object_222; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_222; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_222; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_222 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_222_; 109.AMB.CodiTipus: Object_222; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.30563 m; Area: 0.531304 m2; Height: 0.63198 m; Volume (Net): 0.0146995 m3; Width: 0.230437 m; Elevation to Project Zero: 3.67427 m; Elevation to 1st Reference Level: 3.67427 m; Elevation to 2nd Reference Level: 3.67427 m; Elevation to Sea Level: 13.0143 m; Elevation to Linked/Home Story: 3.67427 m; Home Offset: 3.67427 m; Surface Area: 0.769371 m2; Top Elevation To First Reference Level: 3.99953 m; Top Elevation To Home Story: 3.99953 m; Top Elevation To Project Zero: 3.99953 m; Top Elevation To Sea Level: 13.3395 m; Top Elevation To Second Reference Level: 3.99953 m; Bottom Elevation To First Reference Level: 3.67427 m; Bottom Elevation To Home Story: 3.67427 m; Bottom Elevation To Project Zero: 3.67427 m; Bottom Elevation To Sea Level: 13.0143 m; Bottom Elevation To Second Reference Level: 3.67427 m; Survey Coordinate X: 426575 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.0143 m; Top Surface Area (Net): 0.531304 m2; Bottom Surface Area (Net): 0.769371 m2
AC_Equantity_Rhino_Object_222 - Dimension 1: 2.30563 m; Dimension 2: 0.230437 m; Height: 0.63198 m; Bottom Level: -9.76996e-15 m; Top Level: 0.63198 m
5 AMB.Geometria - 502.AMB.Amplada: 0.230437 m; 503.AMB.Altura: 0.63198 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0146995 m3; Component, Component Volume (Gross): 0.0146995 m3

# IfcBuildingElementProxy: Rhino_Object_223, Object_223
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_223; Hotlink and Element ID: Object_223; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_223; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_223; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_223_; 109.AMB.CodiTipus: Object_223; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.348867 m; Area: 0.0282585 m2; Height: 1.11675 m; Volume (Net): 0.0130788 m3; Width: 0.0810007 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.605393 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426583 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.0282585 m2; Bottom Surface Area (Net): 0.605393 m2
AC_Equantity_Rhino_Object_223 - Dimension 1: 0.348867 m; Dimension 2: 0.0810007 m; Height: 1.11675 m; Bottom Level: -1.77636e-15 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0810007 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0130788 m3; Component, Component Volume (Gross): 0.0130788 m3
AC_Pset_Rhino_Object_223 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg

# IfcBuildingElementProxy: Rhino_Object_224, Object_224
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_224; Hotlink and Element ID: Object_224; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_224; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_224; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_224 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_224_; 109.AMB.CodiTipus: Object_224; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.348867 m; Area: 0.0282585 m2; Height: 1.11675 m; Volume (Net): 0.0130788 m3; Width: 0.0810007 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.605393 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426578 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.0282585 m2; Bottom Surface Area (Net): 0.605393 m2
AC_Equantity_Rhino_Object_224 - Dimension 1: 0.348867 m; Dimension 2: 0.0810007 m; Height: 1.11675 m; Bottom Level: -1.77636e-15 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0810007 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0130788 m3; Component, Component Volume (Gross): 0.0130788 m3

# IfcBuildingElementProxy: Rhino_Object_225, Object_225
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_225; Hotlink and Element ID: Object_225; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_225; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_225; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_225 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_225_; 109.AMB.CodiTipus: Object_225; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.348867 m; Area: 0.0282585 m2; Height: 1.11675 m; Volume (Net): 0.0130788 m3; Width: 0.0810007 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.605393 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426576 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.0282585 m2; Bottom Surface Area (Net): 0.605393 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_225 - Dimension 1: 0.348867 m; Dimension 2: 0.0810007 m; Height: 1.11675 m; Bottom Level: -1.77636e-15 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0810007 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0130788 m3; Component, Component Volume (Gross): 0.0130788 m3

# IfcBuildingElementProxy: Rhino_Object_226, Object_226
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_226; Hotlink and Element ID: Object_226; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_226; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_226; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_226 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_226_; 109.AMB.CodiTipus: Object_226; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152722 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.69311 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426584 m; Survey Coordinate Y: 4579792 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.69311 m2
AC_Equantity_Rhino_Object_226 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -3.55271e-15 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0152722 m3; Component, Component Volume (Gross): 0.0152722 m3

# IfcBuildingElementProxy: Rhino_Object_227, Object_227
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_227; Hotlink and Element ID: Object_227; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_227; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_227; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_227 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_227_; 109.AMB.CodiTipus: Object_227; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_227 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -3.55271e-15 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0152722 m3; Component, Component Volume (Gross): 0.0152722 m3
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152722 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.69311 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.69311 m2

# IfcBuildingElementProxy: Rhino_Object_228, Object_228
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_228; Hotlink and Element ID: Object_228; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_228; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_228; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_228_; 109.AMB.CodiTipus: Object_228; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_228 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152722 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.69311 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426579 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.69311 m2
AC_Equantity_Rhino_Object_228 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -3.55271e-15 m; Top Level: 1.11675 m
Component Quantities - Component, Component Volume (Net): 0.0152722 m3; Component, Component Volume (Gross): 0.0152722 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_229, Object_229
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_229; Hotlink and Element ID: Object_229; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_229; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_229; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_229_; 109.AMB.CodiTipus: Object_229; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152722 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.69311 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.69311 m2
AC_Equantity_Rhino_Object_229 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -3.55271e-15 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0152722 m3; Component, Component Volume (Gross): 0.0152722 m3
AC_Pset_Rhino_Object_229 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg

# IfcBuildingElementProxy: Rhino_Object_230, Object_230
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_230 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_230; Hotlink and Element ID: Object_230; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_230; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_230; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_230_; 109.AMB.CodiTipus: Object_230; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152724 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.693129 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693129 m2
AC_Equantity_Rhino_Object_230 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -8.88178e-16 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
