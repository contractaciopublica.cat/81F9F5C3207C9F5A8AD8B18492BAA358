Properties of the parts of a building model (IFC2X3), part 1 of 99

# File
Description: ViewDefinition [CoordinationView_V2.0, SurfaceGeometryAddOnView, QuantityTakeOffAddOnView], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and Archicad 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Split complex elements: Off], Option [Material Preservation: Explode where necessary], Option [IFC Model position: Survey Point and Project Origin], Option [Curtain Wall export mode: Single Element], Option [Railing export mode: Single Element], Option [Stair export mode: Single Element], Option [Properties To Export: Current Scheme properties only], Option [Space containment: Off], Option [Geometry to type objects: Off], Option [Element Properties: All], Option [Building Material Properties: Off], Option [Element Parameters: All], Option [Component Parameters: All], Option [IFC Base Quantities: On], Option [Door Window Parameters: On], Option [IFC Space boundaries: Off], Option [Archicad Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: Z:\OneDrive - MIPMARI\Ilyass\BIM\Can Trinxet\4.EXP\ifc\ENTREGA\90523221_CanTrinxet_PE_ARQ_A27.ifc
Time: 2025-04-29T09:11:10
Author: Architect
Organization: self-office
Written by: DDS_IFC v3.0
Made in: IFC file generated by Graphisoft Archicad 27.0.0 INT FULL Windows version (IFC add-on version: 5003 INT FULL).
Authorization: The authorising person

# IfcSite, Site
RefLatitude: 41, 21, 46, 0; RefLongitude: 2, 4, 32, 0; RefElevation: 9.34 m
BaseQuantities - GrossPerimeter: 0 m; GrossArea: 0 m2

# IfcBuilding, Building
BaseQuantities - GrossFloorArea: 0 m2

# IfcBuildingStorey (2)
In: Building
BaseQuantities - GrossFloorArea: 0 m2
Name | Elevation (m) | NetHeight (m) = GrossHeight (m) = Height (m)
planta coberta | 4.5 | 5.5
planta baixa | 0 | 4.5

# IfcBuildingElementPart (244)
Name | In | Material | Embodied Carbon | Embodied Energy (MJ) | Component Type | Mass (kg) | Projected Component Area (Net) (m2) | Projected Component Area (Gross) (m2) | Component Thickness (m) | Component Volume (Net) (m3) | Component Volume (Gross) (m3)
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 29.5889 (kgCO₂) | 512.116 | Core | 75.869 | 2.83416 | 2.83416 | 0.03 | 0.0842989 | 0.0842989 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.066 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 9.68745 (kgCO₂) | 128.269 | Core | 8.96986 | 2.86761 | 2.86761 | 0.08 | 0.224247 | 0.224247 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.176 m2
2 x Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 48.6964 (kgCO₂) | 842.822 | Core | 124.863 | 4.62454 | 6.70454 | 0.03 | 0.138736 | 0.201136 | Component Quantities - Rectangular Component Height: 5.003 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.15009 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 12.0133 (kgCO₂) | 159.065 | Core | 11.1234 | 4.62454 | 6.70454 | 0.08 | 0.278086 | 0.536363 | Component Quantities - Rectangular Component Height: 5.003 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.40024 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 26.927 (kgCO₂) | 466.044 | Core | 69.0436 | 2.59177 | 2.59177 | 0.03 | 0.0767151 | 0.0767151 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.066 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 10.2765 (kgCO₂) | 136.068 | Core | 9.51528 | 3.08297 | 3.08297 | 0.08 | 0.237882 | 0.237882 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.176 m2
2 x Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 30.63 (kgCO₂) | 530.135 | Core | 78.5385 | 2.91924 | 2.91924 | 0.03 | 0.087265 | 0.087265 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.066 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 9.39252 (kgCO₂) | 124.364 | Core | 8.69678 | 2.81001 | 2.81001 | 0.08 | 0.21742 | 0.21742 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.176 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 48.7255 (kgCO₂) | 843.325 | Core | 124.937 | 4.62735 | 6.70735 | 0.03 | 0.138819 | 0.201219 | Component Quantities - Rectangular Component Height: 5.003 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.15009 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 48.7281 (kgCO₂) | 843.371 | Core | 124.944 | 4.62759 | 6.70759 | 0.03 | 0.138826 | 0.201226 | Component Quantities - Rectangular Component Height: 5.003 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.15009 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 12.0233 (kgCO₂) | 159.197 | Core | 11.1326 | 4.62755 | 6.70755 | 0.08 | 0.278316 | 0.536594 | Component Quantities - Rectangular Component Height: 5.003 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.40024 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 22.303 (kgCO₂) | 386.014 | Core | 57.1873 | 2.14224 | 2.14224 | 0.03 | 0.0635414 | 0.0635414 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.066 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 7.29619 (kgCO₂) | 96.607 | Core | 6.75574 | 2.17569 | 2.17569 | 0.08 | 0.168893 | 0.168893 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.176 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 9.39551 (kgCO₂) | 124.404 | Core | 8.69955 | 2.81088 | 2.81088 | 0.08 | 0.217489 | 0.217489 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.176 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 26.9361 (kgCO₂) | 466.202 | Core | 69.067 | 2.59264 | 2.59264 | 0.03 | 0.0767411 | 0.0767411 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.066 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 10.2759 (kgCO₂) | 136.06 | Core | 9.51472 | 3.08297 | 3.08297 | 0.08 | 0.237868 | 0.237868 | Component Quantities - Rectangular Component Height: 2.2 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.176 m2
28 x  | planta baixa
Stone - Finish | planta baixa | Stone - Finish | 2285.82 (kgCO₂) | 35166.4 | Finish | 17583.2 | 125.594 | 124.474 | 0.05 | 6.27972 | 6.22371
Plaster - Gypsum | planta baixa | Plaster - Gypsum | 1061.27 (kgCO₂) | 14694.5 | Finish | 8163.64 | 125.594 | 124.474 | 0.05 | 6.27972 | 6.22371
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 271.284 (kgCO₂) | 3592 | Finish | 251.189 | 125.594 | 124.474 | 0.05 | 6.27972 | 6.22371
Air Space - Frame | planta baixa | Air Space - Frame | 0 (kgCO₂) | 0 | Core | 29.8889 | 125.594 | 124.474 | 0.2 | 24.9074 | 24.8948
Concrete - Structural | planta baixa | Concrete - Structural | 1143.91 (kgCO₂) | 11092.5 | Finish | 5777.34 | 125.594 | 124.474 | 0.02 | 2.51189 | 2.48948
Concrete - Structural | planta baixa | Concrete - Structural | 5668.55 (kgCO₂) | 54967.8 | Finish | 28629.1 | 124.474 | 124.474 | 0.1 | 12.4474 | 12.4474
21 x Concrete - Structural | planta baixa | Concrete - Structural | 147.55 (kgCO₂) | 1430.78 | Finish | 745.2 | 0.54 | 0.54 | 0.6 | 0.324 | 0.324
21 x Concrete | planta baixa | Concrete | 93.6036 (kgCO₂) | 647.352 | Finish | 874.8 | 0.54 | 0.54 | 0.9 | 0.486 | 0.486
Concrete - Structural | planta baixa | Concrete - Structural | 147.536 (kgCO₂) | 1430.65 | Finish | 745.129 | 0.539949 | 0.539949 | 0.6 | 0.323969 | 0.323969
2 x Concrete | planta baixa | Concrete | 93.6022 (kgCO₂) | 647.343 | Finish | 874.787 | 0.54 | 0.54 | 0.9 | 0.485993 | 0.485993
Concrete - Structural | planta baixa | Concrete - Structural | 147.536 (kgCO₂) | 1430.65 | Finish | 745.13 | 0.539949 | 0.539949 | 0.6 | 0.323969 | 0.323969
3 x Concrete - Structural | planta baixa | Concrete - Structural | 147.532 (kgCO₂) | 1430.61 | Finish | 745.109 | 0.539934 | 0.539934 | 0.6 | 0.32396 | 0.32396
3 x Concrete | planta baixa | Concrete | 93.6018 (kgCO₂) | 647.34 | Finish | 874.784 | 0.54 | 0.54 | 0.9 | 0.485991 | 0.485991
Concrete - Structural | planta baixa | Concrete - Structural | 147.466 (kgCO₂) | 1429.98 | Finish | 744.78 | 0.539695 | 0.539695 | 0.6 | 0.323817 | 0.323817
Concrete | planta baixa | Concrete | 93.5955 (kgCO₂) | 647.296 | Finish | 874.724 | 0.54 | 0.54 | 0.9 | 0.485958 | 0.485958
2 x Concrete | planta baixa | Concrete | 93.6019 (kgCO₂) | 647.34 | Finish | 874.784 | 0.54 | 0.54 | 0.9 | 0.485991 | 0.485991
2 x Concrete - Structural | planta baixa | Concrete - Structural | 147.532 (kgCO₂) | 1430.62 | Finish | 745.112 | 0.539937 | 0.539937 | 0.6 | 0.323962 | 0.323962
Concrete - Structural | planta baixa | Concrete - Structural | 147.534 (kgCO₂) | 1430.63 | Finish | 745.12 | 0.539942 | 0.539942 | 0.6 | 0.323965 | 0.323965
Concrete - Structural | planta baixa | Concrete - Structural | 147.534 (kgCO₂) | 1430.64 | Finish | 745.123 | 0.539944 | 0.539944 | 0.6 | 0.323967 | 0.323967
Concrete | planta baixa | Concrete | 93.6021 (kgCO₂) | 647.342 | Finish | 874.786 | 0.54 | 0.54 | 0.9 | 0.485992 | 0.485992
Concrete | planta baixa | Concrete | 93.603 (kgCO₂) | 647.348 | Finish | 874.794 | 0.54 | 0.54 | 0.9 | 0.485997 | 0.485997
Concrete - Structural | planta baixa | Concrete - Structural | 147.543 (kgCO₂) | 1430.72 | Finish | 745.167 | 0.539976 | 0.539976 | 0.6 | 0.323985 | 0.323985
3 x Concrete - Structural | planta baixa | Concrete - Structural | 147.546 (kgCO₂) | 1430.75 | Finish | 745.18 | 0.539986 | 0.539986 | 0.6 | 0.323991 | 0.323991
3 x Concrete | planta baixa | Concrete | 93.6032 (kgCO₂) | 647.349 | Finish | 874.796 | 0.54 | 0.54 | 0.9 | 0.485998 | 0.485998
Concrete - Structural | planta baixa | Concrete - Structural | 147.11 (kgCO₂) | 1426.52 | Finish | 742.979 | 0.538391 | 0.538391 | 0.6 | 0.323034 | 0.323034
Concrete | planta baixa | Concrete | 93.5608 (kgCO₂) | 647.056 | Finish | 874.4 | 0.54 | 0.54 | 0.9 | 0.485778 | 0.485778
Concrete | planta baixa | Concrete | 93.6021 (kgCO₂) | 647.341 | Finish | 874.786 | 0.54 | 0.54 | 0.9 | 0.485992 | 0.485992
Concrete - Structural | planta baixa | Concrete - Structural | 104.567 (kgCO₂) | 1013.98 | Finish | 528.114 | 1.54891 | 1.54891 | 0.15 | 0.229615 | 0.229615 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.717 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 9.67042 (kgCO₂) | 128.043 | Core | 8.95409 | 2.25147 | 2.25147 | 0.1 | 0.223852 | 0.223852 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.1 m; Component Cross Section Area: 0.478 m2
Concrete - Structural | planta baixa | Concrete - Structural | 189.496 (kgCO₂) | 1837.53 | Finish | 957.048 | 2.79432 | 2.79432 | 0.15 | 0.416108 | 0.416108 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.717 m2
Concrete - Structural | planta baixa | Concrete - Structural | 2147.01 (kgCO₂) | 20819.5 | Finish | 10843.5 | 31.4748 | 36.9748 | 0.15 | 4.71456 | 5.53956 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.717 m2
Concrete - Structural | planta baixa | Concrete - Structural | 1733.13 (kgCO₂) | 16806.1 | Finish | 8753.17 | 25.4138 | 30.9138 | 0.15 | 3.80572 | 4.63072 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.717 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 123.261 (kgCO₂) | 1632.07 | Core | 114.131 | 28.5617 | 34.0617 | 0.1 | 2.85327 | 3.40327 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.1 m; Component Cross Section Area: 0.478 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 123.013 (kgCO₂) | 1628.78 | Core | 113.901 | 28.5045 | 35.1525 | 0.1 | 2.84752 | 3.51232 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.1 m; Component Cross Section Area: 0.478 m2
Concrete - Structural | planta baixa | Concrete - Structural | 1676.86 (kgCO₂) | 16260.4 | Finish | 8468.97 | 24.59 | 31.19 | 0.15 | 3.68216 | 4.67216 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.717 m2
Concrete - Structural | planta baixa | Concrete - Structural | 2145.73 (kgCO₂) | 20807.1 | Finish | 10837 | 31.4568 | 38.1048 | 0.15 | 4.71175 | 5.70895 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.717 m2
2 x Brick | planta baixa | Brick | 62.7566 (kgCO₂) | 784.457 | Finish | 261.486 | 1.16216 | 1.16216 | 0.15 | 0.174324 | 0.174324 | Component Quantities - Rectangular Component Height: 5.73834 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.860751 m2
Concrete - Structural | planta baixa | Concrete - Structural | 188.272 (kgCO₂) | 1825.66 | Finish | 950.867 | 2.78035 | 2.78035 | 0.15 | 0.41342 | 0.41342 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.717 m2
2 x Brick | planta baixa | Brick | 62.9367 (kgCO₂) | 786.709 | Finish | 262.236 | 1.16549 | 1.16549 | 0.15 | 0.174824 | 0.174824 | Component Quantities - Rectangular Component Height: 5.73834 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.860751 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 9.87916 (kgCO₂) | 130.807 | Core | 9.14737 | 2.30299 | 2.30299 | 0.1 | 0.228684 | 0.228684 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.1 m; Component Cross Section Area: 0.478 m2
Concrete - Structural | planta baixa | Concrete - Structural | 109.495 (kgCO₂) | 1061.77 | Finish | 553.003 | 1.62716 | 1.62716 | 0.15 | 0.240436 | 0.240436 | Component Quantities - Rectangular Component Height: 4.78 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.717 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 5.03494 (kgCO₂) | 66.6663 | Core | 4.66198 | 1.16549 | 1.16549 | 0.1 | 0.116549 | 0.116549 | Component Quantities - Rectangular Component Height: 5.73834 m; Rectangular Component Width: 0.1 m; Component Cross Section Area: 0.573834 m2
Stone - Finish | planta baixa | Stone - Finish | 627.929 (kgCO₂) | 9660.44 | Finish | 4830.22 | 34.5016 | 32.7416 | 0.05 | 1.72508 | 1.63708
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 74.5234 (kgCO₂) | 986.745 | Finish | 69.0032 | 34.5016 | 32.7416 | 0.05 | 1.72508 | 1.63708
Concrete - Structural | planta baixa | Concrete - Structural | 314.972 (kgCO₂) | 3054.28 | Finish | 1590.77 | 34.5819 | 33.9819 | 0.02 | 0.691639 | 0.679639
Plaster - Gypsum | planta baixa | Plaster - Gypsum | 291.538 (kgCO₂) | 4036.69 | Finish | 2242.6 | 34.5016 | 32.7416 | 0.05 | 1.72508 | 1.63708
Air Space - Frame | planta baixa | Air Space - Frame | 0 (kgCO₂) | 0 | Core | 8.15566 | 33.9819 | 33.9819 | 0.2 | 6.79639 | 6.79639
Brick | planta baixa | Brick | 76.0976 (kgCO₂) | 951.22 | Finish | 317.073 | 1.40922 | 1.40922 | 0.15 | 0.211382 | 0.211382 | Component Quantities - Rectangular Component Height: 6.45647 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.96847 m2
Concrete - Structural | planta baixa | Concrete - Structural | 1547.54 (kgCO₂) | 15006.4 | Finish | 7815.84 | 33.9819 | 33.9819 | 0.1 | 3.39819 | 3.39819
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 6.08781 (kgCO₂) | 80.6072 | Core | 5.63686 | 1.40922 | 1.40922 | 0.1 | 0.140922 | 0.140922 | Component Quantities - Rectangular Component Height: 6.45647 m; Rectangular Component Width: 0.1 m; Component Cross Section Area: 0.645647 m2
Brick | planta baixa | Brick | 76.0958 (kgCO₂) | 951.197 | Finish | 317.066 | 1.40922 | 1.40922 | 0.15 | 0.211377 | 0.211377 | Component Quantities - Rectangular Component Height: 6.45647 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.96847 m2
Concrete - Structural | planta baixa | Concrete - Structural | 123.819 (kgCO₂) | 1200.67 | Finish | 625.351 | 1.83718 | 1.83718 | 0.15 | 0.271892 | 0.271892 | Component Quantities - Rectangular Component Height: 4.28 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.642 m2
Concrete - Structural | planta baixa | Concrete - Structural | 191.57 (kgCO₂) | 1857.65 | Finish | 967.524 | 2.82883 | 2.82883 | 0.15 | 0.420663 | 0.420663 | Component Quantities - Rectangular Component Height: 4.28 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.642 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 10.4367 (kgCO₂) | 138.189 | Core | 9.66358 | 2.43217 | 2.43217 | 0.1 | 0.241589 | 0.241589 | Component Quantities - Rectangular Component Height: 4.28 m; Rectangular Component Width: 0.1 m; Component Cross Section Area: 0.428 m2
Stone - Finish | planta baixa | Stone - Finish | 2376.51 (kgCO₂) | 36561.6 | Finish | 18280.8 | 130.577 | 129.48 | 0.05 | 6.52886 | 6.474
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 5.02053 (kgCO₂) | 66.4755 | Core | 4.64864 | 1.16216 | 1.16216 | 0.1 | 0.116216 | 0.116216 | Component Quantities - Rectangular Component Height: 5.73834 m; Rectangular Component Width: 0.1 m; Component Cross Section Area: 0.573834 m2
Plaster - Gypsum | planta baixa | Plaster - Gypsum | 1103.38 (kgCO₂) | 15277.5 | Finish | 8487.52 | 130.577 | 129.48 | 0.05 | 6.52886 | 6.474
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 282.047 (kgCO₂) | 3734.51 | Finish | 261.155 | 130.577 | 129.48 | 0.05 | 6.52886 | 6.474
Concrete - Structural | planta baixa | Concrete - Structural | 1189.3 (kgCO₂) | 11532.6 | Finish | 6006.56 | 130.577 | 129.48 | 0.02 | 2.61155 | 2.5896
Air Space - Frame | planta baixa | Air Space - Frame | 0 (kgCO₂) | 0 | Core | 31.1586 | 130.577 | 129.48 | 0.2 | 25.9655 | 25.896
Concrete - Structural | planta baixa | Concrete - Structural | 5896.52 (kgCO₂) | 57178.3 | Finish | 29780.4 | 129.48 | 129.48 | 0.1 | 12.948 | 12.948
2 x Brick | planta baixa | Brick | 69.8201 (kgCO₂) | 872.751 | Finish | 290.917 | 1.29296 | 1.29296 | 0.15 | 0.193945 | 0.193945 | Component Quantities - Rectangular Component Height: 6.46104 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.969155 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 5.58561 (kgCO₂) | 73.9576 | Core | 5.17186 | 1.29296 | 1.29296 | 0.1 | 0.129296 | 0.129296 | Component Quantities - Rectangular Component Height: 6.46104 m; Rectangular Component Width: 0.1 m; Component Cross Section Area: 0.646104 m2
Concrete - Structural | planta baixa | Concrete - Structural | 191.208 (kgCO₂) | 1854.14 | Finish | 965.696 | 2.81726 | 2.81726 | 0.15 | 0.419868 | 0.419868 | Component Quantities - Rectangular Component Height: 4.28 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.642 m2
Concrete - Structural | planta baixa | Concrete - Structural | 122.131 (kgCO₂) | 1184.3 | Finish | 616.821 | 1.80603 | 1.80603 | 0.15 | 0.268183 | 0.268183 | Component Quantities - Rectangular Component Height: 4.28 m; Rectangular Component Width: 0.15 m; Component Cross Section Area: 0.642 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 10.3709 (kgCO₂) | 137.319 | Core | 9.6027 | 2.41277 | 2.41277 | 0.1 | 0.240067 | 0.240067 | Component Quantities - Rectangular Component Height: 4.28 m; Rectangular Component Width: 0.1 m; Component Cross Section Area: 0.428 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 216.629 (kgCO₂) | 2868.33 | Finish | 200.583 | 100.426 | 99.8884 | 0.05 | 5.01457 | 4.99442
Plaster - Gypsum | planta baixa | Plaster - Gypsum | 848.597 (kgCO₂) | 11749.8 | Finish | 6527.67 | 100.426 | 99.8884 | 0.05 | 5.02129 | 4.99442
Concrete - Structural | planta baixa | Concrete - Structural | 909.783 (kgCO₂) | 8822.14 | Finish | 4594.86 | 99.8884 | 99.8884 | 0.02 | 1.99777 | 1.99777
Air Space - Frame | planta baixa | Air Space - Frame | 0 (kgCO₂) | 0 | Core | 23.9732 | 99.8884 | 99.8884 | 0.2 | 19.9777 | 19.9777
Concrete - Structural | planta baixa | Concrete - Structural | 4548.92 (kgCO₂) | 44110.7 | Finish | 22974.3 | 99.8884 | 99.8884 | 0.1 | 9.98884 | 9.98884
Stone - Finish | planta baixa | Stone - Finish | 1827.75 (kgCO₂) | 28119.2 | Finish | 14059.6 | 100.426 | 99.8884 | 0.05 | 5.02129 | 4.99442
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 20.9 (kgCO₂) | 276.732 | Core | 19.3519 | 7.22341 | 13.4805 | 0.08 | 0.483797 | 1.07844 | Component Quantities - Rectangular Component Height: 5.003 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.40024 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 76.1839 (kgCO₂) | 1318.57 | Core | 195.343 | 7.24693 | 13.4805 | 0.03 | 0.217048 | 0.404416 | Component Quantities - Rectangular Component Height: 5.003 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.15009 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 18.2866 (kgCO₂) | 316.499 | Core | 46.8887 | 1.77758 | 2.02603 | 0.03 | 0.0520986 | 0.0597008 | Component Quantities - Rectangular Component Height: 1.53992 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.0461976 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 5.4071 (kgCO₂) | 71.594 | Core | 5.00658 | 1.60422 | 1.84536 | 0.08 | 0.125164 | 0.146075 | Component Quantities - Rectangular Component Height: 1.53992 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.123194 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 71.2162 (kgCO₂) | 1232.59 | Core | 182.606 | 6.76317 | 8.84317 | 0.03 | 0.202895 | 0.265295 | Component Quantities - Rectangular Component Height: 5.3 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.159 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 71.2163 (kgCO₂) | 1232.59 | Core | 182.606 | 6.76318 | 8.84318 | 0.03 | 0.202895 | 0.265295 | Component Quantities - Rectangular Component Height: 5.3 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.159 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 16.3625 (kgCO₂) | 283.196 | Core | 41.955 | 1.56869 | 1.81149 | 0.03 | 0.0466167 | 0.0541262 | Component Quantities - Rectangular Component Height: 1.53992 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.0461976 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 6.30838 (kgCO₂) | 83.5277 | Core | 5.8411 | 1.92251 | 2.15797 | 0.08 | 0.146027 | 0.166513 | Component Quantities - Rectangular Component Height: 1.53992 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.123194 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 23.3735 (kgCO₂) | 309.483 | Core | 21.6422 | 6.76318 | 8.84318 | 0.08 | 0.541054 | 0.707454 | Component Quantities - Rectangular Component Height: 5.3 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.424 m2
2 x Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 12.0032 (kgCO₂) | 207.748 | Core | 30.7774 | 1.1399 | 1.62619 | 0.03 | 0.0341971 | 0.0487857 | Component Quantities - Rectangular Component Height: 1.51399 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.0454197 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 3.93951 (kgCO₂) | 52.162 | Core | 3.64769 | 1.1399 | 1.62619 | 0.08 | 0.0911924 | 0.130095 | Component Quantities - Rectangular Component Height: 1.51399 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.121119 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 33.4813 (kgCO₂) | 443.317 | Core | 31.0012 | 9.72273 | 17.0998 | 0.08 | 0.77503 | 1.36798 | Component Quantities - Rectangular Component Height: 5.003 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.40024 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 102.518 (kgCO₂) | 1774.35 | Core | 262.866 | 9.74886 | 17.0998 | 0.03 | 0.292074 | 0.512994 | Component Quantities - Rectangular Component Height: 5.003 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.15009 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 6.96732 (kgCO₂) | 92.2524 | Core | 6.45122 | 2.11968 | 3.2497 | 0.08 | 0.16128 | 0.252138 | Component Quantities - Rectangular Component Height: 2.31898 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.185519 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 19.8804 (kgCO₂) | 344.084 | Core | 50.9755 | 1.93856 | 3.05514 | 0.03 | 0.0566394 | 0.0900582 | Component Quantities - Rectangular Component Height: 2.31898 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.0695695 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 5.59526 (kgCO₂) | 74.0853 | Core | 5.18079 | 1.64496 | 3.37427 | 0.08 | 0.12952 | 0.267602 | Component Quantities - Rectangular Component Height: 2.803 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.22424 m2
Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 16.9293 (kgCO₂) | 293.007 | Core | 43.4085 | 1.61744 | 3.32326 | 0.03 | 0.0482317 | 0.0993688 | Component Quantities - Rectangular Component Height: 2.803 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.08409 m2
2 x Gypsum Plasterboard | planta baixa | Gypsum Plasterboard | 40.4959 (kgCO₂) | 700.891 | Core | 103.836 | 3.84577 | 6.07005 | 0.03 | 0.115373 | 0.182101 | Component Quantities - Rectangular Component Height: 5.3 m; Rectangular Component Width: 0.03 m; Component Cross Section Area: 0.159 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 13.291 (kgCO₂) | 175.982 | Core | 12.3065 | 3.84577 | 6.07005 | 0.08 | 0.307661 | 0.485604 | Component Quantities - Rectangular Component Height: 5.3 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.424 m2
Stone - Finish | planta baixa | Stone - Finish | 203.503 (kgCO₂) | 3130.81 | Finish | 1565.4 | 11.1815 | 11.1815 | 0.05 | 0.559073 | 0.559073
Insulation - Mineral Hard | planta baixa | Insulation - Mineral Hard | 106.084 (kgCO₂) | 1363.02 | Finish | 64.2934 | 11.1815 | 11.1815 | 0.05 | 0.559073 | 0.559073
Concrete - Structural | planta baixa | Concrete - Structural | 1018.41 (kgCO₂) | 9875.47 | Finish | 5143.47 | 11.1815 | 11.1815 | 0.2 | 2.23629 | 2.23629
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 31.2441 (kgCO₂) | 413.695 | Core | 28.9297 | 10.3321 | 10.386 | 0.07 | 0.723242 | 0.727022 | Component Quantities - Rectangular Component Height: 3.96287 m; Rectangular Component Width: 0.07 m; Component Cross Section Area: 0.277401 m2
Timber - Structural | planta baixa | Timber - Structural | 40.0378 (kgCO₂) | 1242.2 | Core | 102.661 | 9.77724 | 9.83123 | 0.015 | 0.146658 | 0.147468 | Component Quantities - Rectangular Component Height: 3.96287 m; Rectangular Component Width: 0.015 m; Component Cross Section Area: 0.059443 m2
Air Space - Frame | planta baixa | Air Space - Frame | 0 (kgCO₂) | 0 | Core | 1.05358 | 11.0108 | 11.0108 | 0.08 | 0.877984 | 0.87853 | Component Quantities - Rectangular Component Height: 3.96287 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.31703 m2
Air Space - Frame | planta baixa | Air Space - Frame | 0 (kgCO₂) | 0 | Core | 1.24062 | 12.9232 | 12.9232 | 0.08 | 1.03385 | 1.03385 | Component Quantities - Rectangular Component Height: 5.38434 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.430747 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 37.0682 (kgCO₂) | 490.81 | Core | 34.3224 | 12.258 | 12.258 | 0.07 | 0.858059 | 0.858059 | Component Quantities - Rectangular Component Height: 5.38434 m; Rectangular Component Width: 0.07 m; Component Cross Section Area: 0.376904 m2
Timber - Structural | planta baixa | Timber - Structural | 48.5476 (kgCO₂) | 1506.22 | Core | 124.481 | 11.8553 | 11.8553 | 0.015 | 0.17783 | 0.17783 | Component Quantities - Rectangular Component Height: 5.38434 m; Rectangular Component Width: 0.015 m; Component Cross Section Area: 0.0807651 m2
Air Space - Frame | planta baixa | Air Space - Frame | 0 (kgCO₂) | 0 | Core | 0.836155 | 8.70995 | 12.9226 | 0.08 | 0.696795 | 1.03381 | Component Quantities - Rectangular Component Height: 5.38434 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.430747 m2
Timber - Structural | planta baixa | Timber - Structural | 31.2951 (kgCO₂) | 970.949 | Core | 80.2438 | 7.64226 | 11.8549 | 0.015 | 0.114634 | 0.177824 | Component Quantities - Rectangular Component Height: 5.38434 m; Rectangular Component Width: 0.015 m; Component Cross Section Area: 0.0807651 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 24.3276 (kgCO₂) | 322.116 | Core | 22.5256 | 8.04486 | 12.2575 | 0.07 | 0.56314 | 0.858025 | Component Quantities - Rectangular Component Height: 5.38434 m; Rectangular Component Width: 0.07 m; Component Cross Section Area: 0.376904 m2
Concrete | planta baixa | Concrete | 83.7063 (kgCO₂) | 578.903 | Finish | 782.302 | 0.482912 | 0.482912 | 0.9 | 0.434612 | 0.434612
Concrete - Structural | planta baixa | Concrete - Structural | 131.951 (kgCO₂) | 1279.52 | Finish | 666.419 | 0.482912 | 0.482912 | 0.6 | 0.289747 | 0.289747
Concrete | planta baixa | Concrete | 83.708 (kgCO₂) | 578.915 | Finish | 782.318 | 0.482912 | 0.482912 | 0.9 | 0.434621 | 0.434621
Concrete - Structural | planta baixa | Concrete - Structural | 341.877 (kgCO₂) | 3315.17 | Finish | 1726.65 | 1.2512 | 1.2512 | 0.6 | 0.750719 | 0.750719
Concrete | planta baixa | Concrete | 216.905 (kgCO₂) | 1500.09 | Finish | 2027.15 | 1.25138 | 1.25138 | 0.9 | 1.12619 | 1.12619
Concrete - Structural | planta baixa | Concrete - Structural | 146.905 (kgCO₂) | 1424.53 | Finish | 741.944 | 0.53764 | 0.53764 | 0.6 | 0.322584 | 0.322584
Concrete | planta baixa | Concrete | 93.4899 (kgCO₂) | 646.566 | Finish | 873.738 | 0.54 | 0.54 | 0.9 | 0.48541 | 0.48541
Concrete - Structural | planta baixa | Concrete - Structural | 131.941 (kgCO₂) | 1279.43 | Finish | 666.369 | 0.482876 | 0.482876 | 0.6 | 0.289726 | 0.289726
Concrete - Structural | planta baixa | Concrete - Structural | 1433.54 (kgCO₂) | 13901 | Finish | 7240.09 | 5.24644 | 5.24644 | 0.6 | 3.14786 | 3.14786
Concrete | planta baixa | Concrete | 909.418 (kgCO₂) | 6289.43 | Finish | 8499.23 | 5.24644 | 5.24644 | 0.9 | 4.7218 | 4.7218
3 x Concrete - Structural | planta baixa | Concrete - Structural | 393.099 (kgCO₂) | 3811.87 | Finish | 1985.35 | 1.43866 | 1.43866 | 0.6 | 0.863194 | 0.863194
3 x Concrete | planta baixa | Concrete | 249.377 (kgCO₂) | 1724.66 | Finish | 2330.62 | 1.43866 | 1.43866 | 0.9 | 1.29479 | 1.29479
Concrete - Structural | planta baixa | Concrete - Structural | 147.544 (kgCO₂) | 1430.73 | Finish | 745.174 | 0.539981 | 0.539981 | 0.6 | 0.323989 | 0.323989
Concrete | planta baixa | Concrete | 93.6031 (kgCO₂) | 647.349 | Finish | 874.795 | 0.54 | 0.54 | 0.9 | 0.485997 | 0.485997
Concrete - Structural | planta baixa | Concrete - Structural | 147.529 (kgCO₂) | 1430.58 | Finish | 745.094 | 0.539923 | 0.539923 | 0.6 | 0.323954 | 0.323954
Concrete | planta baixa | Concrete | 93.6016 (kgCO₂) | 647.338 | Finish | 874.781 | 0.54 | 0.54 | 0.9 | 0.485989 | 0.485989
Timber - Structural | planta baixa | Timber - Structural | 21.879 (kgCO₂) | 678.81 | Core | 56.1 | 5.35646 | 6.03261 | 0.015 | 0.0801429 | 0.0904892 | Component Quantities - Rectangular Component Height: 2.46145 m; Rectangular Component Width: 0.015 m; Component Cross Section Area: 0.0369217 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 15.9237 (kgCO₂) | 210.842 | Core | 14.7442 | 5.32926 | 6.03261 | 0.07 | 0.368605 | 0.422283 | Component Quantities - Rectangular Component Height: 2.46145 m; Rectangular Component Width: 0.07 m; Component Cross Section Area: 0.172301 m2
Air Space - Frame | planta baixa | Air Space - Frame | 0 (kgCO₂) | 0 | Core | 0.492458 | 5.20231 | 6.03261 | 0.08 | 0.410382 | 0.482609 | Component Quantities - Rectangular Component Height: 2.46145 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.196916 m2
Concrete - Structural | planta baixa | Concrete - Structural | 147.531 (kgCO₂) | 1430.6 | Finish | 745.106 | 0.539932 | 0.539932 | 0.6 | 0.323959 | 0.323959
Concrete | planta baixa | Concrete | 93.6018 (kgCO₂) | 647.339 | Finish | 874.783 | 0.54 | 0.54 | 0.9 | 0.485991 | 0.485991
Concrete | planta baixa | Concrete | 767.311 (kgCO₂) | 5306.63 | Finish | 7171.13 | 4.42662 | 4.42662 | 0.9 | 3.98396 | 3.98396
Concrete - Structural | planta baixa | Concrete - Structural | 1209.53 (kgCO₂) | 11728.8 | Finish | 6108.74 | 4.42662 | 4.42662 | 0.6 | 2.65597 | 2.65597
Air Space - Frame | planta baixa | Air Space - Frame | 0 (kgCO₂) | 0 | Core | 1.21944 | 12.78 | 14.1115 | 0.08 | 1.0162 | 1.12892 | Component Quantities - Rectangular Component Height: 5.38434 m; Rectangular Component Width: 0.08 m; Component Cross Section Area: 0.430747 m2
Timber - Structural | planta baixa | Timber - Structural | 49.5151 (kgCO₂) | 1536.24 | Core | 126.962 | 12.1052 | 13.1961 | 0.015 | 0.181374 | 0.197942 | Component Quantities - Rectangular Component Height: 5.38434 m; Rectangular Component Width: 0.015 m; Component Cross Section Area: 0.0807651 m2
Insulation - Mineral Soft | planta baixa | Insulation - Mineral Soft | 36.7767 (kgCO₂) | 486.95 | Core | 34.0525 | 12.2258 | 13.3577 | 0.07 | 0.851311 | 0.935037 | Component Quantities - Rectangular Component Height: 5.38434 m; Rectangular Component Width: 0.07 m; Component Cross Section Area: 0.376904 m2
Tile - Wall | planta coberta | Tile - Wall | 162.036 (kgCO₂) | 2025.45 | Finish | 675.149 | 22.505 | 23.6978 | 0.02 | 0.450099 | 0.473955
Concrete | planta coberta | Concrete | 694.444 (kgCO₂) | 4802.69 | Finish | 6490.13 | 22.574 | 23.6978 | 0.16 | 3.60563 | 3.79164
Tile - Wall | planta coberta | Tile - Wall | 267.167 (kgCO₂) | 3339.59 | Finish | 1113.2 | 37.1066 | 37.8933 | 0.02 | 0.742131 | 0.757866
Timber - Structural | planta coberta | Timber - Structural | 623.109 (kgCO₂) | 19332.3 | Core | 1597.71 | 22.991 | 23.6978 | 0.1 | 2.28245 | 2.36978
Concrete | planta coberta | Concrete | 214.402 (kgCO₂) | 1482.78 | Finish | 2003.75 | 37.1066 | 37.8933 | 0.03 | 1.1132 | 1.1368
Concrete | planta coberta | Concrete | 357.336 (kgCO₂) | 2471.3 | Finish | 3339.59 | 37.1066 | 37.8933 | 0.05 | 1.85533 | 1.89466
Insulation - Mineral Soft | planta coberta | Insulation - Mineral Soft | 160.3 (kgCO₂) | 2122.5 | Core | 148.426 | 37.1066 | 37.8933 | 0.1 | 3.71066 | 3.78933
Concrete - Structural | planta coberta | Concrete - Structural | 4899.72 (kgCO₂) | 47512.4 | Finish | 24746.1 | 35.8638 | 36.6506 | 0.3 | 10.7592 | 10.9952
Insulation - Mineral Soft | planta coberta | Insulation - Mineral Soft | 97.5545 (kgCO₂) | 1291.69 | Finish | 90.3282 | 22.5866 | 23.6978 | 0.1 | 2.25821 | 2.36978

# IfcBuildingElementProxy: Arch Door 27 (2)
In: planta baixa
Classification: 30.10.20.20 Portes de façanes (GuBIMclass CA)
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0; Status: NEW
ArchiCADProperties - Reveal Dimensions: 1.390,5×3.238,9; Wallhole Dimensions: 1.390,5×3.238,9; Unit Dimensions: 1.390,5×3.238,9; Egress Dimensions: 1.310,5×3.198,9; Leaf Dimensions: 1.334,5×3.210,9; Nominal W x H Size: 1.390,5×3.238,9; Nominal W x H x T Size: 1.390,5×3.238,9×160,0; Wall Structure: Concrete 40-20 (2); Marker Text: <Custom Text>; Opening Library Part Name: Arch Door 27; Opening Side Fill Index: Background; Layer: 00_TABIQUE; Library Part Name: Arch Door 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Door; Parent ID: F1; Surfaces (All): Glass - Clear Fast; Metal - Aluminium; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.20.20 Portes de façanes; 104.AMB.ClassificacioCodi: 30.10.20.20; 105.AMB.ClassificacioDescripcio: Portes de façanes; 111.AMB.DescripcioTipus: Porta baten; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
AC_Pset_Arch_Door_27 - Wall Contours (0-None,1-Full,2-Side,3-Length): 0; Hotspots 0-None,1-2D,2-3D,3-All: 3; Show 2D Hotspots in 3D: yes; Floor Plan Display Option: 3; Hole Position Angle: 0 deg; Hole has Wall's Side Surface: yes; Hole Surface's Split is Curved in Curved Walls: no; Wall Type: 1; Reveal Anchor Position: 1; Opening Direction: 1; Flip: no; Parapet Wall Inset Value: 2; Demolition / New construction: 1; New Wall Fill Type: Masonry Block; New Wall Fill Pen: General - General; New Wall Fill Background Pen: Backgrounds - color 1; Show new construction on Wall: no; Demolition line type: 1; Show Demolition/New parameter: no; Display as Transom: no; Sidelight (gs_SidelightTransomRelation): Under Transom; Sidelight (gs_SidelightTransomRelation_m): 1; Sidelight 1: no; Sidelight 2: yes; Transom: yes; Uniform Tolerances: yes; Nominal Size: 0; Set Wallhole Size as Nominal Size: yes; Set Reveal Size as Nominal Size: no; Set Unit Size as Nominal Size: no; Set Egress Size as Nominal Size: no; Set Leaf Size as Nominal Size: no; Transfer Current Nominal Size to Selection: no; Show Editable Hotspots: yes; 2D Detail Level: 1; Show Reveal on Symbol: 1; Symbolic Display of Opening: no; 3D Detail Level: 8; Opening Direction Sidelight (gs_opening_dir_sl): Opposite to Leaf; Opening Direction Sidelight (gs_opening_dir_sl_m): 2; Door Frame (gs_pocket_door_frame): yes; Frame Style (gs_frame_style): Simple Rebate; Frame Style (gs_frame_style_m): 3; Frame Thickness=Wall Thickness: no; Uniform Frame Thickness: yes; Centered Leaf: yes; Uniform Frame Width: yes; Frame Style Changed Automatically: no; Number of Door Leaves: 4; Number of Door Leaves - Side 2: 3; Door Panel Style: 46; Leaves Configuration (gs_LeavesConfig): Uniform Leaves; Leaves Configuration (gs_iLeavesConfig): 1; Grid Position (gs_grill_pos): Throughout; Grid Position (gs_grill_pos_m): 3; Panes Number Vertically: 4; Panes Number Horizontally: 3; Panes Number Vertically Side 1: 4; Panes Number Horizontally Side 1: 3; Show as Glass Panel on Symbol: no; Show Chinese Spring Door Symbol: no; Show Symbol as Airtight Panel: no; Opening Handle (gs_handle_type_m): 0; Show Handle on Symbol: no; Kick Board Outside (bKickBoardOut): no; Kick Board Inside (bKickBoardIn): no; Uniform Sashes: no; Opening Type (gs_optype_m_05): 3; Opening Type (gs_optype_m_09): 3; Opening Type (gs_optype_m_02): 1; Opening Type (gs_optype_m_06): 1; Opening Type (gs_optype_m_10): 1; Sash Type (MullionStyle_00): No Grid; Sash Type (iMullionStyle_00): 1; Sash Type (iMullionStyle_05): 1; Sash Type (iMullionStyle_09): 1; Sash Type (iMullionStyle_02): 1; Sash Type (iMullionStyle_06): 1; Sash Type (iMullionStyle_10): 1; Hotspot Grill Editing: yes; Grid Position (MullionPosition): Throughout; Grid Position (iMullionPosition): 3; Panes Number Vertically Main Sash Side 1: 4; Panes Number Horizontally Main Sash Side 1: 2; Panes Number Vertically 2 Main Sash Side 1: 4; Panes Number Horizontally 2 Main Sash Side 1: 2; Panes Number Vertically Main Sash Side 2: 4; Panes Number Horizontally Main Sash Side 2: 2; Panes Number Vertically 2 Main Sash Side 2: 4; Panes Number Horizontally 2 Main Sash Side 2: 2; Panes Number Vertically Middle Transom: 2; Panes Number Horizontally Middle Transom: 2; Panes Number Vertically 2 Middle Transom: 2; Panes Number Horizontally 2 Middle Transom: 2; Panes Number Vertically Transom Side 1: 2; Panes Number Horizontally Transom Side 1: 2; Panes Number Vertically 2 Transom Side 1: 2; Panes Number Horizontally 2 Transom Side 1: 2; Panes Number Vertically Transom Side 2: 2; Panes Number Horizontally Transom Side 2: 2; Panes Number Vertically 2 Transom Side 2: 2; Panes Number Horizontally 2 Transom Side 2: 2; Casing Outside: no; Casing Type Outside (gs_trimtype_out): Simple; Casing Type Outside (gs_trimtype_out_int): 1; Cover Outer Wall Surface: yes; Uniform Casing Widths (gs_trim_outside_uniform): yes; Casing Inside: no; Casing Type Inside (gs_trimtype_in): Simple; Casing Type Inside (gs_trimtype_in_int): 1; Cover Inner Wall Surface: yes; Uniform Casing Widths (gs_trim_inside_uniform): yes; Threshold (bThreshold): no; Threshold Type: 2; Threshold Angle: 3.1996 deg; Threshold Changed Automatically: no; Sill - Door: no; Sill - Sidelight Side 1: no; Sill - Sidelight: no; Sill Oversize: no; Type of the Sill: 1; Sill Angle: 3 deg; Sill is Curved in Curved Walls: yes; Insulation below Sill: yes; Use Wall Insulation Skin: no; Brick Sill 3D Detail Level: 1; Sill Style Changed Automatically: no; Board - Sidelight Side 1: no; Board - Sidelight: no; Board - Door: no; Board Angle: 0 deg; Board is Curved in Curved Walls: yes; Board in Polygonal Walls: 1; Sunshade: no; Sunshade Type: 1; Enabled Sunshade Types: 38; Number of Panels: 2; Number of Panels 2: 1; Panel Position (gs_shutter_panelPos): Symmetric; Panel Position (gs_shutter_iPanelPos): 1; Automatic Shutter Height: yes; Extra Frame: no; Cover Type (gs_slidingShutter_cover): Z-Profile; Cover Type (gs_slidingShutter_iCover): 1; Stacking Direction (gs_foldingShutter_stacking): Inside; Stacking Direction (gs_foldingShutter_iStacking): 1; Open in 3D: yes; 3D Opening Angle: 180 deg; Show 2D Symbol: yes; Show Opening Lines on Symbol: no; Panel Type (gs_shutPanel_type): Style 1; Panel Type (gs_shutPanel_iType): 1; Different Bottom Frame Width: no; Automatic Shutter Width: yes; Louver Angle: 30 deg; Holes Number Horizontal: 5; Holes Number Vertical: 8; Rolling Shutter Placement (gs_shutRoll_placement): On Facade; Rolling Shutter Placement (gs_shutRoll_iPlacement): 1; Box Type (gs_shutRoll_boxType): Rectangular; Box Type (gs_shutRoll_iBoxType): 1; Rail Position (gs_shutRoll_railPos): On Casing; Rail Position (gs_shutRoll_iRailPos): 1; Show Casing behind Sunshade (gs_shutRoll_showCasingBehind): no; Insulation behind Box (gs_shutRoll_cutWallBehind): no; Include Height in Wallhole Height: no; Box Top Angle: 10 deg; Box Default Width (gs_shutRoll_boxDefaultSize): Reveal Width; Box Default Width (gs_shutRoll_iBoxDefaultSize): 1; Venetian Blinds Placement (gs_shutLam_placement): Fixed on Facade; Venetian Blinds Placement (gs_shutLam_iPlacement): 1; Insulation behind Box (gs_shutLam_cutWallBehind): no; Opened Box: yes; Rail (gs_shutLam_bRail): yes; Rail Position (gs_shutLam_railPos): On Casing; Rail Position (gs_shutLam_iRailPos): 1; Show Casing behind Sunshade (gs_shutLam_showCasingBehind): no; Rotation Angle of Slats (gs_shutLam_rotation): 45 deg; Rotation Angle of Slats (gs_shutLam2_rotation): 45 deg; Masonry Arch (bMasonryArch): no; Masonry Arch (gs_masonry_arch_int): 5; Masonry Arch Type (gs_masonry_arch_structure): Stucco Arch; Masonry Arch Type (gs_masonry_arch_structure_int): 1; Arch on Header: yes; Niche below Arch: yes; Skewback Angle: 75 deg; Custom Niche Surface: no; Reveal Type (gs_reveal_type_new): No Reveal - Edge; Reveal Type (gs_reveal_type_int): 1; Bottom Reveal Type (gs_reveal_type_bottom): Uniform; Bottom Reveal Type (gs_reveal_type_bottom_int): 1; Set Jamb Depth on Side: 1; Uniform Jamb Depth: yes; Outer Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleOuterTypeInt): 0; Inner Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleInnerTypeInt): 0; Angle Side 2: 20 deg; Angle Side: 20 deg; Upper Side Angle: 20 deg; Bottom Side Angle: 20 deg; Outer Angle Side 2: 20 deg; Outer Angle Side: 20 deg; Outer Angle Upper Side: 20 deg; Outer Angle Bottom Side: 20 deg; Rail under Leaves: no; Rail (gs_door_rail_ext): Off; Rail (gs_door_rail_ext_m): 1; Use Wall Finish Component: no; Auto Turn Inside Face Plaster: yes; Turn Inside Face Plaster: 0; Auto Turn Outside Face Plaster: yes; Turn Outside Face Plaster: 0; Dimensionable on 2D: no; Show in 3D: no; Closure Type (gs_closure_type): No Closure; Closure Type (gs_closure_type_int): 1; Turn Skin on Side (gs_cavity_side): Both; Turn Skin on Side (iCavityClosureSide): 1; Number of Skins to Turn: 1; Number from (gs_nTurnDir): Outside Face; Number from (iCavityClosureTurnDir): 1; Place Closer on Side 1: yes; Place Closer on Side 2: yes; Place Closer on Top: no; Place Closer on Bottom: no; Place Closer to Skin: 1; Place Closer from Side (gs_cc_dutch_ClosureToSide): 1; Gap at Outside Skin: yes; Turn Skin to Closer: no; Insert Insulation Strip: yes; Show Insulation Strip: yes; Contour Pen (gs_penJoint): Openings - Cut Non-Structural; Contour Line Type (gs_ltJoint): 1; Fill Type (gs_fillJoint): Rigid Insulation; Fill Pen (gs_penJointFg): General - General; Fill Background Pen (gs_penJointBg): 2D Elements - Drafting; Custom Surface: no; Surface: Wood - Pine Grained Horizontal; Contour Pen (gs_penPlug): Openings - Cut Non-Structural; Contour Line Type (gs_ltPlug): 1; Fill Type (gs_fillPlug): Rigid Insulation; Fill Pen (gs_penPlugFg): General - General; Fill Background Pen (gs_penPlugBg): 2D Elements - Drafting; Edited Jamb Side: 1; Edited Wall Side: 1; Edited Skin Number: 1; Turn-in Skin: no; Consider Skin as Plaster: no; Turn-in Thickness: 1; Hatch Orientation: 1; Separating Line at Turn-in: no; Separating Line Pen: General - General; Last Selected Side: no; Closure Method Changed Automatically: no; Connection on Side 1: no; Connection on Side 2: no; Connection on the Top: no; Opening Type (gs_leaf_optype): Side Hung; Opening Type (gs_leaf_optype_m): 1; End Panel Opening Side 1: no; End Panel Opening Side 2: no; Opening Angle in 2D: 0 deg; Opening Angle in 2D on Side 2: 90 deg; Opening Angle in 3D: 0 deg; End Panel Opening Angle in 3D on Side 2: 0 deg; Opening Angle of Main Sash Side 1 (openingAngle_05): 0 deg; Opening Angle of Main Sash Side 1 (openingAngle2_05): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle_09): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle2_09): 0 deg; Opening Angle of Middle Transom (openingAngle_02): 0 deg; Opening Angle of Middle Transom (openingAngle2_02): 0 deg; Opening Angle of Transom Side 1 (openingAngle_06): 0 deg; Opening Angle of Transom Side 1 (openingAngle2_06): 0 deg; Opening Angle of Transom Side 2 (openingAngle_10): 0 deg; Opening Angle of Transom Side 2 (openingAngle2_10): 0 deg; Double Acting Line Type: 4; Override MVO for 2D Symbolic Display: no; Opening Line Type: 1; Opening Line Shape (or_SwingType): Curved; Opening Line Shape (or_iSwingType): 1; Opening Line Shape (or_iSlidingType): 0; Show Glazing Line in 2D: yes; Glazing Line Pen in 2D (or_iGlazingLinePen): 3; Glazing Line Pen in 2D (or_glazingLinePen): Openings - General; Override MVO for Door 3D Projections: yes; Show Opening Line (or_bOplines3d): yes; Line Type Opening Side (or_opLineType3dIn): Dashed; Line Type Opening Side (or_iOpLineType3dIn): 1; Line Type Opposite Side (or_opLineType3dOut): Dashed; Line Type Opposite Side (or_iOpLineType3dOut): 1; Line Orientation (or_oplineStyle): Handle; Line Orientation (or_iOplineStyle): 1; Opening Line Pen in 2D/3D (or_opLinePen): Roofs/Shells - Outlines and Cover Fills; Opening Line Pen in 2D/3D (or_iOpLinePen): 92; Override MVO for Sidelight/Transom 3D Projections: no; Show Opening Line (or_bWinOplines3d): yes; Line Type Opening Side (or_winOpLineType3dIn): Dashed; Line Type Opening Side (or_iWinOpLineType3dIn): 1; Line Type Opposite Side (or_winOpLineType3dOut): Solid Line; Line Type Opposite Side (or_iWinOpLineType3dOut): 0; Line Orientation (or_winOplineStyle): Handle; Line Orientation (or_iWinOplineStyle): 1; Opening Line Pen in 2D/3D (or_winOpLinePen): Openings - General; Opening Line Pen in 2D/3D (or_iWinOpLinePen): 3; Symbol Pen: Openings - General; Frame Contour Pen: Openings - Cut Structural; Casing Cut Line Pen on Both Sides: Openings - General; Leaf Contour Pen: Openings - General; Wall Contour Line (gs_wcont_line): Off; Wall Contour Line (iWallContourLine): 1; Wall Contour Line Type Inside: 1; Wall Contour Line Type Outside: 1; Hidden Wall Contour Line Type Inside: 4; Hidden Wall Contour Line Type Outside: 4; Sidelight Wall Contour Line (gs_wcont_line_sl): Both Sides; Sidelight Wall Contour Line (iWallContourLineSl): 4; Sidelight Wall Contour Line Type Inside: 1; Sidelight Wall Contour Line Type Outside: 1; Sidelight Hidden Wall Contour Line Type Inside: 4; Sidelight Hidden Wall Contour Line Type Outside: 4; Wall Contour Line Pen: Openings - General; Use Fills: yes; Frame Fill Type: Background; Frame Fill Pen: Openings - Cut Fills; Frame Fill Background Pen: Backgrounds - color 1; Leaf Fill Type: Air Space; Leaf Fill Pen: Backgrounds - color 1; Leaf Fill Background Pen: Backgrounds - color 1; Airtight Symbol Fill Type: Foreground; Airtight Symbol Fill Pen: General - General; Airtight Symbol Fill Background Pen: General - General; Door Plan Symbol Fill Type: Background; Door Plan Symbol Fill Pen: Transparent; Door Plan Symbol Fill Background Pen: Transparent; Sidelight Plan Symbol Fill Type: Background; Sidelight Plan Symbol Fill Pen: Backgrounds - color 1; Sidelight Plan Symbol Fill Background Pen: Backgrounds - color 1; Threshold and Sill Line Type: 1; Threshold Section Contour Pen: Openings - General; Threshold Section Fill Type: Background; Threshold Section Fill Pen: Backgrounds - color 1; Threshold Section Fill Background Pen: Backgrounds - color 1; Sill 3D and Uncut Pen: General - General; Sill Section Contour Pen: General - General; Sill Section Fill Type: Air Space; Sill Section Fill Pen: Backgrounds - color 1; Sill Section Fill Background Pen: Backgrounds - color 1; Section Insulation Contour Pen: General - General; Section Insulation Fill Type: Rigid Insulation; Section Insulation Fill Pen: General - General; Section Insulation Fill Background Pen: Backgrounds - color 1; Board 3D and Uncut Pen: General - General; Board Section Contour Pen: General - General; Board Section Fill Type: Air Space; Board Section Fill Pen: Backgrounds - color 1; Board Section Fill Bkg. Pen: Backgrounds - color 1; Casing Fill Type Inside: Air Space; Casing Fill Pen Inside: Backgrounds - color 1; Casing Fill Background Pen Inside: Backgrounds - color 1; Casing Fill Type Outside: Air Space; Casing Fill Pen Outside: Backgrounds - color 1; Casing Fill Background Pen Outside: Backgrounds - color 1; Arch Section Fill Type: Background; Arch Section Fill Pen: Backgrounds - color 1; Arch Section Fill Bkg. Pen: Backgrounds - color 1; Sunshade Symbol Line Type: 1; Sunshade Cut Line Pen: General - General; 3D/Section Uncut Line Pen: General - General; Sunshade Cut Fill Type: Background; Sunshade Cut Fill Pen: General - General; Sunshade Cut Fill Background Pen: Window Background; Sunshade Insulation Fill Type: Batt Insulation; Sunshade Insulation Fill Pen: General - General; Sunshade Insulation Background Pen: Window Background; Uncut Fill Type: Background; Uncut Fill Pen: Backgrounds - color 1; Uncut Fill Background Pen: Backgrounds - color 1; Opening Side Values (gs_opside_list): Custom; Opening Side Values (gs_opside_list_m): 0; Frame Element Joinery (gs_SashText_typ): Butt Joint; Frame Element Joinery (gs_SashText_typ_num): 2; Frame Pen: Openings - General; Leaf Pen: Openings - General; Sash Glass Pen: Openings - Cut Non-Structural; Leaf Glass Pen: Openings - Cut Non-Structural; Masonry Arch Pen: Walls/Curtain Walls - General; Curve Resolution: 50; Shadow: yes; Uniform Door Surfaces: yes; Frame Outside: Metal - Aluminium; Frame Inside: Metal - Aluminium; Leaf Outside: Metal - Aluminium; Leaf Inside: Metal - Aluminium; Leaf 2: Metal - Aluminium; Leaf 3: Metal - Aluminium; Lock: Paint - Anthracite; Grid Outside (gs_grill_mat): Metal - Aluminium; Grid Inside (gs_grill_mat2): Metal - Aluminium; Grid Outside (gs_leaf_grill_mat): Metal - Aluminium; Grid Inside (gs_leaf_grill_mat2): Metal - Aluminium; Solid Panel Outside: Metal - Aluminium; Solid Panel Inside: Metal - Aluminium; Sash Glass: Glass - Clear Fast; Leaf Glass: Glass - Clear Fast; Rail (gs_rail_mat): Metal - Iron; Louver Outside: Wood - Pine Grained Horizontal; Louver Inside: Wood - Pine Grained Horizontal; Kick Plate: Metal - Aluminium; Uniform Casing Surfaces: yes; Interior Casing: Wood - Pine Grained Horizontal; Exterior Casing: Wood - Pine Grained Horizontal; Shutter Panel: Wood - Pine Grained Horizontal; Shutter Panel Frame: Wood - Pine Grained Horizontal; Rolling Shutter Box: Metal - Stainless Steel; Rolling Shutter Blades: Paint - Glossy White; Rolling Shutter Rail: Paint - Glossy White; Venetian Blinds Box: Metal - Stainless Steel; Venetian Blinds Segments: Paint - Glossy White; Sliding Shutter Rail: Metal - Stainless Steel; Threshold (gs_treshold_mat): Wood - Pine Grained Horizontal; Threshold Metal: Metal - Aluminium; Sill (gs_sill_mat): Brick - Running Bond; Brick Sill Mortar: Stucco - White Rough; Board (gs_board_mat): Wood - Pine Grained Horizontal; Handle: Metal - Stainless Steel; Handle Accessories: Metal - Iron; Kick Board Outside (matKickBoardOut): Metal - Stainless Steel; Kick Board Inside (matKickBoardIn): Metal - Stainless Steel; Masonry Arch Brick: Brick - Running Bond; Masonry Arch Mortar: Stucco - White Rough; Masonry Arch Keystone: Stone - Sandstone 01; Niche: Paint - Lead Oxide Yellow; Tags and Labels: 1; Show Leaf Width Dimensions: yes; Show Door ID: no; Show Custom Text: no; Custom Text: <Custom Text>; Always Readable: yes; Font Type: Arial; Font Size: 2; Font Style: 0; Text Pen (iPenText): 1; Text Pen (penText): General - General; Door belongs to the Zone into which it opens: yes; Cost: 0; Location as: Custom; Total Glazed Area (gs_list_glassarea_tmp): 0; Override Glazed Area: no; Total Glass Perimeter: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg; Door Orientation Definition: 0; Door Closer: no; Vision Panel Type: No Vision Panel; Hold Open Device: no; Door Leaf Widths: 1,33; IFC Operation (ifc_optypestr): Single Door Single Swing; IFC Operation (ifc_optype): 1
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: PortaExtTipusY
ArchiCADQuantities - W/D Opening Nominal Volume: 0.720596 m3; W/D Opening Nominal Surface Area: 4.50372 m2; W/D Opening Height on the Reveal Side: 3.23889 m; W/D Opening Height on the Side Opposite to the Reveal Side: 3.23889 m; Nominal W/D Opening Width on the Reveal Side: 1.39052 m; Nominal W/D Opening Height on the Reveal Side: 3.23889 m; Nominal W/D Opening Width on the Side Opposite to the Reveal Side: 1.39052 m; Nominal W/D Opening Height on the Side Opposite to the Reveal Side: 3.23889 m; Nominal W/D Opening Surface Area on the Reveal Side: 4.50372 m2; Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side: 4.50372 m2; Sill/Header Value: 0.406317 m; W/D Nominal Sill Height: 0.406317 m; W/D Sill Height on the Reveal Side: 0.0363166 m; W/D Sill Height on the Side Opposite to the Reveal Side: 0.0363166 m; W/D Nominal Head Height: 3.6452 m; W/D Head Height on the Reveal Side: 3.2752 m; W/D Head Height on the Side Opposite to the Reveal Side: 3.2752 m; Wall Thickness: 0.16 m; Frame Thickness: 0.16 m; Height: 3.23889 m; Width: 1.39052 m; Elevation to Project Zero: 0.406317 m; Elevation to 1st Reference Level: 0.406317 m; Elevation to 2nd Reference Level: 0.406317 m; Elevation to Sea Level: 9.74632 m; Elevation to Linked/Home Story: 0.406317 m; Home Offset: 0.406317 m; Top Elevation To First Reference Level: 3.6452 m; Top Elevation To Home Story: 3.6452 m; Top Elevation To Project Zero: 3.6452 m; Top Elevation To Sea Level: 12.9852 m; Top Elevation To Second Reference Level: 3.6452 m; Bottom Elevation To First Reference Level: 0.406317 m; Bottom Elevation To Home Story: 0.406317 m; Bottom Elevation To Project Zero: 0.406317 m; Bottom Elevation To Sea Level: 9.74632 m; Bottom Elevation To Second Reference Level: 0.406317 m
