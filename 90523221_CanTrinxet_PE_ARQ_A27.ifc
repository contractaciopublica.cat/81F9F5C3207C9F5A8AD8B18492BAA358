Properties of the parts of a building model (IFC2X3), part 86 of 99

# IfcBuildingElementProxy: Rhino_Object_578, Object_578
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_578; Hotlink and Element ID: Object_578; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_578; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_578; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_578 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_578_; 109.AMB.CodiTipus: Object_578; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152722 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.69311 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426549 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.69311 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_578 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -4.3201e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0152722 m3; Component, Component Volume (Gross): 0.0152722 m3

# IfcBuildingElementProxy: Rhino_Object_579, Object_579
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_579; Hotlink and Element ID: Object_579; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_579; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_579; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_579 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_579_; 109.AMB.CodiTipus: Object_579; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152722 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53967 m; Elevation to 1st Reference Level: 4.53967 m; Elevation to 2nd Reference Level: 4.53967 m; Elevation to Sea Level: 13.8797 m; Elevation to Linked/Home Story: 4.53967 m; Home Offset: 4.53967 m; Surface Area: 0.69311 m2; Top Elevation To First Reference Level: 5.65642 m; Top Elevation To Home Story: 5.65642 m; Top Elevation To Project Zero: 5.65642 m; Top Elevation To Sea Level: 14.9964 m; Top Elevation To Second Reference Level: 5.65642 m; Bottom Elevation To First Reference Level: 4.53967 m; Bottom Elevation To Home Story: 4.53967 m; Bottom Elevation To Project Zero: 4.53967 m; Bottom Elevation To Sea Level: 13.8797 m; Bottom Elevation To Second Reference Level: 4.53967 m; Survey Coordinate X: 426546 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 13.8797 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.69311 m2
AC_Equantity_Rhino_Object_579 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -4.3201e-12 m; Top Level: 1.11675 m
Component Quantities - Component, Component Volume (Net): 0.0152722 m3; Component, Component Volume (Gross): 0.0152722 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_58, Object_58
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_58; Hotlink and Element ID: Object_58; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_58; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_58; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_58 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_58_; 109.AMB.CodiTipus: Object_58; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_58 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_580, Object_580
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_580_; 109.AMB.CodiTipus: Object_580; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_580 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_580; Hotlink and Element ID: Object_580; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_580; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_580; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.17957 m; Area: 0.419755 m2; Height: 2.71628 m; Volume (Net): 0.101802 m3; Width: 0.192586 m; Elevation to Project Zero: 1.5418 m; Elevation to 1st Reference Level: 1.5418 m; Elevation to 2nd Reference Level: 1.5418 m; Elevation to Sea Level: 10.8818 m; Elevation to Linked/Home Story: 1.5418 m; Home Offset: 1.5418 m; Surface Area: 4.47082 m2; Top Elevation To First Reference Level: 3.95871 m; Top Elevation To Home Story: 3.95871 m; Top Elevation To Project Zero: 3.95871 m; Top Elevation To Sea Level: 13.2987 m; Top Elevation To Second Reference Level: 3.95871 m; Bottom Elevation To First Reference Level: 1.5418 m; Bottom Elevation To Home Story: 1.5418 m; Bottom Elevation To Project Zero: 1.5418 m; Bottom Elevation To Sea Level: 10.8818 m; Bottom Elevation To Second Reference Level: 1.5418 m; Survey Coordinate X: 426545 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 10.8818 m; Top Surface Area (Net): 0.419755 m2; Bottom Surface Area (Net): 4.47082 m2
AC_Equantity_Rhino_Object_580 - Dimension 1: 2.17957 m; Dimension 2: 0.192586 m; Height: 2.71628 m; Bottom Level: -3.77476e-14 m; Top Level: 2.71628 m
5 AMB.Geometria - 502.AMB.Amplada: 0.192586 m; 503.AMB.Altura: 2.71628 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.101802 m3; Component, Component Volume (Gross): 0.101802 m3

# IfcBuildingElementProxy: Rhino_Object_581, Object_581
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_581; Hotlink and Element ID: Object_581; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_581; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_581; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_581 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_581_; 109.AMB.CodiTipus: Object_581; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.78783 m; Area: 0.640308 m2; Height: 2.61918 m; Volume (Net): 0.0856519 m3; Width: 0.22968 m; Elevation to Project Zero: 1.55959 m; Elevation to 1st Reference Level: 1.55959 m; Elevation to 2nd Reference Level: 1.55959 m; Elevation to Sea Level: 10.8996 m; Elevation to Linked/Home Story: 1.55959 m; Home Offset: 1.55959 m; Surface Area: 3.76302 m2; Top Elevation To First Reference Level: 3.93203 m; Top Elevation To Home Story: 3.93203 m; Top Elevation To Project Zero: 3.93203 m; Top Elevation To Sea Level: 13.272 m; Top Elevation To Second Reference Level: 3.93203 m; Bottom Elevation To First Reference Level: 1.55959 m; Bottom Elevation To Home Story: 1.55959 m; Bottom Elevation To Project Zero: 1.55959 m; Bottom Elevation To Sea Level: 10.8996 m; Bottom Elevation To Second Reference Level: 1.55959 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.8996 m; Top Surface Area (Net): 0.640308 m2; Bottom Surface Area (Net): 3.76302 m2
AC_Equantity_Rhino_Object_581 - Dimension 1: 2.78783 m; Dimension 2: 0.22968 m; Height: 2.61918 m; Bottom Level: -3.35287e-14 m; Top Level: 2.61918 m
5 AMB.Geometria - 502.AMB.Amplada: 0.22968 m; 503.AMB.Altura: 2.61918 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0856519 m3; Component, Component Volume (Gross): 0.0856519 m3

# IfcBuildingElementProxy: Rhino_Object_582, Object_582
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_582 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_582; Hotlink and Element ID: Object_582; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_582; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_582; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_582 - Dimension 1: 2.78783 m; Dimension 2: 0.22968 m; Height: 2.61918 m; Bottom Level: -3.35287e-14 m; Top Level: 2.61918 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_582_; 109.AMB.CodiTipus: Object_582; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 2.78783 m; Area: 0.640308 m2; Height: 2.61918 m; Volume (Net): 0.0856519 m3; Width: 0.22968 m; Elevation to Project Zero: 1.55675 m; Elevation to 1st Reference Level: 1.55675 m; Elevation to 2nd Reference Level: 1.55675 m; Elevation to Sea Level: 10.8968 m; Elevation to Linked/Home Story: 1.55675 m; Home Offset: 1.55675 m; Surface Area: 3.76302 m2; Top Elevation To First Reference Level: 3.92919 m; Top Elevation To Home Story: 3.92919 m; Top Elevation To Project Zero: 3.92919 m; Top Elevation To Sea Level: 13.2692 m; Top Elevation To Second Reference Level: 3.92919 m; Bottom Elevation To First Reference Level: 1.55675 m; Bottom Elevation To Home Story: 1.55675 m; Bottom Elevation To Project Zero: 1.55675 m; Bottom Elevation To Sea Level: 10.8968 m; Bottom Elevation To Second Reference Level: 1.55675 m; Survey Coordinate X: 426556 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 10.8968 m; Top Surface Area (Net): 0.640308 m2; Bottom Surface Area (Net): 3.76302 m2
Component Quantities - Component, Component Volume (Net): 0.0856519 m3; Component, Component Volume (Gross): 0.0856519 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.22968 m; 503.AMB.Altura: 2.61918 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_583, Object_583
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_583; Hotlink and Element ID: Object_583; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_583; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_583; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_583 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.17957 m; Area: 0.419755 m2; Height: 2.71628 m; Volume (Net): 0.101802 m3; Width: 0.192586 m; Elevation to Project Zero: 1.54085 m; Elevation to 1st Reference Level: 1.54085 m; Elevation to 2nd Reference Level: 1.54085 m; Elevation to Sea Level: 10.8808 m; Elevation to Linked/Home Story: 1.54085 m; Home Offset: 1.54085 m; Surface Area: 4.47082 m2; Top Elevation To First Reference Level: 3.95776 m; Top Elevation To Home Story: 3.95776 m; Top Elevation To Project Zero: 3.95776 m; Top Elevation To Sea Level: 13.2978 m; Top Elevation To Second Reference Level: 3.95776 m; Bottom Elevation To First Reference Level: 1.54085 m; Bottom Elevation To Home Story: 1.54085 m; Bottom Elevation To Project Zero: 1.54085 m; Bottom Elevation To Sea Level: 10.8808 m; Bottom Elevation To Second Reference Level: 1.54085 m; Survey Coordinate X: 426548 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.8808 m; Top Surface Area (Net): 0.419755 m2; Bottom Surface Area (Net): 4.47082 m2
AC_Equantity_Rhino_Object_583 - Dimension 1: 2.17957 m; Dimension 2: 0.192586 m; Height: 2.71628 m; Bottom Level: -3.77476e-14 m; Top Level: 2.71628 m
5 AMB.Geometria - 502.AMB.Amplada: 0.192586 m; 503.AMB.Altura: 2.71628 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.101802 m3; Component, Component Volume (Gross): 0.101802 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_583_; 109.AMB.CodiTipus: Object_583; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_584, Object_584
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_584; Hotlink and Element ID: Object_584; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_584; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_584; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_584 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_584_; 109.AMB.CodiTipus: Object_584; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.17957 m; Area: 0.419755 m2; Height: 2.71628 m; Volume (Net): 0.101802 m3; Width: 0.192586 m; Elevation to Project Zero: 1.54085 m; Elevation to 1st Reference Level: 1.54085 m; Elevation to 2nd Reference Level: 1.54085 m; Elevation to Sea Level: 10.8808 m; Elevation to Linked/Home Story: 1.54085 m; Home Offset: 1.54085 m; Surface Area: 4.47082 m2; Top Elevation To First Reference Level: 3.95776 m; Top Elevation To Home Story: 3.95776 m; Top Elevation To Project Zero: 3.95776 m; Top Elevation To Sea Level: 13.2978 m; Top Elevation To Second Reference Level: 3.95776 m; Bottom Elevation To First Reference Level: 1.54085 m; Bottom Elevation To Home Story: 1.54085 m; Bottom Elevation To Project Zero: 1.54085 m; Bottom Elevation To Sea Level: 10.8808 m; Bottom Elevation To Second Reference Level: 1.54085 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.8808 m; Top Surface Area (Net): 0.419755 m2; Bottom Surface Area (Net): 4.47082 m2
AC_Equantity_Rhino_Object_584 - Dimension 1: 2.17957 m; Dimension 2: 0.192586 m; Height: 2.71628 m; Bottom Level: -3.77476e-14 m; Top Level: 2.71628 m
5 AMB.Geometria - 502.AMB.Amplada: 0.192586 m; 503.AMB.Altura: 2.71628 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.101802 m3; Component, Component Volume (Gross): 0.101802 m3

# IfcBuildingElementProxy: Rhino_Object_585, Object_585
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_585; Hotlink and Element ID: Object_585; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_585; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_585; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_585 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_585_; 109.AMB.CodiTipus: Object_585; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.17957 m; Area: 0.419755 m2; Height: 2.71628 m; Volume (Net): 0.101802 m3; Width: 0.192586 m; Elevation to Project Zero: 1.53895 m; Elevation to 1st Reference Level: 1.53895 m; Elevation to 2nd Reference Level: 1.53895 m; Elevation to Sea Level: 10.879 m; Elevation to Linked/Home Story: 1.53895 m; Home Offset: 1.53895 m; Surface Area: 4.47082 m2; Top Elevation To First Reference Level: 3.95587 m; Top Elevation To Home Story: 3.95587 m; Top Elevation To Project Zero: 3.95587 m; Top Elevation To Sea Level: 13.2959 m; Top Elevation To Second Reference Level: 3.95587 m; Bottom Elevation To First Reference Level: 1.53895 m; Bottom Elevation To Home Story: 1.53895 m; Bottom Elevation To Project Zero: 1.53895 m; Bottom Elevation To Sea Level: 10.879 m; Bottom Elevation To Second Reference Level: 1.53895 m; Survey Coordinate X: 426553 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 10.879 m; Top Surface Area (Net): 0.419755 m2; Bottom Surface Area (Net): 4.47082 m2
AC_Equantity_Rhino_Object_585 - Dimension 1: 2.17957 m; Dimension 2: 0.192586 m; Height: 2.71628 m; Bottom Level: -3.77476e-14 m; Top Level: 2.71628 m
5 AMB.Geometria - 502.AMB.Amplada: 0.192586 m; 503.AMB.Altura: 2.71628 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.101802 m3; Component, Component Volume (Gross): 0.101802 m3

# IfcBuildingElementProxy: Rhino_Object_586, Object_586
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_586; Hotlink and Element ID: Object_586; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_586; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_586; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_586 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.97185 m; Area: 0.893242 m2; Height: 0.516507 m; Volume (Net): 0.00795521 m3; Width: 0.300568 m; Elevation to Project Zero: 3.76333 m; Elevation to 1st Reference Level: 3.76333 m; Elevation to 2nd Reference Level: 3.76333 m; Elevation to Sea Level: 13.1033 m; Elevation to Linked/Home Story: 3.76333 m; Home Offset: 3.76333 m; Surface Area: 0.864871 m2; Top Elevation To First Reference Level: 4.02356 m; Top Elevation To Home Story: 4.02356 m; Top Elevation To Project Zero: 4.02356 m; Top Elevation To Sea Level: 13.3636 m; Top Elevation To Second Reference Level: 4.02356 m; Bottom Elevation To First Reference Level: 3.76333 m; Bottom Elevation To Home Story: 3.76333 m; Bottom Elevation To Project Zero: 3.76333 m; Bottom Elevation To Sea Level: 13.1033 m; Bottom Elevation To Second Reference Level: 3.76333 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 13.1033 m; Top Surface Area (Net): 0.893242 m2; Bottom Surface Area (Net): 0.864871 m2
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_586_; 109.AMB.CodiTipus: Object_586; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Equantity_Rhino_Object_586 - Dimension 1: 2.97185 m; Dimension 2: 0.300568 m; Height: 0.516507 m; Bottom Level: 0 m; Top Level: 0.516507 m
5 AMB.Geometria - 502.AMB.Amplada: 0.300568 m; 503.AMB.Altura: 0.516507 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00795521 m3; Component, Component Volume (Gross): 0.00795521 m3

# IfcBuildingElementProxy: Rhino_Object_587, Object_587
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_587; Hotlink and Element ID: Object_587; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_587; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_587; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_587 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_587_; 109.AMB.CodiTipus: Object_587; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.36359 m; Area: 0.622745 m2; Height: 0.591492 m; Volume (Net): 0.00633563 m3; Width: 0.263474 m; Elevation to Project Zero: 3.76333 m; Elevation to 1st Reference Level: 3.76333 m; Elevation to 2nd Reference Level: 3.76333 m; Elevation to Sea Level: 13.1033 m; Elevation to Linked/Home Story: 3.76333 m; Home Offset: 3.76333 m; Surface Area: 0.700057 m2; Top Elevation To First Reference Level: 4.04884 m; Top Elevation To Home Story: 4.04884 m; Top Elevation To Project Zero: 4.04884 m; Top Elevation To Sea Level: 13.3888 m; Top Elevation To Second Reference Level: 4.04884 m; Bottom Elevation To First Reference Level: 3.76333 m; Bottom Elevation To Home Story: 3.76333 m; Bottom Elevation To Project Zero: 3.76333 m; Bottom Elevation To Sea Level: 13.1033 m; Bottom Elevation To Second Reference Level: 3.76333 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 13.1033 m; Top Surface Area (Net): 0.622745 m2; Bottom Surface Area (Net): 0.700057 m2
AC_Equantity_Rhino_Object_587 - Dimension 1: 2.36359 m; Dimension 2: 0.263474 m; Height: 0.591492 m; Bottom Level: -3.9968e-15 m; Top Level: 0.591492 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 0.263474 m; 503.AMB.Altura: 0.591492 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00633563 m3; Component, Component Volume (Gross): 0.00633563 m3

# IfcBuildingElementProxy: Rhino_Object_588, Object_588
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_588; Hotlink and Element ID: Object_588; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_588; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_588; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_588 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_588_; 109.AMB.CodiTipus: Object_588; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.97185 m; Area: 0.893242 m2; Height: 0.516507 m; Volume (Net): 0.00795521 m3; Width: 0.300568 m; Elevation to Project Zero: 3.76049 m; Elevation to 1st Reference Level: 3.76049 m; Elevation to 2nd Reference Level: 3.76049 m; Elevation to Sea Level: 13.1005 m; Elevation to Linked/Home Story: 3.76049 m; Home Offset: 3.76049 m; Surface Area: 0.864871 m2; Top Elevation To First Reference Level: 4.02071 m; Top Elevation To Home Story: 4.02071 m; Top Elevation To Project Zero: 4.02071 m; Top Elevation To Sea Level: 13.3607 m; Top Elevation To Second Reference Level: 4.02071 m; Bottom Elevation To First Reference Level: 3.76049 m; Bottom Elevation To Home Story: 3.76049 m; Bottom Elevation To Project Zero: 3.76049 m; Bottom Elevation To Sea Level: 13.1005 m; Bottom Elevation To Second Reference Level: 3.76049 m; Survey Coordinate X: 426556 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 13.1005 m; Top Surface Area (Net): 0.893242 m2; Bottom Surface Area (Net): 0.864871 m2
AC_Equantity_Rhino_Object_588 - Dimension 1: 2.97185 m; Dimension 2: 0.300568 m; Height: 0.516507 m; Bottom Level: 0 m; Top Level: 0.516507 m
5 AMB.Geometria - 502.AMB.Amplada: 0.300568 m; 503.AMB.Altura: 0.516507 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00795521 m3; Component, Component Volume (Gross): 0.00795521 m3

# IfcBuildingElementProxy: Rhino_Object_589, Object_589
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_589; Hotlink and Element ID: Object_589; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_589; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_589; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_589 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_589_; 109.AMB.CodiTipus: Object_589; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.36359 m; Area: 0.622745 m2; Height: 0.591492 m; Volume (Net): 0.00633563 m3; Width: 0.263474 m; Elevation to Project Zero: 3.76238 m; Elevation to 1st Reference Level: 3.76238 m; Elevation to 2nd Reference Level: 3.76238 m; Elevation to Sea Level: 13.1024 m; Elevation to Linked/Home Story: 3.76238 m; Home Offset: 3.76238 m; Surface Area: 0.700057 m2; Top Elevation To First Reference Level: 4.04789 m; Top Elevation To Home Story: 4.04789 m; Top Elevation To Project Zero: 4.04789 m; Top Elevation To Sea Level: 13.3879 m; Top Elevation To Second Reference Level: 4.04789 m; Bottom Elevation To First Reference Level: 3.76238 m; Bottom Elevation To Home Story: 3.76238 m; Bottom Elevation To Project Zero: 3.76238 m; Bottom Elevation To Sea Level: 13.1024 m; Bottom Elevation To Second Reference Level: 3.76238 m; Survey Coordinate X: 426547 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 13.1024 m; Top Surface Area (Net): 0.622745 m2; Bottom Surface Area (Net): 0.700057 m2
AC_Equantity_Rhino_Object_589 - Dimension 1: 2.36359 m; Dimension 2: 0.263474 m; Height: 0.591492 m; Bottom Level: -3.9968e-15 m; Top Level: 0.591492 m
5 AMB.Geometria - 502.AMB.Amplada: 0.263474 m; 503.AMB.Altura: 0.591492 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00633563 m3; Component, Component Volume (Gross): 0.00633563 m3

# IfcBuildingElementProxy: Rhino_Object_59, Object_59
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_59; Hotlink and Element ID: Object_59; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_59; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_59; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_59 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_59_; 109.AMB.CodiTipus: Object_59; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_59 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_590, Object_590
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5661 deg; Surface: Brick - Aged Natural; Element ID: Object_590; Hotlink and Element ID: Object_590; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_590; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_590; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_590 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_590_; 109.AMB.CodiTipus: Object_590; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 2.36359 m; Area: 0.622745 m2; Height: 0.591492 m; Volume (Net): 0.00633563 m3; Width: 0.263474 m; Elevation to Project Zero: 3.76238 m; Elevation to 1st Reference Level: 3.76238 m; Elevation to 2nd Reference Level: 3.76238 m; Elevation to Sea Level: 13.1024 m; Elevation to Linked/Home Story: 3.76238 m; Home Offset: 3.76238 m; Surface Area: 0.700057 m2; Top Elevation To First Reference Level: 4.04789 m; Top Elevation To Home Story: 4.04789 m; Top Elevation To Project Zero: 4.04789 m; Top Elevation To Sea Level: 13.3879 m; Top Elevation To Second Reference Level: 4.04789 m; Bottom Elevation To First Reference Level: 3.76238 m; Bottom Elevation To Home Story: 3.76238 m; Bottom Elevation To Project Zero: 3.76238 m; Bottom Elevation To Sea Level: 13.1024 m; Bottom Elevation To Second Reference Level: 3.76238 m; Survey Coordinate X: 426549 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.1024 m; Top Surface Area (Net): 0.622745 m2; Bottom Surface Area (Net): 0.700057 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_590 - Dimension 1: 2.36359 m; Dimension 2: 0.263474 m; Height: 0.591492 m; Bottom Level: -3.9968e-15 m; Top Level: 0.591492 m
5 AMB.Geometria - 502.AMB.Amplada: 0.263474 m; 503.AMB.Altura: 0.591492 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00633563 m3; Component, Component Volume (Gross): 0.00633563 m3

# IfcBuildingElementProxy: Rhino_Object_591, Object_591
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.36359 m; Area: 0.622745 m2; Height: 0.591492 m; Volume (Net): 0.00633563 m3; Width: 0.263474 m; Elevation to Project Zero: 3.76238 m; Elevation to 1st Reference Level: 3.76238 m; Elevation to 2nd Reference Level: 3.76238 m; Elevation to Sea Level: 13.1024 m; Elevation to Linked/Home Story: 3.76238 m; Home Offset: 3.76238 m; Surface Area: 0.700057 m2; Top Elevation To First Reference Level: 4.04789 m; Top Elevation To Home Story: 4.04789 m; Top Elevation To Project Zero: 4.04789 m; Top Elevation To Sea Level: 13.3879 m; Top Elevation To Second Reference Level: 4.04789 m; Bottom Elevation To First Reference Level: 3.76238 m; Bottom Elevation To Home Story: 3.76238 m; Bottom Elevation To Project Zero: 3.76238 m; Bottom Elevation To Sea Level: 13.1024 m; Bottom Elevation To Second Reference Level: 3.76238 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.1024 m; Top Surface Area (Net): 0.622745 m2; Bottom Surface Area (Net): 0.700057 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
