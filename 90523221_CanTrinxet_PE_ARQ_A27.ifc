Properties of the parts of a building model (IFC2X3), part 38 of 99

# IfcBuildingElementProxy: Rhino_Object_1317, Object_1317
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1317; Hotlink and Element ID: Object_1317; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1317; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1317; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1318, Object_1318
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1318; Hotlink and Element ID: Object_1318; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1318; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1318; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1318 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1318_; 109.AMB.CodiTipus: Object_1318; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23494 m; Elevation to 1st Reference Level: 1.23494 m; Elevation to 2nd Reference Level: 1.23494 m; Elevation to Sea Level: 10.5749 m; Elevation to Linked/Home Story: 1.23494 m; Home Offset: 1.23494 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35502 m; Top Elevation To Home Story: 1.35502 m; Top Elevation To Project Zero: 1.35502 m; Top Elevation To Sea Level: 10.695 m; Top Elevation To Second Reference Level: 1.35502 m; Bottom Elevation To First Reference Level: 1.23494 m; Bottom Elevation To Home Story: 1.23494 m; Bottom Elevation To Project Zero: 1.23494 m; Bottom Elevation To Sea Level: 10.5749 m; Bottom Elevation To Second Reference Level: 1.23494 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5749 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1318 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1319, Object_1319
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1319; Hotlink and Element ID: Object_1319; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1319; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1319; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1319 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1319_; 109.AMB.CodiTipus: Object_1319; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23502 m; Elevation to 1st Reference Level: 1.23502 m; Elevation to 2nd Reference Level: 1.23502 m; Elevation to Sea Level: 10.575 m; Elevation to Linked/Home Story: 1.23502 m; Home Offset: 1.23502 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.3551 m; Top Elevation To Home Story: 1.3551 m; Top Elevation To Project Zero: 1.3551 m; Top Elevation To Sea Level: 10.6951 m; Top Elevation To Second Reference Level: 1.3551 m; Bottom Elevation To First Reference Level: 1.23502 m; Bottom Elevation To Home Story: 1.23502 m; Bottom Elevation To Project Zero: 1.23502 m; Bottom Elevation To Sea Level: 10.575 m; Bottom Elevation To Second Reference Level: 1.23502 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.575 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1319 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_132, Object_132
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_132; Hotlink and Element ID: Object_132; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_132; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_132; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_132 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_132_; 109.AMB.CodiTipus: Object_132; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_132 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1320, Object_1320
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1320; Hotlink and Element ID: Object_1320; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1320; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1320; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1320 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1320_; 109.AMB.CodiTipus: Object_1320; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.2351 m; Elevation to 1st Reference Level: 1.2351 m; Elevation to 2nd Reference Level: 1.2351 m; Elevation to Sea Level: 10.5751 m; Elevation to Linked/Home Story: 1.2351 m; Home Offset: 1.2351 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35518 m; Top Elevation To Home Story: 1.35518 m; Top Elevation To Project Zero: 1.35518 m; Top Elevation To Sea Level: 10.6952 m; Top Elevation To Second Reference Level: 1.35518 m; Bottom Elevation To First Reference Level: 1.2351 m; Bottom Elevation To Home Story: 1.2351 m; Bottom Elevation To Project Zero: 1.2351 m; Bottom Elevation To Sea Level: 10.5751 m; Bottom Elevation To Second Reference Level: 1.2351 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5751 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1320 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1321, Object_1321
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1321; Hotlink and Element ID: Object_1321; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1321; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1321; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1321 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23518 m; Elevation to 1st Reference Level: 1.23518 m; Elevation to 2nd Reference Level: 1.23518 m; Elevation to Sea Level: 10.5752 m; Elevation to Linked/Home Story: 1.23518 m; Home Offset: 1.23518 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35526 m; Top Elevation To Home Story: 1.35526 m; Top Elevation To Project Zero: 1.35526 m; Top Elevation To Sea Level: 10.6953 m; Top Elevation To Second Reference Level: 1.35526 m; Bottom Elevation To First Reference Level: 1.23518 m; Bottom Elevation To Home Story: 1.23518 m; Bottom Elevation To Project Zero: 1.23518 m; Bottom Elevation To Sea Level: 10.5752 m; Bottom Elevation To Second Reference Level: 1.23518 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5752 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1321 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1321_; 109.AMB.CodiTipus: Object_1321; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1322, Object_1322
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1322; Hotlink and Element ID: Object_1322; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1322; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1322; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1322 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1322_; 109.AMB.CodiTipus: Object_1322; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23526 m; Elevation to 1st Reference Level: 1.23526 m; Elevation to 2nd Reference Level: 1.23526 m; Elevation to Sea Level: 10.5753 m; Elevation to Linked/Home Story: 1.23526 m; Home Offset: 1.23526 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35534 m; Top Elevation To Home Story: 1.35534 m; Top Elevation To Project Zero: 1.35534 m; Top Elevation To Sea Level: 10.6953 m; Top Elevation To Second Reference Level: 1.35534 m; Bottom Elevation To First Reference Level: 1.23526 m; Bottom Elevation To Home Story: 1.23526 m; Bottom Elevation To Project Zero: 1.23526 m; Bottom Elevation To Sea Level: 10.5753 m; Bottom Elevation To Second Reference Level: 1.23526 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5753 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1322 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1323, Object_1323
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1323; Hotlink and Element ID: Object_1323; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1323; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1323; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1323 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1323_; 109.AMB.CodiTipus: Object_1323; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23534 m; Elevation to 1st Reference Level: 1.23534 m; Elevation to 2nd Reference Level: 1.23534 m; Elevation to Sea Level: 10.5753 m; Elevation to Linked/Home Story: 1.23534 m; Home Offset: 1.23534 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35542 m; Top Elevation To Home Story: 1.35542 m; Top Elevation To Project Zero: 1.35542 m; Top Elevation To Sea Level: 10.6954 m; Top Elevation To Second Reference Level: 1.35542 m; Bottom Elevation To First Reference Level: 1.23534 m; Bottom Elevation To Home Story: 1.23534 m; Bottom Elevation To Project Zero: 1.23534 m; Bottom Elevation To Sea Level: 10.5753 m; Bottom Elevation To Second Reference Level: 1.23534 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5753 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1323 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1324, Object_1324
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1324; Hotlink and Element ID: Object_1324; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1324; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1324; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1324 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1324_; 109.AMB.CodiTipus: Object_1324; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23542 m; Elevation to 1st Reference Level: 1.23542 m; Elevation to 2nd Reference Level: 1.23542 m; Elevation to Sea Level: 10.5754 m; Elevation to Linked/Home Story: 1.23542 m; Home Offset: 1.23542 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.3555 m; Top Elevation To Home Story: 1.3555 m; Top Elevation To Project Zero: 1.3555 m; Top Elevation To Sea Level: 10.6955 m; Top Elevation To Second Reference Level: 1.3555 m; Bottom Elevation To First Reference Level: 1.23542 m; Bottom Elevation To Home Story: 1.23542 m; Bottom Elevation To Project Zero: 1.23542 m; Bottom Elevation To Sea Level: 10.5754 m; Bottom Elevation To Second Reference Level: 1.23542 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5754 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
AC_Equantity_Rhino_Object_1324 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m

# IfcBuildingElementProxy: Rhino_Object_1325, Object_1325
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1325; Hotlink and Element ID: Object_1325; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1325; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1325; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1325 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1325_; 109.AMB.CodiTipus: Object_1325; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.2355 m; Elevation to 1st Reference Level: 1.2355 m; Elevation to 2nd Reference Level: 1.2355 m; Elevation to Sea Level: 10.5755 m; Elevation to Linked/Home Story: 1.2355 m; Home Offset: 1.2355 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35558 m; Top Elevation To Home Story: 1.35558 m; Top Elevation To Project Zero: 1.35558 m; Top Elevation To Sea Level: 10.6956 m; Top Elevation To Second Reference Level: 1.35558 m; Bottom Elevation To First Reference Level: 1.2355 m; Bottom Elevation To Home Story: 1.2355 m; Bottom Elevation To Project Zero: 1.2355 m; Bottom Elevation To Sea Level: 10.5755 m; Bottom Elevation To Second Reference Level: 1.2355 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5755 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1325 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1326, Object_1326
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1326; Hotlink and Element ID: Object_1326; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1326; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1326; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1326 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1326_; 109.AMB.CodiTipus: Object_1326; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23557 m; Elevation to 1st Reference Level: 1.23557 m; Elevation to 2nd Reference Level: 1.23557 m; Elevation to Sea Level: 10.5756 m; Elevation to Linked/Home Story: 1.23557 m; Home Offset: 1.23557 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35565 m; Top Elevation To Home Story: 1.35565 m; Top Elevation To Project Zero: 1.35565 m; Top Elevation To Sea Level: 10.6957 m; Top Elevation To Second Reference Level: 1.35565 m; Bottom Elevation To First Reference Level: 1.23557 m; Bottom Elevation To Home Story: 1.23557 m; Bottom Elevation To Project Zero: 1.23557 m; Bottom Elevation To Sea Level: 10.5756 m; Bottom Elevation To Second Reference Level: 1.23557 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5756 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1326 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m

# IfcBuildingElementProxy: Rhino_Object_1327, Object_1327
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1327 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1327_; 109.AMB.CodiTipus: Object_1327; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1327; Hotlink and Element ID: Object_1327; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1327; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1327; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23565 m; Elevation to 1st Reference Level: 1.23565 m; Elevation to 2nd Reference Level: 1.23565 m; Elevation to Sea Level: 10.5757 m; Elevation to Linked/Home Story: 1.23565 m; Home Offset: 1.23565 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35573 m; Top Elevation To Home Story: 1.35573 m; Top Elevation To Project Zero: 1.35573 m; Top Elevation To Sea Level: 10.6957 m; Top Elevation To Second Reference Level: 1.35573 m; Bottom Elevation To First Reference Level: 1.23565 m; Bottom Elevation To Home Story: 1.23565 m; Bottom Elevation To Project Zero: 1.23565 m; Bottom Elevation To Sea Level: 10.5757 m; Bottom Elevation To Second Reference Level: 1.23565 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5757 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1327 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1328, Object_1328
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1328; Hotlink and Element ID: Object_1328; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1328; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1328; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1328 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1328_; 109.AMB.CodiTipus: Object_1328; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23573 m; Elevation to 1st Reference Level: 1.23573 m; Elevation to 2nd Reference Level: 1.23573 m; Elevation to Sea Level: 10.5757 m; Elevation to Linked/Home Story: 1.23573 m; Home Offset: 1.23573 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35581 m; Top Elevation To Home Story: 1.35581 m; Top Elevation To Project Zero: 1.35581 m; Top Elevation To Sea Level: 10.6958 m; Top Elevation To Second Reference Level: 1.35581 m; Bottom Elevation To First Reference Level: 1.23573 m; Bottom Elevation To Home Story: 1.23573 m; Bottom Elevation To Project Zero: 1.23573 m; Bottom Elevation To Sea Level: 10.5757 m; Bottom Elevation To Second Reference Level: 1.23573 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5757 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1328 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1329, Object_1329
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1329; Hotlink and Element ID: Object_1329; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1329; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1329; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1329 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1329_; 109.AMB.CodiTipus: Object_1329; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23581 m; Elevation to 1st Reference Level: 1.23581 m; Elevation to 2nd Reference Level: 1.23581 m; Elevation to Sea Level: 10.5758 m; Elevation to Linked/Home Story: 1.23581 m; Home Offset: 1.23581 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35589 m; Top Elevation To Home Story: 1.35589 m; Top Elevation To Project Zero: 1.35589 m; Top Elevation To Sea Level: 10.6959 m; Top Elevation To Second Reference Level: 1.35589 m; Bottom Elevation To First Reference Level: 1.23581 m; Bottom Elevation To Home Story: 1.23581 m; Bottom Elevation To Project Zero: 1.23581 m; Bottom Elevation To Sea Level: 10.5758 m; Bottom Elevation To Second Reference Level: 1.23581 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5758 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
AC_Equantity_Rhino_Object_1329 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m

# IfcBuildingElementProxy: Rhino_Object_133, Object_133
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_133; Hotlink and Element ID: Object_133; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_133; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_133; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_133 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_133_; 109.AMB.CodiTipus: Object_133; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_133 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1330, Object_1330
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1330; Hotlink and Element ID: Object_1330; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1330; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1330; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1330 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1330_; 109.AMB.CodiTipus: Object_1330; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.2362 m; Elevation to 1st Reference Level: 1.2362 m; Elevation to 2nd Reference Level: 1.2362 m; Elevation to Sea Level: 10.5762 m; Elevation to Linked/Home Story: 1.2362 m; Home Offset: 1.2362 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35629 m; Top Elevation To Home Story: 1.35629 m; Top Elevation To Project Zero: 1.35629 m; Top Elevation To Sea Level: 10.6963 m; Top Elevation To Second Reference Level: 1.35629 m; Bottom Elevation To First Reference Level: 1.2362 m; Bottom Elevation To Home Story: 1.2362 m; Bottom Elevation To Project Zero: 1.2362 m; Bottom Elevation To Sea Level: 10.5762 m; Bottom Elevation To Second Reference Level: 1.2362 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5762 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1330 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1331, Object_1331
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
