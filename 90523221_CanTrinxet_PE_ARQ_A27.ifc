Properties of the parts of a building model (IFC2X3), part 59 of 99

# IfcBuildingElementProxy: Rhino_Object_1629, Object_1629
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15015 m; Area: 0.0147983 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.0985568 m; Elevation to Project Zero: 4.19492 m; Elevation to 1st Reference Level: 4.19492 m; Elevation to 2nd Reference Level: 4.19492 m; Elevation to Sea Level: 13.5349 m; Elevation to Linked/Home Story: 4.19492 m; Home Offset: 4.19492 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25242 m; Top Elevation To Home Story: 4.25242 m; Top Elevation To Project Zero: 4.25242 m; Top Elevation To Sea Level: 13.5924 m; Top Elevation To Second Reference Level: 4.25242 m; Bottom Elevation To First Reference Level: 4.19492 m; Bottom Elevation To Home Story: 4.19492 m; Bottom Elevation To Project Zero: 4.19492 m; Bottom Elevation To Sea Level: 13.5349 m; Bottom Elevation To Second Reference Level: 4.19492 m; Survey Coordinate X: 426584 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.5349 m; Top Surface Area (Net): 0.0147983 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Pset_Rhino_Object_1629 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
AC_Equantity_Rhino_Object_1629 - Dimension 1: 0.15015 m; Dimension 2: 0.0985568 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0985568 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_163, Object_163
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_163; Hotlink and Element ID: Object_163; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_163; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_163; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_163 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.330848 m; Area: 0.0264343 m2; Height: 1.11675 m; Volume (Net): 0.0113577 m3; Width: 0.0798986 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.542875 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426587 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.0264343 m2; Bottom Surface Area (Net): 0.542875 m2
AC_Equantity_Rhino_Object_163 - Dimension 1: 0.330848 m; Dimension 2: 0.0798986 m; Height: 1.11675 m; Bottom Level: -4.03855e-12 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0798986 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0113577 m3; Component, Component Volume (Gross): 0.0113577 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_163_; 109.AMB.CodiTipus: Object_163; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1630, Object_1630
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1630 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1630_; 109.AMB.CodiTipus: Object_1630; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.10463 m; Area: 0.00898444 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0858688 m; Elevation to Project Zero: 3.97018 m; Elevation to 1st Reference Level: 3.97018 m; Elevation to 2nd Reference Level: 3.97018 m; Elevation to Sea Level: 13.3102 m; Elevation to Linked/Home Story: 3.97018 m; Home Offset: 3.97018 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19492 m; Top Elevation To Home Story: 4.19492 m; Top Elevation To Project Zero: 4.19492 m; Top Elevation To Sea Level: 13.5349 m; Top Elevation To Second Reference Level: 4.19492 m; Bottom Elevation To First Reference Level: 3.97018 m; Bottom Elevation To Home Story: 3.97018 m; Bottom Elevation To Project Zero: 3.97018 m; Bottom Elevation To Sea Level: 13.3102 m; Bottom Elevation To Second Reference Level: 3.97018 m; Survey Coordinate X: 426584 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.3102 m; Top Surface Area (Net): 0.00898444 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1630 - Dimension 1: 0.10463 m; Dimension 2: 0.0858688 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0858688 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1630; Hotlink and Element ID: Object_1630; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1630; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1630; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1631, Object_1631
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1631; Hotlink and Element ID: Object_1631; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1631; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1631; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1631 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1631_; 109.AMB.CodiTipus: Object_1631; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147744 m; Area: 0.00866213 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0586292 m; Elevation to Project Zero: 3.92949 m; Elevation to 1st Reference Level: 3.92949 m; Elevation to 2nd Reference Level: 3.92949 m; Elevation to Sea Level: 13.2695 m; Elevation to Linked/Home Story: 3.92949 m; Home Offset: 3.92949 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97018 m; Top Elevation To Home Story: 3.97018 m; Top Elevation To Project Zero: 3.97018 m; Top Elevation To Sea Level: 13.3102 m; Top Elevation To Second Reference Level: 3.97018 m; Bottom Elevation To First Reference Level: 3.92949 m; Bottom Elevation To Home Story: 3.92949 m; Bottom Elevation To Project Zero: 3.92949 m; Bottom Elevation To Sea Level: 13.2695 m; Bottom Elevation To Second Reference Level: 3.92949 m; Survey Coordinate X: 426584 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.2695 m; Top Surface Area (Net): 0.00866213 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1631 - Dimension 1: 0.147744 m; Dimension 2: 0.0586292 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0586292 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1632, Object_1632
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1632; Hotlink and Element ID: Object_1632; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1632; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1632; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1632 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1632_; 109.AMB.CodiTipus: Object_1632; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941367 m; Area: 0.00334263 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0355082 m; Elevation to Project Zero: 3.87199 m; Elevation to 1st Reference Level: 3.87199 m; Elevation to 2nd Reference Level: 3.87199 m; Elevation to Sea Level: 13.212 m; Elevation to Linked/Home Story: 3.87199 m; Home Offset: 3.87199 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92949 m; Top Elevation To Home Story: 3.92949 m; Top Elevation To Project Zero: 3.92949 m; Top Elevation To Sea Level: 13.2695 m; Top Elevation To Second Reference Level: 3.92949 m; Bottom Elevation To First Reference Level: 3.87199 m; Bottom Elevation To Home Story: 3.87199 m; Bottom Elevation To Project Zero: 3.87199 m; Bottom Elevation To Sea Level: 13.212 m; Bottom Elevation To Second Reference Level: 3.87199 m; Survey Coordinate X: 426584 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.212 m; Top Surface Area (Net): 0.00334263 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1632 - Dimension 1: 0.0941367 m; Dimension 2: 0.0355082 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0355082 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1633, Object_1633
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1633; Hotlink and Element ID: Object_1633; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1633; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1633; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1633_; 109.AMB.CodiTipus: Object_1633; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216263 m; Area: 0.0243264 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112485 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30992 m; Top Elevation To Home Story: 4.30992 m; Top Elevation To Project Zero: 4.30992 m; Top Elevation To Sea Level: 13.6499 m; Top Elevation To Second Reference Level: 4.30992 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426584 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0243264 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Pset_Rhino_Object_1633 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
AC_Equantity_Rhino_Object_1633 - Dimension 1: 0.216263 m; Dimension 2: 0.112485 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112485 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1634, Object_1634
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1634; Hotlink and Element ID: Object_1634; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1634; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1634; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1634 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15015 m; Area: 0.0147983 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.0985568 m; Elevation to Project Zero: 4.19492 m; Elevation to 1st Reference Level: 4.19492 m; Elevation to 2nd Reference Level: 4.19492 m; Elevation to Sea Level: 13.5349 m; Elevation to Linked/Home Story: 4.19492 m; Home Offset: 4.19492 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25242 m; Top Elevation To Home Story: 4.25242 m; Top Elevation To Project Zero: 4.25242 m; Top Elevation To Sea Level: 13.5924 m; Top Elevation To Second Reference Level: 4.25242 m; Bottom Elevation To First Reference Level: 4.19492 m; Bottom Elevation To Home Story: 4.19492 m; Bottom Elevation To Project Zero: 4.19492 m; Bottom Elevation To Sea Level: 13.5349 m; Bottom Elevation To Second Reference Level: 4.19492 m; Survey Coordinate X: 426585 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.5349 m; Top Surface Area (Net): 0.0147983 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1634 - Dimension 1: 0.15015 m; Dimension 2: 0.0985568 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0985568 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1634_; 109.AMB.CodiTipus: Object_1634; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1635, Object_1635
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1635 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1635_; 109.AMB.CodiTipus: Object_1635; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.10463 m; Area: 0.00898444 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0858688 m; Elevation to Project Zero: 3.97018 m; Elevation to 1st Reference Level: 3.97018 m; Elevation to 2nd Reference Level: 3.97018 m; Elevation to Sea Level: 13.3102 m; Elevation to Linked/Home Story: 3.97018 m; Home Offset: 3.97018 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19492 m; Top Elevation To Home Story: 4.19492 m; Top Elevation To Project Zero: 4.19492 m; Top Elevation To Sea Level: 13.5349 m; Top Elevation To Second Reference Level: 4.19492 m; Bottom Elevation To First Reference Level: 3.97018 m; Bottom Elevation To Home Story: 3.97018 m; Bottom Elevation To Project Zero: 3.97018 m; Bottom Elevation To Sea Level: 13.3102 m; Bottom Elevation To Second Reference Level: 3.97018 m; Survey Coordinate X: 426585 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.3102 m; Top Surface Area (Net): 0.00898444 m2; Bottom Surface Area (Net): 0.0969053 m2
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1635; Hotlink and Element ID: Object_1635; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1635; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1635; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
5 AMB.Geometria - 502.AMB.Amplada: 0.0858688 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1635 - Dimension 1: 0.10463 m; Dimension 2: 0.0858688 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1636, Object_1636
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1636; Hotlink and Element ID: Object_1636; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1636; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1636; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1636 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1636_; 109.AMB.CodiTipus: Object_1636; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147744 m; Area: 0.00866213 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0586292 m; Elevation to Project Zero: 3.92949 m; Elevation to 1st Reference Level: 3.92949 m; Elevation to 2nd Reference Level: 3.92949 m; Elevation to Sea Level: 13.2695 m; Elevation to Linked/Home Story: 3.92949 m; Home Offset: 3.92949 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97018 m; Top Elevation To Home Story: 3.97018 m; Top Elevation To Project Zero: 3.97018 m; Top Elevation To Sea Level: 13.3102 m; Top Elevation To Second Reference Level: 3.97018 m; Bottom Elevation To First Reference Level: 3.92949 m; Bottom Elevation To Home Story: 3.92949 m; Bottom Elevation To Project Zero: 3.92949 m; Bottom Elevation To Sea Level: 13.2695 m; Bottom Elevation To Second Reference Level: 3.92949 m; Survey Coordinate X: 426585 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.2695 m; Top Surface Area (Net): 0.00866213 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1636 - Dimension 1: 0.147744 m; Dimension 2: 0.0586292 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0586292 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1637, Object_1637
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1637; Hotlink and Element ID: Object_1637; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1637; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1637; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1637 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1637_; 109.AMB.CodiTipus: Object_1637; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941367 m; Area: 0.00334263 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0355082 m; Elevation to Project Zero: 3.87199 m; Elevation to 1st Reference Level: 3.87199 m; Elevation to 2nd Reference Level: 3.87199 m; Elevation to Sea Level: 13.212 m; Elevation to Linked/Home Story: 3.87199 m; Home Offset: 3.87199 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92949 m; Top Elevation To Home Story: 3.92949 m; Top Elevation To Project Zero: 3.92949 m; Top Elevation To Sea Level: 13.2695 m; Top Elevation To Second Reference Level: 3.92949 m; Bottom Elevation To First Reference Level: 3.87199 m; Bottom Elevation To Home Story: 3.87199 m; Bottom Elevation To Project Zero: 3.87199 m; Bottom Elevation To Sea Level: 13.212 m; Bottom Elevation To Second Reference Level: 3.87199 m; Survey Coordinate X: 426585 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.212 m; Top Surface Area (Net): 0.00334263 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1637 - Dimension 1: 0.0941367 m; Dimension 2: 0.0355082 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0355082 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3

# IfcBuildingElementProxy: Rhino_Object_1638, Object_1638
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1638; Hotlink and Element ID: Object_1638; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1638; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1638; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1638 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1638_; 109.AMB.CodiTipus: Object_1638; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216263 m; Area: 0.0243264 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112485 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30992 m; Top Elevation To Home Story: 4.30992 m; Top Elevation To Project Zero: 4.30992 m; Top Elevation To Sea Level: 13.6499 m; Top Elevation To Second Reference Level: 4.30992 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426584 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0243264 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1638 - Dimension 1: 0.216263 m; Dimension 2: 0.112485 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112485 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1639, Object_1639
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1639_; 109.AMB.CodiTipus: Object_1639; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1639 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1639; Hotlink and Element ID: Object_1639; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1639; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1639; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
5 AMB.Geometria - 502.AMB.Amplada: 0.0985568 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1639 - Dimension 1: 0.15015 m; Dimension 2: 0.0985568 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
ArchiCADQuantities - Length (A): 0.15015 m; Area: 0.0147983 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.0985568 m; Elevation to Project Zero: 4.19492 m; Elevation to 1st Reference Level: 4.19492 m; Elevation to 2nd Reference Level: 4.19492 m; Elevation to Sea Level: 13.5349 m; Elevation to Linked/Home Story: 4.19492 m; Home Offset: 4.19492 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25242 m; Top Elevation To Home Story: 4.25242 m; Top Elevation To Project Zero: 4.25242 m; Top Elevation To Sea Level: 13.5924 m; Top Elevation To Second Reference Level: 4.25242 m; Bottom Elevation To First Reference Level: 4.19492 m; Bottom Elevation To Home Story: 4.19492 m; Bottom Elevation To Project Zero: 4.19492 m; Bottom Elevation To Sea Level: 13.5349 m; Bottom Elevation To Second Reference Level: 4.19492 m; Survey Coordinate X: 426587 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.5349 m; Top Surface Area (Net): 0.0147983 m2; Bottom Surface Area (Net): 0.053125 m2

# IfcBuildingElementProxy: Rhino_Object_164, Object_164
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_164; Hotlink and Element ID: Object_164; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_164; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_164; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_164 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_164_; 109.AMB.CodiTipus: Object_164; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.015273 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.693152 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426589 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693152 m2
AC_Equantity_Rhino_Object_164 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: 0 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.015273 m3; Component, Component Volume (Gross): 0.015273 m3

# IfcBuildingElementProxy: Rhino_Object_1640, Object_1640
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1640 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1640; Hotlink and Element ID: Object_1640; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1640; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1640; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1640_; 109.AMB.CodiTipus: Object_1640; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.10463 m; Area: 0.00898444 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0858688 m; Elevation to Project Zero: 3.97018 m; Elevation to 1st Reference Level: 3.97018 m; Elevation to 2nd Reference Level: 3.97018 m; Elevation to Sea Level: 13.3102 m; Elevation to Linked/Home Story: 3.97018 m; Home Offset: 3.97018 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19492 m; Top Elevation To Home Story: 4.19492 m; Top Elevation To Project Zero: 4.19492 m; Top Elevation To Sea Level: 13.5349 m; Top Elevation To Second Reference Level: 4.19492 m; Bottom Elevation To First Reference Level: 3.97018 m; Bottom Elevation To Home Story: 3.97018 m; Bottom Elevation To Project Zero: 3.97018 m; Bottom Elevation To Sea Level: 13.3102 m; Bottom Elevation To Second Reference Level: 3.97018 m; Survey Coordinate X: 426586 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.3102 m; Top Surface Area (Net): 0.00898444 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1640 - Dimension 1: 0.10463 m; Dimension 2: 0.0858688 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 0.0858688 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3

# IfcBuildingElementProxy: Rhino_Object_1641, Object_1641
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1641; Hotlink and Element ID: Object_1641; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1641; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1641; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1641_; 109.AMB.CodiTipus: Object_1641; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147744 m; Area: 0.00866213 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0586292 m; Elevation to Project Zero: 3.92949 m; Elevation to 1st Reference Level: 3.92949 m; Elevation to 2nd Reference Level: 3.92949 m; Elevation to Sea Level: 13.2695 m; Elevation to Linked/Home Story: 3.92949 m; Home Offset: 3.92949 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97018 m; Top Elevation To Home Story: 3.97018 m; Top Elevation To Project Zero: 3.97018 m; Top Elevation To Sea Level: 13.3102 m; Top Elevation To Second Reference Level: 3.97018 m; Bottom Elevation To First Reference Level: 3.92949 m; Bottom Elevation To Home Story: 3.92949 m; Bottom Elevation To Project Zero: 3.92949 m; Bottom Elevation To Sea Level: 13.2695 m; Bottom Elevation To Second Reference Level: 3.92949 m; Survey Coordinate X: 426587 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 13.2695 m; Top Surface Area (Net): 0.00866213 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Pset_Rhino_Object_1641 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 0.0586292 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
AC_Equantity_Rhino_Object_1641 - Dimension 1: 0.147744 m; Dimension 2: 0.0586292 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m

# IfcBuildingElementProxy: Rhino_Object_1642, Object_1642
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1642; Hotlink and Element ID: Object_1642; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1642; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1642; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1642 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1642_; 109.AMB.CodiTipus: Object_1642; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
