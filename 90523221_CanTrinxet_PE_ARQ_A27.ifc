Properties of the parts of a building model (IFC2X3), part 22 of 99

# IfcBuildingElementProxy: Rhino_Object_1091, Object_1091
AC_Pset_Rhino_Object_1091 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg

# IfcBuildingElementProxy: Rhino_Object_1092, Object_1092
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Equantity_Rhino_Object_1092 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
AC_Pset_Rhino_Object_1092 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1092_; 109.AMB.CodiTipus: Object_1092; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1092; Hotlink and Element ID: Object_1092; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1092; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1092; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_1093, Object_1093
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1093; Hotlink and Element ID: Object_1093; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1093; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1093; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1093_; 109.AMB.CodiTipus: Object_1093; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_1093 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1093 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1094, Object_1094
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1094_; 109.AMB.CodiTipus: Object_1094; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1094 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1094; Hotlink and Element ID: Object_1094; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1094; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1094; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1094 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1095, Object_1095
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1095; Hotlink and Element ID: Object_1095; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1095; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1095; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1095_; 109.AMB.CodiTipus: Object_1095; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_1095 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1095 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1096, Object_1096
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1096 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1096_; 109.AMB.CodiTipus: Object_1096; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1096; Hotlink and Element ID: Object_1096; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1096; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1096; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1096 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1097, Object_1097
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1097; Hotlink and Element ID: Object_1097; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1097; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1097; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1097 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1097_; 109.AMB.CodiTipus: Object_1097; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1097 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1098, Object_1098
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1098 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1098; Hotlink and Element ID: Object_1098; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1098; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1098; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1098_; 109.AMB.CodiTipus: Object_1098; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1098 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1099, Object_1099
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1099; Hotlink and Element ID: Object_1099; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1099; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1099; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1099_; 109.AMB.CodiTipus: Object_1099; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_1099 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
AC_Equantity_Rhino_Object_1099 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m

# IfcBuildingElementProxy: Rhino_Object_110, Object_110
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_110; Hotlink and Element ID: Object_110; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_110; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_110; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_110 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_110_; 109.AMB.CodiTipus: Object_110; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426578 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_110 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1100, Object_1100
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1100; Hotlink and Element ID: Object_1100; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1100; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1100; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1100_; 109.AMB.CodiTipus: Object_1100; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_1100 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1100 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m

# IfcBuildingElementProxy: Rhino_Object_1101, Object_1101
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1101; Hotlink and Element ID: Object_1101; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1101; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1101; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1101 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1101_; 109.AMB.CodiTipus: Object_1101; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1101 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1102, Object_1102
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1102; Hotlink and Element ID: Object_1102; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1102; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1102; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1102 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1102_; 109.AMB.CodiTipus: Object_1102; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1102 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1103, Object_1103
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1103; Hotlink and Element ID: Object_1103; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1103; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1103; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1103 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1103_; 109.AMB.CodiTipus: Object_1103; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1103 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1104, Object_1104
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1104; Hotlink and Element ID: Object_1104; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1104; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1104; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1104 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1104_; 109.AMB.CodiTipus: Object_1104; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1104 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1105, Object_1105
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1105; Hotlink and Element ID: Object_1105; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1105; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1105; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1105_; 109.AMB.CodiTipus: Object_1105; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Pset_Rhino_Object_1105 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1105 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1106, Object_1106
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
