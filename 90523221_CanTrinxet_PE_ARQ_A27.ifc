Properties of the parts of a building model (IFC2X3), part 7 of 99

# IfcBuildingElementProxy: Concrete 40-20 (2) 160 (24)
Name | Element ID = Hotlink and Element ID = Parent ID | Surfaces (All) | Number of Openings | Insulation - Mineral Soft, Embodied Carbon | Insulation - Mineral Soft, Embodied Energy (MJ) | Number of Doors | Number of Windows | Maximum Height of the Wall Skin on the Inside Face (m) = Maximum Height of the Wall (m) = Maximum Height of the Wall Skin on the Outside Face (m) | Minimum Height of the Wall Skin on the Inside Face (m) = Minimum Height of the Wall (m) = Minimum Height of the Wall Skin on the Outside Face (m) | Area of the Doors (m2) | Combined Width of Doors (m) | Area of the Windows (m2) | Combined Width of Windows (m) | Wall Component Volume on the Inside Face (Net) (m3) = Wall Component Volume on the Outside Face (Net) (m3) = Volume (Net) (m3) = Insulation - Mineral Soft, Component Volume (Net) (m3) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Surface Area of the Wall Inside Face (Conditional) (m2) | Length of the Wall Outside Face (Conditional) (m) | Surface Area of the Wall Outside Face (Conditional) (m2) | Volume of the Wall Inside Face Component (Conditional) (m3) = Volume of the Wall Outside Face Component (Conditional) (m3) = Volume (Conditional) (m3) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = 503.AMB.Altura (m) = Insulation - Mineral Soft, Rectangular Component Height (m) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Insulation - Mineral Soft, Mass (kg) | Insulation - Mineral Soft, Projected Component Area (Net) (m2) | Insulation - Mineral Soft, Projected Component Area (Gross) (m2) | Insulation - Mineral Soft, Component Cross Section Area (m2) | Insulation - Mineral Soft, Component Volume (Gross) (m3)
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 786.185 (kgCO₂) | 10409.7 | 0 | 14 | 5.84127 | 0 | 0 | 0 | 12.1606 | 7.12115 | 18.1987 | 12.1606 | 12.1606 | 22.0347 | 113.283 | 114.201 | 1.94569 | 22.8428 | 22.0337 | 125.444 | 22.0358 | 126.361 | 20.1444 | 132.226 | 133.16 | 22.0337 | 22.0358 | 3.52556 | 5.94169 | 22.0454 | 21.2308 | 44.3902 | 6.11127 | 15.4513 | 7.11416 | 727.949 | 114.257 | 127.27 | 0.950671 | 20.281
F1 | F1 | Paint - Anthracite; Insulation - Cellulose | 0 | 454.147 (kgCO₂) | 6013.25 | 1 | 4 | 4.41784 | 0 | 6.24 | 2.4 | 2.19506 | 1.71456 | 10.5127 | 8.43506 | 8.43506 | 16.9922 | 66.4468 | 65.1699 | 1.34961 | 17.1674 | 14.563 | 68.6418 | 14.6214 | 67.365 | 11.8623 | 78.7162 | 77.1535 | 16.963 | 17.0214 | 2.31569 | 4.49332 | 16.963 | 12.4694 | 34.3147 | 4.68784 | 14.0278 | 5.8065 | 420.507 | 66.4468 | 74.8818 | 0.718931 | 11.8623

# IfcBuildingElementProxy: Concrete 80 (2)
In: planta baixa
Classification: 30.20.10 Cobertes (GuBIMclass CA); Material: Concrete
ArchiCADProperties - Geometry Method: Single-plane; Pitch: 18 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: Cu1; Hotlink and Element ID: Cu1; Layer: 00_CLT; Building Material / Composite / Profile / Fill: Concrete; Building Material: Concrete; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Roof; Structure Type: Basic; Parent ID: Cu1; Building Materials (All): Concrete; Surfaces (All): Brick - Aged Natural; Concrete - Bush hammered; Cover Fill: Roof Tile 01; Edge Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 107.AMB.NomTipus: Cu1_CobertaInclinadaR60; 109.AMB.CodiTipus: Cu1; 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: CobertaInclinadaR60
Pset_BuildingElementProxyCommon - Status: NEW
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
5 AMB.Geometria - 503.AMB.Altura: 0.08 m; 504.AMB.Gruix: 0.08 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.08 m; Vertical Thickness: 0.084117 m; Height: 0.08 m; Elevation to Project Zero: 4.06656 m; Elevation to 1st Reference Level: 4.06656 m; Elevation to 2nd Reference Level: 4.06656 m; Elevation to Sea Level: 13.4066 m; Elevation to Linked/Home Story: 4.06656 m; Home Offset: 4.06656 m; Top Elevation To First Reference Level: 4.46037 m; Top Elevation To Home Story: 4.46037 m; Top Elevation To Project Zero: 4.46037 m; Top Elevation To Sea Level: 13.8004 m; Top Elevation To Second Reference Level: 4.46037 m
Component Quantities - Concrete, Component Thickness: 0.08 m
Name | Concrete, Embodied Carbon | Concrete, Embodied Energy (MJ) | Surface Area of the Roof Bottom (Gross) (m2) = Surface Area of the Roof Bottom (Net) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Surface Area of the Roof Top (Gross) (m2) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Concrete, Mass (kg) | Concrete, Projected Component Area (Net) (m2) = Concrete, Projected Component Area (Gross) (m2) | Concrete, Component Volume (Net) (m3) = Concrete, Component Volume (Gross) (m3)
Cu1 | 66.4575 (kgCO₂) | 459.612 | 4.31317 | 0.826619 | 4.31319 | 4.02969 | 13.3697 | 621.098 | 4.41318 | 0.345054
Cu1 | 65.9796 (kgCO₂) | 456.307 | 4.28215 | 0.82533 | 4.28218 | 4.03218 | 13.3722 | 616.632 | 4.38217 | 0.342573

# IfcBuildingElementProxy: Concrete fundacion 1500 (48)
In: planta baixa
Classification: 20.10 Fonaments i contenció de terres (GuBIMclass CA)
ArchiCADProperties - Reference Plane Location: Top; Layer: 00_FUNDACIONES; Building Material / Composite / Profile / Fill: Concrete fundacion; Composite Structure: Concrete fundacion; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Composite; Building Materials (All): Concrete - Structural; Concrete; Cover Fill: Background; Number of Openings: 0; Top Surface: Concrete - Smooth Finish; Edge Surface: Concrete - Smooth Finish; Bottom Surface: Concrete - Smooth Finish; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 20.10 Fonaments i contenció de terres; 104.AMB.ClassificacioCodi: 20.10; 105.AMB.ClassificacioDescripcio: Fonaments i contenció de terres; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Si
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 20; AUX_107.NomTipus: FonamentsFormigo
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Height: 1.5 m; Thickness: 1.5 m; Floor Plan Holes Perimeter: 0 m
5 AMB.Geometria - 503.AMB.Altura: 1.5 m; 504.AMB.Gruix: 1.5 m; 506.AMB.Profunditat: 0 m
Name | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Surfaces (All) | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | Elevation Bottom (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Surface Area of the Slab Top (Conditional) (m2) = Area (m2) = Surface Area (m2) = Top Surface Area (Net) (m2) = Top Surface Area (Conditional) (m2) | Surface Area of the Slab Bottom (Gross) (m2) = Surface Area of the Slab Bottom (Gross, with holes) (m2) = Surface Area of the Slab Top (Gross) (m2) = Surface Area of the Slab Top (Gross, with holes) (m2) = Bottom Surface Area (Gross) (m2) = Top Surface Area (Gross) (m2) | Surface Area of the Slab Edges (Gross) (m2) = Surface Area of the Slab Edges (Gross, with holes) (m2) = Edge Surface Area (Gross) (m2) | Holes Surface Area (m2) | Elevation Top (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Volume (Net) (m3) = Volume (Conditional) (m3) | Elevation to Sea Level (m) = Top Elevation To Sea Level (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Bottom Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) = Bottom Surface Area (Conditional) (m2)
20 x FO1 | FO1 | Concrete - Smooth Finish | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.54 | 0.54 | 4.95 | 0 | -0.22 | 0.81 | 9.12 | 0.81 | 3.3 | 7.62 | 4.95 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539949 | 0.54 | 4.95 | 0.0000510327 | -0.22 | 0.809962 | 9.12 | 0.81 | 3.3 | 7.62 | 4.76169 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539934 | 0.54 | 4.95 | 0.0000658875 | -0.22 | 0.809951 | 9.12 | 0.81 | 3.3 | 7.62 | 4.73603 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539695 | 0.54 | 4.95 | 0.00030451 | -0.22 | 0.809775 | 9.12 | 0.81 | 3.3 | 7.62 | 4.61686 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539949 | 0.54 | 4.95 | 0.0000511513 | -0.22 | 0.809962 | 9.12 | 0.81 | 3.3 | 7.62 | 4.76147 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539942 | 0.54 | 4.95 | 0.0000580453 | -0.22 | 0.809957 | 9.12 | 0.81 | 3.3 | 7.62 | 4.74917 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539944 | 0.54 | 4.95 | 0.0000555744 | -0.22 | 0.809959 | 9.12 | 0.81 | 3.3 | 7.62 | 4.75349 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539976 | 0.54 | 4.95 | 0.0000242357 | -0.22 | 0.809982 | 9.12 | 0.81 | 3.3 | 7.62 | 4.77621 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539986 | 0.54 | 4.95 | 0.0000144475 | -0.22 | 0.809989 | 9.12 | 0.81 | 3.3 | 7.62 | 4.78282 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.538391 | 0.54 | 4.95 | 0.00160945 | -0.22 | 0.808812 | 9.12 | 0.81 | 3.3 | 7.62 | 4.61258 | 0.54
FO3 | FO3 | Concrete - Smooth Finish; Concrete - Bush hammered | FO3_FonamentsFormigo | Fonaments a l'Annex | Annex | -0.8 | 0.482876 | 0.482912 | 4.56942 | 0.0000361908 | 0.7 | 0.724338 | 10.04 | 0.724369 | 3.04628 | 8.54 | 4.3031 | 0.482912 | ArchiCADProperties - Colliding Zones: Instal·lacions; Nau Annexa
FO3 | FO3 | Concrete - Smooth Finish | FO3_FonamentsFormigo | Fonaments a l'Annex | Annex | -0.8 | 0.482912 | 0.482912 | 4.56942 | 0 | 0.7 | 0.724369 | 10.04 | 0.724369 | 3.04628 | 8.54 | 4.56942 | 0.482912 | ArchiCADProperties - Colliding Zones: Instal·lacions; Nau Annexa
FO3 | FO3 | Concrete - Smooth Finish; Concrete - Bush hammered | FO3_FonamentsFormigo | Fonaments a l'Annex | Annex | -0.8 | 1.2512 | 1.25138 | 9.69251 | 0.000178839 | 0.7 | 1.87691 | 10.04 | 1.87706 | 6.46167 | 8.54 | 9.30927 | 1.25138 | ArchiCADProperties - Colliding Zones: Instal·lacions; Lavabo; Nau Annexa
FO3 | FO3 | Concrete - Smooth Finish; Concrete - Bush hammered | FO3_FonamentsFormigo | Fonaments a l'Annex | Annex | -0.8 | 0.53764 | 0.54 | 4.95 | 0.00235972 | 0.7 | 0.807994 | 10.04 | 0.81 | 3.3 | 8.54 | 3.92649 | 0.54 | ArchiCADProperties - Colliding Zones: Lavabo; Nau Annexa
FO3 | FO3 | Concrete - Smooth Finish | FO3_FonamentsFormigo | Fonaments a l'Annex | Annex | -0.8 | 0.54 | 0.54 | 4.95 | 0 | 0.7 | 0.81 | 10.04 | 0.81 | 3.3 | 8.54 | 4.95 | 0.54 | ArchiCADProperties - Colliding Zones: Lavabo; Nau Annexa
FO4 | FO4 | Concrete - Smooth Finish; Concrete - Bush hammered | FO4_FonamentsFormigo | Fonaments a la Nau Lateral Sud | Nau Lateral | -0.275747 | 5.24644 | 5.25199 | 14.6828 | 0.00555289 | 1.22425 | 7.86966 | 10.5643 | 7.87799 | 9.78851 | 9.06425 | 12.2888 | 5.24644 | ArchiCADProperties - Colliding Zones: Nau Lateral; Sala d'actes; Sala de reunions
FO4 | FO4 | Concrete - Smooth Finish | FO4_FonamentsFormigo | Fonaments a la Nau Lateral Sud | Nau Lateral | -0.275747 | 1.43866 | 1.43866 | 7.19664 | 0 | 1.22425 | 2.15799 | 10.5643 | 2.15799 | 4.79776 | 9.06425 | 7.19664 | 1.43866 | ArchiCADProperties - Colliding Zones: Distribuïdor; Nau Lateral; Sala d'actes; Sala de reunions
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539937 | 0.54 | 4.95 | 0.0000634789 | -0.22 | 0.809953 | 9.12 | 0.81 | 3.3 | 7.62 | 4.73998 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539981 | 0.54 | 4.95 | 0.0000187403 | -0.22 | 0.809986 | 9.12 | 0.81 | 3.3 | 7.62 | 4.75959 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539923 | 0.54 | 4.95 | 0.0000767763 | -0.22 | 0.809943 | 9.12 | 0.81 | 3.3 | 7.62 | 4.61761 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539932 | 0.54 | 4.95 | 0.0000684083 | -0.22 | 0.80995 | 9.12 | 0.81 | 3.3 | 7.62 | 4.73197 | 0.54
FO4 | FO4 | Concrete - Smooth Finish | FO4_FonamentsFormigo | Fonaments a la Nau Lateral Sud | Nau Lateral | -0.275747 | 1.43866 | 1.43866 | 7.19664 | 0 | 1.22425 | 2.15799 | 10.5643 | 2.15799 | 4.79776 | 9.06425 | 7.19664 | 1.43866 | ArchiCADProperties - Colliding Zones: Distribuïdor; Nau Lateral; Sala de reunions
FO4 | FO4 | Concrete - Smooth Finish | FO4_FonamentsFormigo | Fonaments a la Nau Lateral Sud | Nau Lateral | -0.275747 | 4.42662 | 4.42662 | 14.6478 | 0 | 1.22425 | 6.63993 | 10.5643 | 6.63993 | 9.76523 | 9.06425 | 14.6478 | 4.42662 | ArchiCADProperties - Colliding Zones: Nau Lateral; Sala d'actes
FO4 | FO4 | Concrete - Smooth Finish | FO4_FonamentsFormigo | Fonaments a la Nau Lateral Sud | Nau Lateral | -0.275747 | 1.43866 | 1.43866 | 7.19664 | 0 | 1.22425 | 2.15799 | 10.5643 | 2.15799 | 4.79776 | 9.06425 | 7.19664 | 1.43866 | ArchiCADProperties - Colliding Zones: Nau Lateral; Sala de reunions
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539934 | 0.54 | 4.95 | 0.000065912 | -0.22 | 0.809951 | 9.12 | 0.81 | 3.3 | 7.62 | 4.73599 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539986 | 0.54 | 4.95 | 0.000014465 | -0.22 | 0.809989 | 9.12 | 0.81 | 3.3 | 7.62 | 4.78271 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539934 | 0.54 | 4.95 | 0.0000658854 | -0.22 | 0.809951 | 9.12 | 0.81 | 3.3 | 7.62 | 4.73603 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539937 | 0.54 | 4.95 | 0.0000634458 | -0.22 | 0.809953 | 9.12 | 0.81 | 3.3 | 7.62 | 4.74003 | 0.54
FO1 | FO1 | Concrete - Smooth Finish; Concrete - Bush hammered | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | -1.72 | 0.539986 | 0.54 | 4.95 | 0.0000144245 | -0.22 | 0.809989 | 9.12 | 0.81 | 3.3 | 7.62 | 4.78295 | 0.54

# IfcBuildingElementProxy: Cu4 380, Cu4
In: planta coberta
Classification: 30.20.10 Cobertes (GuBIMclass CA)
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 107.AMB.NomTipus: Cu4_ Coberta plana; 109.AMB.CodiTipus: Cu4; 111.AMB.DescripcioTipus: Paviment transitable sobre sistema d’aïllament i impermeabilització, amb llosa CLT; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
ArchiCADProperties - Reference Plane Location: Bottom; Element ID: Cu4; Hotlink and Element ID: Cu4; Layer: 00_CLT; Building Material / Composite / Profile / Fill: Cu4; Composite Structure: Cu4; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Slab; Structure Type: Composite; Parent ID: Cu4; Building Materials (All): Tile - Wall; Concrete; Insulation - Mineral Soft; Timber - Structural; Surfaces (All): Paint - Anthracite; Wood - Pine Grained Horizontal; Tiles - White Matte 15x15; Insulation - Cellulose; Tiles - Red 30x30; Concrete - Bush hammered; Cover Fill: Grid 20x20; Number of Openings: 0; Top Surface: Tiles - Red 30x30; Bottom Surface: Paint - Anthracite; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
5 AMB.Geometria - 503.AMB.Altura: 0.38 m; 504.AMB.Gruix: 0.38 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Elevation Bottom: 5.27425 m; Surface Area of the Slab Top (Conditional): 22.505 m2; Surface Area of the Slab Bottom (Gross): 23.6978 m2; Surface Area of the Slab Bottom (Gross, with holes): 23.6978 m2; Surface Area of the Slab Edges (Gross): 7.42386 m2; Surface Area of the Slab Edges (Gross, with holes): 7.42386 m2; Surface Area of the Slab Top (Gross): 23.6978 m2; Surface Area of the Slab Top (Gross, with holes): 23.6978 m2; Holes Surface Area: 0 m2; Elevation Top: 5.65425 m; Area: 22.505 m2; Height: 0.38 m; Volume (Net): 8.59638 m3; Elevation to Project Zero: 5.27425 m; Elevation to 1st Reference Level: 5.27425 m; Elevation to 2nd Reference Level: 5.27425 m; Elevation to Sea Level: 14.6143 m; Elevation to Linked/Home Story: 0.774253 m; Home Offset: 0.774253 m; Surface Area: 22.505 m2; Thickness: 0.38 m; Volume (Conditional): 8.59638 m3; Volume (Gross): 9.00515 m3; Floor Plan Perimeter: 19.5365 m; Floor Plan Holes Perimeter: 0 m; Top Elevation To First Reference Level: 5.65425 m; Top Elevation To Home Story: 1.15425 m; Top Elevation To Project Zero: 5.65425 m; Top Elevation To Sea Level: 14.9943 m; Top Elevation To Second Reference Level: 5.65425 m; Bottom Elevation To First Reference Level: 5.27425 m; Bottom Elevation To Home Story: 0.774253 m; Bottom Elevation To Project Zero: 5.27425 m; Bottom Elevation To Sea Level: 14.6143 m; Bottom Elevation To Second Reference Level: 5.27425 m; Top Surface Area (Net): 22.505 m2; Top Surface Area (Conditional): 22.505 m2; Edge Surface Area (Net): 7.42386 m2; Bottom Surface Area (Net): 22.991 m2; Bottom Surface Area (Conditional): 22.991 m2; Bottom Surface Area (Gross): 23.6978 m2; Edge Surface Area (Gross): 7.42386 m2; Top Surface Area (Gross): 23.6978 m2
Pset_BuildingElementProxyCommon - Status: NEW
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Coberta plana
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No

# IfcBuildingElementProxy: Door 27 (9)
In: planta baixa
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0; Status: NEW
ArchiCADProperties - Marker Text: <Custom Text>; Opening Library Part Name: Door 27; Opening Side Fill Index: Background; Layer: 00_TABIQUE; Library Part Name: Door 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Door; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Door_27 - Wall Contours (0-None,1-Full,2-Side,3-Length): 0; Hotspots 0-None,1-2D,2-3D,3-All: 3; Show 2D Hotspots in 3D: yes; Floor Plan Display Option: 3; Hole Position Angle: 0 deg; Hole has Wall's Side Surface: yes; Hole Surface's Split is Curved in Curved Walls: no; Wall Type: 1; Reveal Anchor Position: 1; Flip: no; Demolition / New construction: 1; New Wall Fill Type: Masonry Block; New Wall Fill Pen: General - General; New Wall Fill Background Pen: Backgrounds - color 1; Show new construction on Wall: no; Demolition line type: 1; Show Demolition/New parameter: no; Display as Transom: no; Sidelight (gs_SidelightTransomRelation): Under Transom; Sidelight (gs_SidelightTransomRelation_m): 1; Sidelight 1: no; Sidelight 2: no; Transom: no; Uniform Tolerances: yes; Nominal Size: 0; Set Wallhole Size as Nominal Size: yes; Set Reveal Size as Nominal Size: no; Set Unit Size as Nominal Size: no; Set Egress Size as Nominal Size: no; Set Leaf Size as Nominal Size: no; Transfer Current Nominal Size to Selection: no; Show Editable Hotspots: yes; Show Reveal on Symbol: 1; Symbolic Display of Opening: no; 3D Detail Level: 8; Opening Direction Sidelight (gs_opening_dir_sl): Opposite to Leaf; Opening Direction Sidelight (gs_opening_dir_sl_m): 2; Door Frame (gs_pocket_door_frame): yes; Frame Thickness=Wall Thickness: no; Uniform Frame Thickness: yes; Centered Leaf: yes; Frame Style Changed Automatically: no; Number of Door Leaves: 4; Number of Door Leaves - Side 2: 3; Leaves Configuration (gs_LeavesConfig): Uniform Leaves; Leaves Configuration (gs_iLeavesConfig): 1; Grid Position (gs_grill_pos): Throughout; Grid Position (gs_grill_pos_m): 3; Panes Number Vertically: 4; Panes Number Horizontally: 3; Panes Number Vertically Side 1: 4; Panes Number Horizontally Side 1: 3; Show as Glass Panel on Symbol: no; Show Chinese Spring Door Symbol: no; Show Symbol as Airtight Panel: no; Show Handle on Symbol: no; Kick Board Outside (bKickBoardOut): no; Kick Board Inside (bKickBoardIn): no; Uniform Sashes: no; Opening Type (gs_optype_m_05): 3; Opening Type (gs_optype_m_09): 3; Opening Type (gs_optype_m_02): 1; Opening Type (gs_optype_m_06): 1; Opening Type (gs_optype_m_10): 1; Sash Type (MullionStyle_00): No Grid; Sash Type (iMullionStyle_00): 1; Sash Type (iMullionStyle_05): 1; Sash Type (iMullionStyle_09): 1; Sash Type (iMullionStyle_02): 1; Sash Type (iMullionStyle_06): 1; Sash Type (iMullionStyle_10): 1; Hotspot Grill Editing: yes; Grid Position (MullionPosition): Throughout; Grid Position (iMullionPosition): 3; Panes Number Vertically Main Sash Side 1: 4; Panes Number Horizontally Main Sash Side 1: 2; Panes Number Vertically 2 Main Sash Side 1: 4; Panes Number Horizontally 2 Main Sash Side 1: 2; Panes Number Vertically Main Sash Side 2: 4; Panes Number Horizontally Main Sash Side 2: 2; Panes Number Vertically 2 Main Sash Side 2: 4; Panes Number Horizontally 2 Main Sash Side 2: 2; Panes Number Vertically Middle Transom: 2; Panes Number Horizontally Middle Transom: 2; Panes Number Vertically 2 Middle Transom: 2; Panes Number Horizontally 2 Middle Transom: 2; Panes Number Vertically Transom Side 1: 2; Panes Number Horizontally Transom Side 1: 2; Panes Number Vertically 2 Transom Side 1: 2; Panes Number Horizontally 2 Transom Side 1: 2; Panes Number Vertically Transom Side 2: 2; Panes Number Horizontally Transom Side 2: 2; Panes Number Vertically 2 Transom Side 2: 2; Panes Number Horizontally 2 Transom Side 2: 2; Casing Outside: no; Casing Type Outside (gs_trimtype_out): Simple; Casing Type Outside (gs_trimtype_out_int): 1; Outside Casing Head Type: 1; Architrave Capital: yes; Architrave Capital Type: 1; Cover Outer Wall Surface: yes; Uniform Casing Widths (gs_trim_outside_uniform): yes; Casing Inside: no; Casing Type Inside (gs_trimtype_in): Simple; Casing Type Inside (gs_trimtype_in_int): 1; Cover Inner Wall Surface: yes; Uniform Casing Widths (gs_trim_inside_uniform): yes; Threshold (bThreshold): no; Threshold Type: 2; Threshold Angle: 3.1996 deg; Threshold Changed Automatically: no; Sill - Door: no; Sill - Sidelight Side 1: no; Sill - Sidelight Side 2: no; Sill Oversize: no; Type of the Sill: 1; Sill Angle: 3 deg; Sill is Curved in Curved Walls: yes; Insulation below Sill: yes; Use Wall Insulation Skin: no; Brick Sill 3D Detail Level: 1; Sill Style Changed Automatically: no; Board - Sidelight Side 1: no; Board - Sidelight Side 2: no; Board - Door: no; Board Angle: 0 deg; Board is Curved in Curved Walls: yes; Board in Polygonal Walls: 1; Natural Ventilation: no; Natural Ventilation Type: 2; Sunshade: no; Sunshade Type: 1; Enabled Sunshade Types: 126; Number of Panels: 2; Number of Panels 2: 1; Panel Position (gs_shutter_panelPos): Symmetric; Panel Position (gs_shutter_iPanelPos): 1; Automatic Shutter Height: yes; Extra Frame: no; Cover Type (gs_slidingShutter_cover): Z-Profile; Cover Type (gs_slidingShutter_iCover): 1; Stacking Direction (gs_foldingShutter_stacking): Inside; Stacking Direction (gs_foldingShutter_iStacking): 1; Open in 3D: yes; 3D Opening Angle: 180 deg; Show 2D Symbol: yes; Show Opening Lines on Symbol: no; Panel Type (gs_shutPanel_type): Style 1; Panel Type (gs_shutPanel_iType): 1; Different Bottom Frame Width: no; Automatic Shutter Width: yes; Louver Angle: 30 deg; Holes Number Horizontal: 5; Holes Number Vertical: 8; Rolling Shutter Placement (gs_shutRoll_placement): On Facade; Rolling Shutter Placement (gs_shutRoll_iPlacement): 1; Box Type (gs_shutRoll_boxType): Rectangular; Box Type (gs_shutRoll_iBoxType): 1; Rail Position (gs_shutRoll_railPos): On Casing; Rail Position (gs_shutRoll_iRailPos): 1; Show Casing behind Sunshade (gs_shutRoll_showCasingBehind): no; Insulation behind Box (gs_shutRoll_cutWallBehind): no; Include Height in Wallhole Height: no; Box Top Angle: 10 deg; Box Default Width (gs_shutRoll_boxDefaultSize): Reveal Width; Box Default Width (gs_shutRoll_iBoxDefaultSize): 1; Venetian Blinds Placement (gs_shutLam_placement): Fixed on Facade; Venetian Blinds Placement (gs_shutLam_iPlacement): 1; Insulation behind Box (gs_shutLam_cutWallBehind): no; Opened Box: yes; Rail (gs_shutLam_bRail): yes; Rail Position (gs_shutLam_railPos): On Casing; Rail Position (gs_shutLam_iRailPos): 1; Show Casing behind Sunshade (gs_shutLam_showCasingBehind): no; Rotation Angle of Slats (gs_shutLam_rotation): 45 deg; Rotation Angle of Slats (gs_shutLam2_rotation): 45 deg; Masonry Arch (bMasonryArch): no; Masonry Arch (gs_masonry_arch_int): 2; Masonry Arch Type (gs_masonry_arch_structure): Stucco Arch; Masonry Arch Type (gs_masonry_arch_structure_int): 1; Arch on Header: yes; Niche below Arch: yes; Skewback Angle: 75 deg; Custom Niche Surface: no; Set Jamb Depth on Side: 1; Uniform Jamb Depth: yes; Outer Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleOuterTypeInt): 0; Inner Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleInnerTypeInt): 0; Angle Side 2: 20 deg; Angle Side: 20 deg; Upper Side Angle: 20 deg; Bottom Side Angle: 20 deg; Outer Angle Side 2: 20 deg; Outer Angle Side: 20 deg; Outer Angle Upper Side: 20 deg; Outer Angle Bottom Side: 20 deg; Rail under Leaves: no; Use Wall Finish Component: no; Turn Inside Face Plaster: 0; Turn Outside Face Plaster: 0; Dimensionable on 2D: no; Show in 3D: no; Closure Type (gs_closure_type): No Closure; Closure Type (gs_closure_type_int): 1; Turn Skin on Side (gs_cavity_side): Both; Turn Skin on Side (iCavityClosureSide): 1; Number of Skins to Turn: 1; Number from (gs_nTurnDir): Outside Face; Number from (iCavityClosureTurnDir): 1; Place Closer on Side 1: yes; Place Closer on Side 2: yes; Place Closer on Top: no; Place Closer on Bottom: no; Place Closer to Skin: 1; Place Closer from Side (gs_cc_dutch_ClosureToSide): 1; Gap at Outside Skin: yes; Turn Skin to Closer: no; Insert Insulation Strip: yes; Show Insulation Strip: yes; Contour Pen (gs_penJoint): Openings - Cut Non-Structural; Contour Line Type (gs_ltJoint): 1; Fill Type (gs_fillJoint): Rigid Insulation; Fill Pen (gs_penJointFg): General - General; Fill Background Pen (gs_penJointBg): 2D Elements - Drafting; Custom Surface: no; Surface: Wood - Pine Grained Horizontal; Contour Pen (gs_penPlug): Openings - Cut Non-Structural; Contour Line Type (gs_ltPlug): 1; Fill Type (gs_fillPlug): Rigid Insulation; Fill Pen (gs_penPlugFg): General - General; Fill Background Pen (gs_penPlugBg): 2D Elements - Drafting; Edited Jamb Side: 1; Edited Wall Side: 1; Edited Skin Number: 1; Turn-in Skin: no; Consider Skin as Plaster: no; Turn-in Thickness: 1; Hatch Orientation: 1; Separating Line at Turn-in: no; Separating Line Pen: General - General; Last Selected Side: no; Closure Method Changed Automatically: no; Connection on Side 1: no; Connection on Side 2: no; Connection on the Top: no; Opening Type (gs_leaf_optype): Side Hung; Opening Type (gs_leaf_optype_m): 1; End Panel Opening Side 1: no; End Panel Opening Side 2: no; Opening Angle in 2D: 90 deg; Opening Angle in 2D on Side 2: 90 deg; End Panel Opening Angle in 3D on Side 2: 0 deg; Opening Angle of Main Sash Side 1 (openingAngle_05): 0 deg; Opening Angle of Main Sash Side 1 (openingAngle2_05): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle_09): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle2_09): 0 deg; Opening Angle of Middle Transom (openingAngle_02): 0 deg; Opening Angle of Middle Transom (openingAngle2_02): 0 deg; Opening Angle of Transom Side 1 (openingAngle_06): 0 deg; Opening Angle of Transom Side 1 (openingAngle2_06): 0 deg; Opening Angle of Transom Side 2 (openingAngle_10): 0 deg; Opening Angle of Transom Side 2 (openingAngle2_10): 0 deg; Double Acting Line Type: 4; Override MVO for 2D Symbolic Display: yes; Opening Line Shape (or_SwingType): Curved; Opening Line Shape (or_iSwingType): 1; Show Glazing Line in 2D: yes; Glazing Line Pen in 2D (or_iGlazingLinePen): 3; Glazing Line Pen in 2D (or_glazingLinePen): Openings - General; Override MVO for Door 3D Projections: yes; Show Opening Line (or_bOplines3d): yes; Line Type Opening Side (or_opLineType3dIn): Dashed; Line Type Opening Side (or_iOpLineType3dIn): 1; Line Type Opposite Side (or_opLineType3dOut): Dashed; Line Type Opposite Side (or_iOpLineType3dOut): 1; Line Orientation (or_oplineStyle): Handle; Line Orientation (or_iOplineStyle): 1; Opening Line Pen in 2D/3D (or_opLinePen): Roofs/Shells - Outlines and Cover Fills; Opening Line Pen in 2D/3D (or_iOpLinePen): 92; Override MVO for Sidelight/Transom 3D Projections: no; Show Opening Line (or_bWinOplines3d): yes; Line Type Opening Side (or_winOpLineType3dIn): Dashed; Line Type Opening Side (or_iWinOpLineType3dIn): 1; Line Type Opposite Side (or_winOpLineType3dOut): Solid Line; Line Type Opposite Side (or_iWinOpLineType3dOut): 0; Line Orientation (or_winOplineStyle): Handle; Line Orientation (or_iWinOplineStyle): 1; Opening Line Pen in 2D/3D (or_winOpLinePen): Openings - General; Opening Line Pen in 2D/3D (or_iWinOpLinePen): 3; Symbol Pen: Openings - General; Frame Contour Pen: Openings - Cut Structural; Casing Cut Line Pen on Both Sides: Openings - General; Leaf Contour Pen: Openings - General; Wall Contour Line (gs_wcont_line): Off; Wall Contour Line (iWallContourLine): 1; Wall Contour Line Type Inside: 1; Wall Contour Line Type Outside: 1; Hidden Wall Contour Line Type Inside: 4; Hidden Wall Contour Line Type Outside: 4; Sidelight Wall Contour Line (gs_wcont_line_sl): Both Sides; Sidelight Wall Contour Line (iWallContourLineSl): 4; Sidelight Wall Contour Line Type Inside: 1; Sidelight Wall Contour Line Type Outside: 1; Sidelight Hidden Wall Contour Line Type Inside: 4; Sidelight Hidden Wall Contour Line Type Outside: 4; Wall Contour Line Pen: Openings - General; Frame Fill Type: Background; Frame Fill Pen: Openings - Cut Fills; Frame Fill Background Pen: Backgrounds - color 1; Leaf Fill Type: Air Space; Leaf Fill Pen: Backgrounds - color 1; Leaf Fill Background Pen: Backgrounds - color 1; Airtight Symbol Fill Type: Foreground; Airtight Symbol Fill Pen: General - General; Airtight Symbol Fill Background Pen: General - General; Sidelight Plan Symbol Fill Type: Background; Sidelight Plan Symbol Fill Pen: Backgrounds - color 1; Sidelight Plan Symbol Fill Background Pen: Backgrounds - color 1; Threshold and Sill Line Type: 1; Threshold Section Contour Pen: Openings - General; Threshold Section Fill Type: Background; Threshold Section Fill Pen: Backgrounds - color 1; Threshold Section Fill Background Pen: Backgrounds - color 1; Sill 3D and Uncut Pen: General - General; Sill Section Contour Pen: General - General; Sill Section Fill Type: Air Space; Sill Section Fill Pen: Backgrounds - color 1; Sill Section Fill Background Pen: Backgrounds - color 1; Section Insulation Contour Pen: General - General; Section Insulation Fill Type: Rigid Insulation; Section Insulation Fill Pen: General - General; Section Insulation Fill Background Pen: Backgrounds - color 1; Board 3D and Uncut Pen: General - General; Board Section Contour Pen: General - General; Board Section Fill Type: Air Space; Board Section Fill Pen: Backgrounds - color 1; Board Section Fill Bkg. Pen: Backgrounds - color 1; Casing Fill Type Inside: Air Space; Casing Fill Pen Inside: Backgrounds - color 1; Casing Fill Background Pen Inside: Backgrounds - color 1; Casing Fill Type Outside: Air Space; Casing Fill Pen Outside: Backgrounds - color 1; Casing Fill Background Pen Outside: Backgrounds - color 1; Arch Section Fill Type: Background; Arch Section Fill Pen: Backgrounds - color 1; Arch Section Fill Bkg. Pen: Backgrounds - color 1; Ventilation Profile Section Fill Type: Air Space; Ventilation Profile Section Fill Pen: Backgrounds - color 1; Ventilation Profile Section Fill Background Pen: Backgrounds - color 1; Sunshade Symbol Line Type: 1; Sunshade Cut Line Pen: General - General; 3D/Section Uncut Line Pen: General - General; Sunshade Cut Fill Type: Background; Sunshade Cut Fill Pen: General - General; Sunshade Cut Fill Background Pen: Window Background; Sunshade Insulation Fill Type: Batt Insulation; Sunshade Insulation Fill Pen: General - General; Sunshade Insulation Background Pen: Window Background; Opening Side Values (gs_opside_list): Custom; Opening Side Values (gs_opside_list_m): 0; Frame Element Joinery (gs_SashText_typ): Butt Joint; Frame Element Joinery (gs_SashText_typ_num): 2; Frame Pen: Openings - General; Leaf Pen: Openings - General; Sash Glass Pen: Openings - Cut Non-Structural; Leaf Glass Pen: Openings - Cut Non-Structural; Masonry Arch Pen: Walls/Curtain Walls - General; Shadow: yes; Lock: Paint - Anthracite; Sash Glass: Glass - Clear Fast; Leaf Glass: Glass - Clear Fast; Rail (gs_rail_mat): Metal - Iron; Louver Outside: Wood - Pine Grained Horizontal; Louver Inside: Wood - Pine Grained Horizontal; Kick Plate: Metal - Aluminium; Uniform Casing Surfaces: yes; Interior Casing: Wood - Pine Grained Horizontal; Exterior Casing: Wood - Pine Grained Horizontal; Ventilation Profile: Metal - Aluminium; Shutter Panel: Wood - Pine Grained Horizontal; Shutter Panel Frame: Wood - Pine Grained Horizontal; Rolling Shutter Box: Metal - Stainless Steel; Rolling Shutter Blades: Paint - Glossy White; Rolling Shutter Rail: Paint - Glossy White; Venetian Blinds Box: Metal - Stainless Steel; Venetian Blinds Segments: Paint - Glossy White; Sliding Shutter Rail: Metal - Stainless Steel; Threshold (gs_treshold_mat): Wood - Pine Grained Horizontal; Threshold Metal: Metal - Aluminium; Sill (gs_sill_mat): Brick - Running Bond; Brick Sill Mortar: Stucco - White Rough; Board (gs_board_mat): Wood - Pine Grained Horizontal; Handle Accessories: Metal - Iron; Kick Board Outside (matKickBoardOut): Metal - Stainless Steel; Kick Board Inside (matKickBoardIn): Metal - Stainless Steel; Masonry Arch Brick: Brick - Running Bond; Masonry Arch Mortar: Stucco - White Rough; Masonry Arch Keystone: Stone - Sandstone 01; Niche: Paint - Lead Oxide Yellow; Tags and Labels: 1; Show Leaf Width Dimensions: yes; Show Door ID: no; Show Custom Text: no; Custom Text: <Custom Text>; Always Readable: yes; Font Type: Arial; Font Size: 2; Font Style: 0; Text Pen (iPenText): 1; Text Pen (penText): General - General; Door belongs to the Zone into which it opens: yes; Cost: 0; Location as: Custom; Total Glazed Area (gs_list_glassarea_tmp): 0; Override Glazed Area: no; Total Glass Perimeter: 0; Free Air Performance (mm2/l/m): 0; Object Weight: 0; Object Weight Unit: kg; Door Orientation Definition: 0; Door Closer: no; Vision Panel Type: No Vision Panel; Hold Open Device: no; IFC Operation (ifc_optypestr): Single Door Single Swing; IFC Operation (ifc_optype): 1
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 80.10.40.20 Portes d'accés; 104.AMB.ClassificacioCodi: 80.10.40.20; 105.AMB.ClassificacioDescripcio: Portes d'accés; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 80
AC_Equantity_Door_27 - Z Dimension: 1 m; Bottom Level: 1 m; Top Level: 0 m; New Wall Fill Width Right: 0.15 m; New Wall Fill Width Left: 0.15 m; Sidelight 1 Width (gs_sidelight_width_right): 0 m; Sidelight 1 Width (gs_sidelight_width_right_half): 0.15 m; Sidelight 1 Width (gs_sidelight_width_right_orig): 0.3 m; Sidelight 1 Sill Height: 0 m; Sidelight 2 Width (gs_sidelight_width_left): 0 m; Sidelight 2 Sill Height: 0 m; Transom Height: 0.3 m; Pivot Axis Offset: 0.275 m; Tolerance Side 1: 0 m; Tolerance Side 1 Lower: 0 m; Tolerance Sidelight 1 Bottom: 0 m; Tolerance Side 2: 0 m; Tolerance Side 2 Lower: 0 m; Tolerance Sidelight 2 Bottom: 0 m; Tolerance Upper: 0 m; Tolerance Lower: 0 m; Frame Thickness Inside: 0.115 m; Frame Oversize: 0.01 m; Frame Outer Thickness: 0.01 m; Frame Width Side 1: 0.04 m; Middle Frame Width Side 1: 0.04 m; Bottom Frame Width Side 1: 0.04 m; Frame Width Side 2: 0.04 m; Middle Frame Width Side 2: 0.04 m; Bottom Frame Width Side 2: 0.04 m; Transom Frame Width (gs_frame_width_transom): 0.04 m; Upper Frame Width: 0.04 m; Leaf Rebate Depth in 3D: 0.04 m; Sidelight and Transom Rebate Width: 0.01 m; Sidelight and Transom Rebate Depth: 0.018 m; Leaf Thickness: 0.04 m; Leaf Frame Width Right: 0.1 m; Leaf Frame Width Left: 0.1 m; Leaf Frame Width Internal: 0.025 m; Leaf Undercut: 0 m; Grid Width: 0.012 m; Grid Thickness: 0.025 m; Glass Thickness: 0.012 m; Handle Height: 1 m; Handle Position: 0.05 m; Kick Board Height: 0.1 m; Horizontal Division Height Sidelight Side 1: 0.9 m; Horizontal Division Height Sidelight Side 2: 0.9 m; Horizontal Division Height Middle Transom: 0.9 m; Horizontal Division Height Transom Side 1: 0.9 m; Horizontal Division Height Transom Side 2: 0.9 m; Sidelight and Transom Frame Thickness: 0.044 m; Transom Frame Width (gs_sash_width): 0.067 m; Sidelight Frame Width: 0.067 m; Grill Width: 0.02 m; Grill Thickness: 0.025 m; Sidelight Division Width: 0.04 m; Architrave Capital Width: 0.02 m; Width Side 1 (gs_tw_right_out): 0.05 m; Width Side 2 (gs_tw_left_out): 0.05 m; Width Top (gs_tw_top_out): 0.05 m; Thickness on Wall (gs_trim_thk_out): 0.019 m; Thickness in Wallhole (gs_trim_width_out): 0.025 m; Offset (gs_trim_offs_out): 0.012 m; Nosing (gs_trim_jambext_nosing_out): 0.05 m; Top Overhang (gs_trimov_top_left_out): 0.1 m; Top Overhang (gs_trimov_top_right_out): 0.1 m; Width Side 1 (gs_tw_right_in): 0.05 m; Width Side 2 (gs_tw_left_in): 0.05 m; Width Top (gs_tw_top_in): 0.05 m; Thickness on Wall (gs_trim_thk_in): 0.019 m; Thickness in Wallhole (gs_trim_width_in): 0.025 m; Offset (gs_trim_offs_in): 0.012 m; Nosing (gs_trim_jambext_nosing_in): 0.05 m; Top Overhang (gs_trimov_top_left_in): 0.1 m; Top Overhang (gs_trimov_top_right_in): 0.1 m; Threshold Thickness: 0.012 m; Threshold Width: 0.01 m; Threshold External Thickness: 0.00580738 m; Threshold Nosing Outside: 0.025 m; Threshold Nosing Inside: 0.025 m; Side Overhang Outside: 0 m; Side Overhang Inside: 0 m; Sill Front Side Thickness: 0.015 m; Sill Elevation: 0.005 m; Sill Drip Overlap: 0.02 m; Sill Drip Width: 0.03 m; Sill Nosing: 0.03 m; Sill Overhang Side 1: 0 m; Sill Overhang Side 2: 0 m; Sill Slip-in Depth: 0.02 m; Sill Top Width: 0.01 m; Sill Top Height: 0.01 m; Sill Slip from Wall: 0 m; Rear Hole Depth (gs_sill_holeDepthBehind): 0 m; Width of Sill: 0 m; Brick Thickness (gs_brick_sill_br_thk): 0.065 m; Mortar Thickness (gs_brick_sill_mort_thk): 0.015 m; Board Width: 0.1 m; Board Thickness: 0.025 m; Board Nosing: 0.03 m; Board Overhang Side 1: 0 m; Board Overhang Side 2: 0 m; Board Slip-in Depth: 0 m; Profile Height: 0.065 m; Profile Thickness: 0.11 m; Panel Height: 1.5 m; Inner Offset: 0.02 m; Closing Depth: 0 m; Extra Frame Width: 0.04 m; Extra Frame Thickness: 0.03 m; Rail Width: 0.03 m; Hanging Stick Length: 0.02 m; Hanging Stick Radius: 0.005 m; Panel Distance: 0.006 m; Outside Overhang: 0 m; Inner Panel Width: 0.12 m; 3D Opening Length: 1.5 m; 3D Closed Length: 0 m; 3D Opening Length 1: 0.56 m; 3D Opening Length 2: 0.14 m; 3D Opening Height: 1.5 m; 3D Closed Height: 0 m; Panel Thickness: 0.05 m; Panel Frame Width: 0.05 m; Frame Width Bottom: 0.05 m; Panel Width: 0 m; Panel Fill Thickness: 0.01 m; Louver Thickness: 0.01 m; Louver Width: 0.04 m; Horizontal Frame Divider Width: 0.05 m; Vertical Frame Divider Width: 0.05 m; Hole Radius: 0.01 m; Vertical Board Width: 0.1 m; Z Frame Width: 0.05 m; Z Frame Thickness: 0.025 m; Vertical Boards Thickness: 0.025 m; Horizontal Boards Thickness: 0.025 m; Vertical Boards Approximate Width: 0.08 m; Horizontal Boards Approximate Width: 0.115 m; Box Height (gs_shutRoll_boxHeight): 0.2 m; Box Depth (gs_shutRoll_boxWidth): 0.15 m; Box Left Offset: 0 m; Box Right Offset: 0 m; Depth of Rails: 0.0725 m; Distance from Wall (gs_shutRoll_distFromWall): 0 m; Distance from Header (gs_shutRoll_distFromHead): 0 m; Slat Width: 0.05 m; Box Height (gs_shutLam_boxHeight): 0.2 m; Box Depth (gs_shutLam_boxWidth): 0.15 m; Cover Width: 0 m; Distance from Wall (gs_shutLam_distFromWall): 0 m; Distance from Header (gs_shutLam_distFromHead): 0 m; Segment Width (gs_shutLam_segmentWidth): 0.06 m; Box Height (gs_shutLam2_boxHeight): 0.06 m; Box Width: 0.06 m; Distance from Window: 0.06 m; Distance from Header (gs_shutLam2_distFromHead): 0.06 m; Box Axis Height from Header: 0 m; Segment Width (gs_shutLam2_segmentWidth): 0.06 m; Distance between Arch and Door: 0 m; Masonry Arch Overhang Side 1: 0 m; Masonry Arch Overhang Side 2: 0 m; Masonry Arch Rise: 0.03 m; Masonry Arch Projection: 0 m; Masonry Arch Height: 0.25 m; Masonry Arch Depth: 0.12 m; Rear Hole Depth (gs_masonry_arch_rearHoleDepth): 0 m; Brick Thickness (gs_masonry_arch_brick_thk): 0.065 m; Mortar Thickness (gs_masonry_arch_mort_thk): 0.01 m; Keystone Width: 0.1 m; Keystone Oversize: 0 m; Keystone Projection: 0.01 m; Jamb Depth: 0.06 m; Jamb Depth Side 2: 0.06 m; Lower Jamb Depth Side 1: 0.06 m; Lower Jamb Depth Side 2: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_splayed_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_splayed_innerRight): 0.06 m; Inner Jamb Depth (gs_reveal_double_innerRight): 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_double_innerLeft): 0.06 m; Inner Lower Jamb Depth Side 1: 0.06 m; Inner Lower Jamb Depth Side 2: 0.06 m; Head Depth: 0.06 m; Sill Depth: 0.06 m; Sill Depth Side 1: 0.06 m; Sill Depth Side 2: 0.06 m; Inner Head Depth (gs_reveal_splayed_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_splayed_innerBottom): 0.06 m; Inner Head Depth (gs_reveal_double_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_double_innerBottom): 0.06 m; Inner Sill Depth Side 1: 0 m; Inner Sill Depth Side 2: 0 m; Outer Jamb Depth: 0.08 m; Plaster Thickness Limit: 0.04 m; Distance of Skin from Closer: 0 m; Closer Width: 0.038 m; Closer Thickness: 0.1 m; Strip Thickness: 0.025 m; Profile Width: 0.15 m; Custom Thickness: 0.015 m; Skin Overhang to Frame Depth: 0 m; Left Opening Oversize: 0 m; Right Opening Oversize: 0 m; Upper Opening Oversize: 0 m; Lower Opening Oversize: 0 m; Opening Width in 3D: 0 m; Opening Width in 3D on Side 2: 0 m; Opening Width in 2D on Side 2: 0 m; Opening Distance 1 Main Sash Side 1: 0 m; Opening Distance 2 Main Sash Side 1: 0 m; Opening Distance 1 Main Sash Side 2: 0 m; Opening Distance 2 Main Sash Side 2: 0 m; Opening Distance 1 Middle Transom: 0 m; Opening Distance 2 Middle Transom: 0 m; Opening Distance 1 Transom Side 1: 0 m; Opening Distance 2 Transom Side 1: 0 m; Opening Distance 1 Transom Side 2: 0 m; Opening Distance 2 Transom Side 2: 0 m; Opposite Side Width 2: 0.25 m; Opposite Side Depth: 1.2 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m; ID Offset X: 0 m; ID Offset Y: 0 m; Custom Text Offset X: 0 m; Custom Text Offset Y: 0 m; Leaf Width Offset X: 0 m; Leaf Width Offset Y: 0 m
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
Name | Classification | Reveal Dimensions = Wallhole Dimensions = Unit Dimensions = Nominal W x H Size | Egress Dimensions | Leaf Dimensions | Nominal W x H x T Size | Wall Structure | Orientation = Door Orientation | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Colliding Zones | Parent ID | Surfaces (All) | Wall Direction Type | Opening Direction | Parapet Wall Inset Value | 2D Detail Level | Frame Style (gs_frame_style) | Frame Style (gs_frame_style_m) | Uniform Frame Width | Door Panel Style | Opening Handle (gs_handle_type_m) | Reveal Type (gs_reveal_type_new) | Reveal Type (gs_reveal_type_int) | Bottom Reveal Type (gs_reveal_type_bottom) | Bottom Reveal Type (gs_reveal_type_bottom_int) | Rail (gs_door_rail_ext) | Rail (gs_door_rail_ext_m) | Auto Turn Inside Face Plaster = Auto Turn Outside Face Plaster | Opening Angle in 3D (deg) | Opening Line Type | Opening Line Shape (or_iSlidingType) | Use Fills | Door Plan Symbol Fill Type | Door Plan Symbol Fill Pen | Door Plan Symbol Fill Background Pen | Uncut Fill Type | Uncut Fill Pen = Uncut Fill Background Pen | Curve Resolution | Uniform Door Surfaces | Frame Outside = Frame Inside = Leaf Outside = Leaf Inside = Leaf 2 = Leaf 3 = Grid Outside (gs_grill_mat) = Grid Inside (gs_grill_mat2) = Grid Outside (gs_leaf_grill_mat) = Grid Inside (gs_leaf_grill_mat2) = Solid Panel Outside = Solid Panel Inside | Handle | Total Glazed Area (gs_list_glassarea) | Group Type (FM_Type) | Group Type (iFMType) | Door Leaf Widths | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_107.NomTipus | W/D Opening Opening Volume (m3) = W/D Opening Nominal Volume (m3) | W/D Opening Surface Area (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | W/D Opening Nominal Surface Area (m2) = W/D Opening Surface Area on the Reveal Side (m2) = W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | W/D Opening Width on the Reveal Side (m) = W/D Opening Width on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Width on the Reveal Side (m) = Nominal W/D Opening Width on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Width (m) = AC_Equantity_Door_27, Width (m) = Wallhole Width (m) = Reveal Width (m) = Unit Width (m) = 502.AMB.Amplada (m) | W/D Opening Height on the Reveal Side (m) = W/D Opening Height on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Height on the Reveal Side (m) = Nominal W/D Opening Height on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Height (m) = AC_Equantity_Door_27, Height (m) = Wallhole Height (m) = Reveal Height (m) = Unit Height (m) = 503.AMB.Altura (m) | Sill/Header Value (m) = W/D Nominal Sill Height (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) = Sill Height to Current Story (m) | W/D Sill Height on the Reveal Side (m) = W/D Sill Height on the Side Opposite to the Reveal Side (m) | W/D Nominal Head Height (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | W/D Head Height on the Reveal Side (m) = W/D Head Height on the Side Opposite to the Reveal Side (m) | Wall Thickness (m) | ArchiCADQuantities, Frame Thickness (m) = AC_Equantity_Door_27, Frame Thickness (m) = Real Frame Thickness (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Top Elevation To Sea Level (m) | Reveal to Wall Core (m) = Reveal Depth (gs_wido_sill) (m) = Reveal Depth (AC_wido_sill) (m) | Shoulder Height (m) | Sidelight 2 Width (gs_sidelight_width_left_half) (m) | Sidelight 2 Width (gs_sidelight_width_left_orig) (m) | Egress Width (m) | Egress Height (m) | Nominal Leaf Width (m) | Nominal Leaf Height (m) | Leaf Offset (m) | Frame Width (m) | Door Stop Thickness (m) | Door Stop Width (m) | Rebate Width (m) | Nominal Leaf Width Side 1 (m) | Leaf Frame Width Side (m) = Leaf Frame Width Upper (m) | Leaf Frame Width Lower (m) | Sidelight Division Thickness (m) | Sill Thickness (m) | Opening Width in 2D (m) | Opening Side Width 2 (m) | Opening Side Width 1 (m) = Opposite Side Width 1 (m) | Opening Side Depth (m) | Opening Handle (gs_handle_type)
PI010 | 80.10.40.20 Portes d'accés (GuBIMclass CA) | 800,0×2.600,0 | 720,0×2.560,0 | 744,0×2.572,0 | 800,0×2.600,0×140,0 | Concrete 18 (1) | L | PI010 | Nau Santa Eulàlia | T3 | Wood - Pine Grained Horizontal | 2 | 0 | 3 | 2 | Simple Rebate | 3 | yes | 1 | 0 | No Reveal - Edge | 1 | No Reveal | 2 | Off | 1 | no | 0 | 21 | 0 | no | Background | Backgrounds - color 1 | Backgrounds - color 1 | Air Space | Transparent | 32 | no | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 0 | Others | 25 | 74 | PI010_PortaIntTipusD | Porta de pi amb doble fulla de 72.5cm | Nau Santa Eulalia | PortaIntTipusD | 0.2912 | 5.95426 | 2.08 | 0.8 | 2.6 | 0.27 | 0 | 2.87 | 2.5 | 0.14 | 0.115 | 0.10096 | 9.61 | 12.21 | 0 | 2.57 | 0.3 | 0.6 | 0.72 | 2.56 | 0.744 | 2.572 | 0 | 0.04 | 0.032 | 0.016 | 0.012 | 0.372 | 0.15 | 0.15 | 0.115 | 0.025 | 0 | 0.3 | 0.1 | 1.8
PI009 | 80.10.40.20 Portes d'accés (GuBIMclass CA) | 800,0×2.600,0 | 720,0×2.560,0 | 744,0×2.572,0 | 800,0×2.600,0×80,0 | Insulation | L | PI009 | Nau Santa Eulàlia; Office | T1 | Metal - Stainless Steel; Wood - Pine Grained Horizontal; Glass - Clear Fast | 2 | 0 | 3 | 2 | Simple Rebate | 3 | yes | 46 | 18 | No Reveal - Edge | 1 | No Reveal | 2 | Off | 1 | no | 0 | 21 | 0 | no | Background | Backgrounds - color 1 | Backgrounds - color 1 | Air Space | Transparent | 32 | no | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 1.00877 | Others | 25 | 74 | PI009_PortaIntTipusC | Porta de pi amb fulla de 72.5cm | Nau Santa Eulalia | PortaIntTipusC | 0.1664 | 6.30801 | 2.08 | 0.8 | 2.6 | 0.27 | 0 | 2.87 | 2.5 | 0.08 | 0.115 | 0.0606751 | 9.61 | 12.21 | 0 | 2.57 | 0.3 | 0.6 | 0.72 | 2.56 | 0.744 | 2.572 | 0 | 0.04 | 0.032 | 0.016 | 0.012 | 0.372 | 0.15 | 0.15 | 0.115 | 0.025 | 0 | 0.3 | 0.1 | 1.8 | Handle 8
PI008 | 80.10.40.20 Portes d'accés (GuBIMclass CA) | 800,0×2.600,0 | 720,0×2.560,0 | 744,0×2.572,0 | 800,0×2.600,0×80,0 | Insulation | R | PI008 | Despatx; Nau Santa Eulàlia | T1 | Metal - Stainless Steel; Wood - Pine Grained Horizontal; Glass - Clear Fast | 2 | 0 | 3 | 2 | Simple Rebate | 3 | yes | 46 | 18 | No Reveal - Edge | 1 | No Reveal | 2 | Off | 1 | no | 0 | 21 | 0 | no | Background | Backgrounds - color 1 | Backgrounds - color 1 | Air Space | Transparent | 32 | no | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 1.00877 | Others | 25 | 74 | PI008_PortaIntTipusC | Porta de pi amb fulla de 72.5cm | Nau Santa Eulalia | PortaIntTipusC | 0.1664 | 6.30801 | 2.08 | 0.8 | 2.6 | 0.27 | 0 | 2.87 | 2.5 | 0.08 | 0.115 | 0.0606751 | 9.61 | 12.21 | 0 | 2.57 | 0.3 | 0.6 | 0.72 | 2.56 | 0.744 | 2.572 | 0 | 0.04 | 0.032 | 0.016 | 0.012 | 0.372 | 0.15 | 0.15 | 0.115 | 0.025 | 0 | 0.3 | 0.1 | 1.8 | Handle 8
PI004 | 80.10.40.20 Portes d'accés (GuBIMclass CA) | 879,4×2.600,0 | 879,4×2.600,0 | 879,4×2.600,0 | 879,4×2.600,0×80,0 | Insulation | R | PI004 | Espai de treball; Nau Santa Eulàlia | T1 | Metal - Chrome 01; Wood - Pine Grained Horizontal; Glass - Clear Fast | 2 | 1 | 2 | 2 | Simple Rebate | 3 | yes | 46 | 18 | No Reveal | 2 | Uniform | 1 | Off | 1 | no | 0 | 21 | 0 | no | Background | Backgrounds - color 1 | Backgrounds - color 1 | Air Space | Transparent | 32 | no | Wood - Pine Grained Horizontal | Metal - Chrome 01 | 1.33267 | Others | 25 | 88 | PI004_PortaIntTipusA | Porta de pi amb fulla de 72.5cm | Nau Santa Eulalia | PortaIntTipusA | 0.18292 | 5.2221 | 2.2865 | 0.879423 | 2.6 | 0.27 | 0 | 2.87 | 2.5 | 0.08 | 0.115 | 0.0382189 | 9.61 | 12.21 | 0.015 | 2.57 | 0.3 | 0.6 | 0.879423 | 2.6 | 0.879423 | 2.6 | 0 | 0 | 0.032 | 0.016 | 0 | 0.372 | 0.15 | 0.15 | 0.115 | 0.025 | 0 | 0.3 | 0.1 | 1.8 | Handle 8
PI006 | 80.10.40.20 Portes d'accés (GuBIMclass CA) | 800,0×2.600,0 | 720,0×2.560,0 | 744,0×2.572,0 | 800,0×2.600,0×80,0 | Insulation | L | PI006 | Espai de treball; Nau Santa Eulàlia | T1 | Metal - Stainless Steel; Wood - Pine Grained Horizontal; Glass - Clear Fast | 2 | 1 | 2 | 2 | Simple Rebate | 3 | yes | 46 | 18 | No Reveal - Edge | 1 | No Reveal | 2 | Off | 1 | no | 0 | 21 | 0 | no | Background | Backgrounds - color 1 | Backgrounds - color 1 | Air Space | Transparent | 32 | no | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 1.00877 | Others | 25 | 74 | PI006_PortaIntTipusC | Porta de pi amb fulla de 72.5cm | Nau Santa Eulalia | PortaIntTipusC | 0.1664 | 6.30801 | 2.08 | 0.8 | 2.6 | 0.27 | 0 | 2.87 | 2.5 | 0.08 | 0.115 | 0.0606751 | 9.61 | 12.21 | 0 | 2.57 | 0.3 | 0.6 | 0.72 | 2.56 | 0.744 | 2.572 | 0 | 0.04 | 0.032 | 0.016 | 0.012 | 0.372 | 0.15 | 0.15 | 0.115 | 0.025 | 0 | 0.3 | 0.1 | 1.8 | Handle 8
PI005 | 80.10.40.20 Portes d'accés (GuBIMclass CA) | 800,0×2.600,0 | 720,0×2.560,0 | 744,0×2.572,0 | 800,0×2.600,0×80,0 | Insulation | R | PI005 | Espai de treball; Nau Santa Eulàlia | T1 | Metal - Stainless Steel; Wood - Pine Grained Horizontal; Glass - Clear Fast | 2 | 1 | 2 | 2 | Simple Rebate | 3 | yes | 46 | 18 | No Reveal - Edge | 1 | No Reveal | 2 | Off | 1 | no | 0 | 21 | 0 | no | Background | Backgrounds - color 1 | Backgrounds - color 1 | Air Space | Transparent | 32 | no | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 1.00877 | Others | 25 | 74 | PI005_PortaIntTipusC | Porta de pi amb fulla de 72.5cm | Nau Santa Eulalia | PortaIntTipusC | 0.1664 | 6.30801 | 2.08 | 0.8 | 2.6 | 0.27 | 0 | 2.87 | 2.5 | 0.08 | 0.115 | 0.0606751 | 9.61 | 12.21 | 0 | 2.57 | 0.3 | 0.6 | 0.72 | 2.56 | 0.744 | 2.572 | 0 | 0.04 | 0.032 | 0.016 | 0.012 | 0.372 | 0.15 | 0.15 | 0.115 | 0.025 | 0 | 0.3 | 0.1 | 1.8 | Handle 8
