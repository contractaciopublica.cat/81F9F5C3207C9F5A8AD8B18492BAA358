Properties of the parts of a building model (IFC2X3), part 4 of 99

# IfcBuildingElementProxy: Brick 250 (56)
Name | Layer | Renovation Status | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | Status | Brick, Embodied Carbon | Brick, Embodied Energy (MJ) | Maximum Height of the Wall (m) = Minimum Height of the Wall (m) = Height (m) = Brick, Rectangular Component Height (m) = 503.AMB.Altura (m) | Average length of the Wall (m) = Length of Reference Line (m) = Length of the Wall Inside Face (Conditional) (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall at the Center (m) = Length of the Wall on the Inside Face (m) = Length of the Wall on the Outside Face (m) = 3D Length (m) = 501.AMB.Longitud (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area of the Wall Inside Face (Gross) (m2) = Surface Area of the Wall Outside Face (Gross) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) = Brick, Projected Component Area (Net) (m2) = Brick, Projected Component Area (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Volume (Gross) (m3) = Brick, Component Volume (Net) (m3) = Brick, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To Home Story (m) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Brick, Mass (kg) | Brick, Component Cross Section Area (m2)
3 x F6 | 00_ORNAMENTOS | Existing | Preexistències | EXISTING | 6.6385 (kgCO₂) | 82.9813 | 0.207899 | 0.354794 | 0.0737611 | 0.0886985 | 0.0184403 | 3.32499 | 12.665 | -1.17501 | 1.20959 | 3.53289 | -0.967109 | 12.8729 | 0.281346 | 27.6604 | 0.0519746 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
3 x F6 | 00_ORNAMENTOS | Existing | Preexistències | EXISTING | 6.6385 (kgCO₂) | 82.9813 | 0.207899 | 0.354794 | 0.0737611 | 0.0886985 | 0.0184403 | 3.32594 | 12.6659 | -1.17406 | 1.20959 | 3.53384 | -0.966162 | 12.8738 | 0.281346 | 27.6604 | 0.0519746 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
F6 | 00_ORNAMENTOS | Existing | Preexistències | EXISTING | 6.6385 (kgCO₂) | 82.9813 | 0.207899 | 0.354794 | 0.0737611 | 0.0886985 | 0.0184403 | 3.3231 | 12.6631 | -1.1769 | 1.20959 | 3.531 | -0.969004 | 12.871 | 0.281346 | 27.6604 | 0.0519746 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
F6 | 00_ORNAMENTOS | Existing | Preexistències | EXISTING | 7.55144 (kgCO₂) | 94.393 | 0.207899 | 0.403586 | 0.0839049 | 0.100896 | 0.0209762 | 3.3231 | 12.6631 | -1.1769 | 1.30717 | 3.531 | -0.969004 | 12.871 | 0.305742 | 31.4643 | 0.0519746 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
6 x F6 | 00_ORNAMENTOS | Existing | Preexistències | EXISTING | 4.86482 (kgCO₂) | 60.8103 | 0.207899 | 0.26 | 0.0540536 | 0.0649999 | 0.0135134 | 3.32594 | 12.6659 | -1.17406 | 1.02 | 3.53384 | -0.966162 | 12.8738 | 0.233949 | 20.2701 | 0.0519746 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
28 x F6 | 00_RELLENO VANOS | New | Obra | NEW | 30.9785 (kgCO₂) | 387.232 | 0.747969 | 0.460187 | 0.344206 | 0.115047 | 0.0860515 | 4.62175 | 13.9617 | 0.121748 | 1.42037 | 5.36972 | 0.869717 | 14.7097 | 0.604078 | 129.077 | 0.186992
6 x F6 | 00_ORNAMENTOS | Existing | Preexistències | EXISTING | 4.86482 (kgCO₂) | 60.8102 | 0.207899 | 0.26 | 0.0540535 | 0.0649999 | 0.0135134 | 3.32594 | 12.6659 | -1.17406 | 1.02 | 3.53384 | -0.966162 | 12.8738 | 0.233949 | 20.2701 | 0.0519746 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
2 x F6 | 00_ORNAMENTOS | Existing | Preexistències | EXISTING | 6.6385 (kgCO₂) | 82.9812 | 0.207899 | 0.354794 | 0.0737611 | 0.0886984 | 0.0184403 | 3.32594 | 12.6659 | -1.17406 | 1.20959 | 3.53384 | -0.966162 | 12.8738 | 0.281346 | 27.6604 | 0.0519746 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
4 x F6 | 00_ORNAMENTOS | Existing | Preexistències | EXISTING | 6.6385 (kgCO₂) | 82.9812 | 0.207899 | 0.354794 | 0.0737611 | 0.0886984 | 0.0184403 | 3.32499 | 12.665 | -1.17501 | 1.20959 | 3.53289 | -0.967109 | 12.8729 | 0.281346 | 27.6604 | 0.0519746 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
2 x F6 | 00_ORNAMENTOS | Existing | Preexistències | EXISTING | 6.6385 (kgCO₂) | 82.9812 | 0.207899 | 0.354794 | 0.0737611 | 0.0886984 | 0.0184403 | 3.3231 | 12.6631 | -1.1769 | 1.20959 | 3.531 | -0.969004 | 12.871 | 0.281346 | 27.6604 | 0.0519746 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia

# IfcBuildingElementProxy: Brick 310, F1
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Brick
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Brick - Aged Natural; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F1; Hotlink and Element ID: F1; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: planta coberta; Relative Top Link Story: Home + 1; Top Link Story: Home + 1 (planta coberta); Structure Type: Basic; Parent ID: F1; Building Materials (All): Brick; Surfaces (All): Brick - Aged Natural; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: F1_; 109.AMB.CodiTipus: F1; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Component Properties - Brick, Embodied Carbon: 575.291 (kgCO₂); Brick, Embodied Energy: 7191.14 MJ
ArchiCADQuantities - Number of Doors: 1; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 4.19817 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 12.4648 m2; Combined Width of Doors: 3.56138 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 11.8101 m2; Analytic Surface Area of Openings on the Outside Face: 11.8101 m2; Average length of the Wall: 4.04119 m; Surface Area of the Wall Inside Face (Net): 5.14293 m2; Surface Area of the Wall Outside Face (Net): 5.16109 m2; Analytic Volume of the Openings: 3.66112 m3; Length of Reference Line: 4.04251 m; Length of the Wall Inside Face (Conditional): 0.478483 m; Surface Area of the Wall Inside Face (Conditional): 5.14293 m2; Length of the Wall Outside Face (Conditional): 0.481133 m; Surface Area of the Wall Outside Face (Conditional): 5.16109 m2; Surface Area of the Wall Inside Face (Gross): 21.2423 m2; Surface Area of the Wall Outside Face (Gross): 19.143 m2; End Thickness of the Wall: 0.31 m; Length of the Wall at the Center: 4.04119 m; Length of the Wall on the Inside Face: 4.03986 m; Length of the Wall on the Outside Face: 4.04251 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 0.14874 m2; Height: 4.19817 m; Volume (Net): 1.59803 m3; Width: 0.31 m; Elevation to Project Zero: 0.00183192 m; Elevation to 1st Reference Level: 0.00183192 m; Elevation to 2nd Reference Level: 0.00183192 m; Elevation to Sea Level: 9.34183 m; Elevation to Linked/Home Story: 0.00183192 m; Home Offset: 0.00183192 m; Top Offset: -0.3 m; Surface Area: 5.16109 m2; 3D Length: 4.05927 m; Thickness: 0.31 m; Volume (Conditional): 1.59803 m3; Volume (Gross): 6.58438 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 8.70344 m; Top Elevation To First Reference Level: 4.2 m; Top Elevation To Home Story: 4.2 m; Top Elevation To Project Zero: 4.2 m; Top Elevation To Sea Level: 13.54 m; Top Elevation To Second Reference Level: 4.2 m; Bottom Elevation To First Reference Level: 0.00183192 m; Bottom Elevation To Home Story: 0.00183192 m; Bottom Elevation To Project Zero: 0.00183192 m; Bottom Elevation To Sea Level: 9.34183 m; Bottom Elevation To Second Reference Level: 0.00183192 m; Top Surface Area (Net): 0.14874 m2; Edge Surface Area (Net): 1.37988 m2; Bottom Surface Area (Net): 5.16109 m2
5 AMB.Geometria - 501.AMB.Longitud: 4.04251 m; 502.AMB.Amplada: 0.31 m; 503.AMB.Altura: 4.19817 m; 504.AMB.Gruix: 0.31 m; 506.AMB.Profunditat: 0 m
Component Quantities - Brick, Mass: 2397.05 kg; Brick, Projected Component Area (Net): 5.23142 m2; Brick, Projected Component Area (Gross): 17.0415 m2; Brick, Component Thickness: 0.31 m; Brick, Rectangular Component Height: 4.19817 m; Brick, Rectangular Component Width: 0.31 m; Brick, Component Cross Section Area: 1.30143 m2; Brick, Component Volume (Net): 1.59803 m3; Brick, Component Volume (Gross): 5.25915 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Brick 350 (3)
In: planta baixa
Classification: 30.10.10.10 Façanes in situ (GuBIMclass CA); Material: Brick
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Brick - Aged Natural; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F6; Hotlink and Element ID: F6; Layer: 00_RELLENO VANOS; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F6; Building Materials (All): Brick; Surfaces (All): Brick - Aged Natural; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.10 Façanes in situ; 104.AMB.ClassificacioCodi: 30.10.10.10; 105.AMB.ClassificacioDescripcio: Façanes in situ; 107.AMB.NomTipus: F6_Mur_350_Mao; 109.AMB.CodiTipus: F6; 111.AMB.DescripcioTipus: Mur de fàbrica de maó massís manual armat amb morter de calç 3,5 HL; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Mur_350_Mao
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.35 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.35 m; Top Offset: 0 m; Thickness: 0.35 m; Insulation Skin Thickness: 0 m; Top Elevation To First Reference Level: 2.82347 m; Top Elevation To Home Story: 2.82347 m; Top Elevation To Project Zero: 2.82347 m; Top Elevation To Sea Level: 12.1635 m; Top Elevation To Second Reference Level: 2.82347 m
5 AMB.Geometria - 502.AMB.Amplada: 0.35 m; 504.AMB.Gruix: 0.35 m; 506.AMB.Profunditat: 0 m
Component Quantities - Brick, Component Thickness: 0.35 m; Brick, Rectangular Component Width: 0.35 m
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
Pset_BuildingElementProxyCommon - Status: NEW
Name | Brick, Embodied Carbon | Brick, Embodied Energy (MJ) | Maximum Height of the Wall (m) = Minimum Height of the Wall (m) = Height (m) = 503.AMB.Altura (m) = Brick, Rectangular Component Height (m) | Average length of the Wall (m) = Length of Reference Line (m) = Length of the Wall Inside Face (Conditional) (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall at the Center (m) = Length of the Wall on the Inside Face (m) = Length of the Wall on the Outside Face (m) = 3D Length (m) = 501.AMB.Longitud (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area of the Wall Inside Face (Gross) (m2) = Surface Area of the Wall Outside Face (Gross) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) = Brick, Projected Component Area (Net) (m2) = Brick, Projected Component Area (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Volume (Gross) (m3) = Brick, Component Volume (Net) (m3) = Brick, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Floor Plan Perimeter (m) | Edge Surface Area (Net) (m2) | Brick, Mass (kg) | Brick, Component Cross Section Area (m2)
2 x F6 | 58.212 (kgCO₂) | 727.65 | 0.77 | 0.6 | 0.462 | 0.21 | 0.1617 | 2.05347 | 11.3935 | 1.9 | 0.959 | 242.55 | 0.2695
F6 | 32.886 (kgCO₂) | 411.075 | 0.58 | 0.45 | 0.261 | 0.1575 | 0.09135 | 2.24347 | 11.5835 | 1.6 | 0.721 | 137.025 | 0.203

# IfcBuildingElementProxy: Brick 350 x 300 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Brick
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: BMR - 004_; 109.AMB.CodiTipus: BMR - 004; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Brick, Component Type: Core
ArchiCADQuantities - Surface Area of Both Beam Ends: 0.261241 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Offset: 0 m; Height: 0.3 m; Width: 0.35 m; Elevation to Project Zero: 6.7018 m; Elevation to 1st Reference Level: 6.7018 m; Elevation to 2nd Reference Level: 6.7018 m; Elevation to Sea Level: 16.0418 m; Elevation to Linked/Home Story: 6.7018 m; Home Offset: 6.7018 m; Top Elevation To First Reference Level: 6.7018 m; Top Elevation To Home Story: 6.7018 m; Top Elevation To Project Zero: 6.7018 m; Top Elevation To Sea Level: 16.0418 m; Top Elevation To Second Reference Level: 6.7018 m; Cross Section Height at Top/End (perpendicular): 0.3 m; Cross Section Height at Bottom/Start (perpendicular): 0.3 m; Cross Section Width at Top/End (perpendicular): 0.35 m; Cross Section Width at Bottom/Start (perpendicular): 0.35 m; Cross Section Height at Top/End (cut): 0.373201 m; Cross Section Height at Bottom/Start (cut): 0.373201 m; Cross Section Width at Top/End (cut): 0.35 m; Cross Section Width at Bottom/Start (cut): 0.35 m; Cross Section Area at Bottom/Start: 0.13062 m2; Cross Section Area at Top/End: 0.13062 m2; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.35 m; 503.AMB.Altura: 0.3 m; 506.AMB.Profunditat: 0 m
ArchiCADProperties - Beam Cross Section: Rectangular; End Surface: Brick - Aged Natural; Left Side Surface: Brick - Aged Natural; Right Side Surface: Brick - Aged Natural; Beam Slant Angle: -36.5 deg; Element ID: BMR - 004; Hotlink and Element ID: BMR - 004; Layer: 00_ORNAMENTOS CORNISAS; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Basic; Parent ID: BMR - 004; Building Materials (All): Brick; Surfaces (All): Brick - Aged Natural; Roof Tiles - Dutch; Cover Fill: Background; Slant Angle: -36.5 deg; Number of Openings: 0; Top Surface: Roof Tiles - Dutch; Bottom Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Brick, Component Thickness: 0.35 m; Brick, Rectangular Component Height: 0.3 m; Brick, Rectangular Component Width: 0.35 m; Brick, Component Cross Section Area: 0.105 m2
Name | Brick, Embodied Carbon | Brick, Embodied Energy (MJ) | Surface Area of the Beam Left Side (Net) (m2) = Surface Area of the Beam Right Side (Net) (m2) = Brick, Projected Component Area (Net) (m2) = Brick, Projected Component Area (Gross) (m2) | Length Left (m) = Length Right (m) | Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Volume (Gross) (m3) = Brick, Component Volume (Net) (m3) = Brick, Component Volume (Gross) (m3) | Surface Area (m2) | 3D Length (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Top Surface Area (Net) (m2) = Bottom Surface Area (Net) (m2) | Brick, Mass (kg)
BMR - 004 | 87.405 (kgCO₂) | 1092.56 | 0.693691 | 2.3123 | 0.650566 | 0.242792 | 3.26723 | 2.53429 | 4.95319 | 14.2932 | 0.809306 | 364.188
BMR - 004 | 87.4823 (kgCO₂) | 1093.53 | 0.694304 | 2.31435 | 0.651141 | 0.243006 | 3.26989 | 2.53633 | 4.95198 | 14.292 | 0.810021 | 364.509

# IfcBuildingElementProxy: Brick 400 (2)
In: planta baixa
Classification: Wall (ARCHICAD Classification); 30.10.10.10 Façanes in situ (GuBIMclass CA); Material: Brick
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.10 Façanes in situ; 104.AMB.ClassificacioCodi: 30.10.10.10; 105.AMB.ClassificacioDescripcio: Façanes in situ; 107.AMB.NomTipus: F6_Mur_350_Mao; 109.AMB.CodiTipus: F6; 111.AMB.DescripcioTipus: Mur de fàbrica de maó massís manual armat amb morter de calç 3,5 HL; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Mur_350_Mao
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Brick - Aged Natural; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F6; Hotlink and Element ID: F6; Layer: 00_MURO LADRILLO; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F6; Building Materials (All): Brick; Surfaces (All): Brick - Aged Natural; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
5 AMB.Geometria - 502.AMB.Amplada: 0.4 m; 504.AMB.Gruix: 0.4 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; End Thickness of the Wall: 0.4 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.4 m; Elevation to Project Zero: 4.3113 m; Elevation to 1st Reference Level: 4.3113 m; Elevation to 2nd Reference Level: 4.3113 m; Elevation to Sea Level: 13.6513 m; Elevation to Linked/Home Story: 4.3113 m; Home Offset: 4.3113 m; Top Offset: 0 m; Thickness: 0.4 m; Insulation Skin Thickness: 0 m; Bottom Elevation To First Reference Level: 4.3113 m; Bottom Elevation To Home Story: 4.3113 m; Bottom Elevation To Project Zero: 4.3113 m; Bottom Elevation To Sea Level: 13.6513 m; Bottom Elevation To Second Reference Level: 4.3113 m
Component Quantities - Brick, Component Thickness: 0.4 m; Brick, Rectangular Component Width: 0.4 m
Name | Brick, Embodied Carbon | Brick, Embodied Energy (MJ) | Colliding Zones | 501.AMB.Longitud (m) = Length of Reference Line (m) = 3D Length (m) | 503.AMB.Altura (m) = Maximum Height of the Wall (m) = Height (m) = Brick, Rectangular Component Height (m) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of the Wall Inside Face (Conditional) (m) = Length of the Wall on the Inside Face (m) | Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Brick, Component Volume (Net) (m3) = Brick, Component Volume (Gross) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Brick, Mass (kg) | Brick, Projected Component Area (Net) (m2) = Brick, Projected Component Area (Gross) (m2) | Brick, Component Cross Section Area (m2)
F6 | 1074.05 (kgCO₂) | 13425.6 | Nau Santa Eulàlia | 20.5382 | 0.379456 | 2.66454e-15 | 0 | 19.968 | 7.71462 | 7.39055 | -3.55271e-15 | 20.1443 | 19.7918 | 7.92713 | 7.79336 | 8.14303 | 2.98348 | 3.1441 | 40.8693 | 4.69075 | 14.0308 | 15.4989 | 4475.22 | 7.77828 | 0.151782
F6 | 1120.69 (kgCO₂) | 14008.6 | Espai públic; Nau Santa Eulàlia | 21.4965 | 0.379 | 0 | -2.66454e-15 | 20.7218 | 8.03793 | 7.7438 | -1.33227e-15 | 21.2083 | 20.2353 | 8.51593 | 8.14716 | 8.4833 | 3.11302 | 3.33262 | 42.7047 | 4.6903 | 14.0303 | 16.0432 | 4669.53 | 8.13783 | 0.1516

# IfcBuildingElementProxy: Brick 450 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Brick
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Brick - Aged Natural; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: Brick; Building Material: Brick; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Building Materials (All): Brick; Surfaces (All): Brick - Aged Natural; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.45 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.45 m; Top Offset: 0 m; Thickness: 0.45 m; Insulation Skin Thickness: 0 m; Top Elevation To First Reference Level: 3.39321 m; Top Elevation To Home Story: 3.39321 m; Top Elevation To Project Zero: 3.39321 m; Top Elevation To Sea Level: 12.7332 m; Top Elevation To Second Reference Level: 3.39321 m
5 AMB.Geometria - 502.AMB.Amplada: 0.45 m; 504.AMB.Gruix: 0.45 m; 506.AMB.Profunditat: 0 m
Component Quantities - Brick, Component Thickness: 0.45 m; Brick, Rectangular Component Width: 0.45 m
Name | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | 107.AMB.NomTipus | Brick, Embodied Carbon | Brick, Embodied Energy (MJ) | Maximum Height of the Wall (m) = Height (m) = 503.AMB.Altura (m) = Brick, Rectangular Component Height (m) | Minimum Height of the Wall (m) | Average length of the Wall (m) = Length of Reference Line (m) = Length of the Wall Inside Face (Conditional) (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall at the Center (m) = Length of the Wall on the Inside Face (m) = Length of the Wall on the Outside Face (m) = 3D Length (m) = 501.AMB.Longitud (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) = Surface Area of the Wall Inside Face (Gross) (m2) = Surface Area of the Wall Outside Face (Gross) (m2) = Brick, Projected Component Area (Net) (m2) = Brick, Projected Component Area (Gross) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Brick, Component Volume (Net) (m3) = Brick, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Edge Surface Area (Net) (m2) | Brick, Mass (kg) | Brick, Component Cross Section Area (m2)
SW - 052 | SW - 052 | SW - 052_ | 685.314 (kgCO₂) | 8566.43 | 1.83133 | 0 | 2.31006 | 4.23047 | 2.18064 | 1.03949 | 1.90365 | 1.56188 | 10.9019 | 1.90371 | 5.52012 | 3.72707 | 2855.48 | 0.824097
F2 | F2 | F2_ | 785.892 (kgCO₂) | 9823.65 | 2.10791 | 2.10791 | 2.30142 | 4.85119 | 4.85119 | 1.03564 | 2.18303 | 1.2853 | 10.6253 | 2.18303 | 5.50284 | 3.9684 | 3274.55 | 0.948559

# IfcBuildingElementProxy: Concrete - Structural (3)
In: planta baixa
Classification: Slab (ARCHICAD Classification); Material: Concrete - Structural
ArchiCADProperties - Cast Shadow: yes; Receive Shadow: yes; Surface: Pavement - Terrazo; Element ID: SLA - 010; Hotlink and Element ID: SLA - 010; Layer: 00_PELDAÑOS; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Colliding Zones: Espai públic; Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Morph; Parent ID: SLA - 010; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Pavement - Terrazo; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 107.AMB.NomTipus: SLA - 010_; 109.AMB.CodiTipus: SLA - 010; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Volume (Net): 0.176882 m3; Elevation to Project Zero: 1.16425 m; Elevation to 1st Reference Level: 1.16425 m; Elevation to 2nd Reference Level: 1.16425 m; Elevation to Sea Level: 10.5043 m; Elevation to Linked/Home Story: 1.16425 m; Home Offset: 1.16425 m; Surface Area: 1.91901 m2; Floor Plan Perimeter: 2.49282 m; Top Elevation To First Reference Level: 1.71425 m; Top Elevation To Home Story: 1.71425 m; Top Elevation To Project Zero: 1.71425 m; Top Elevation To Sea Level: 11.0543 m; Top Elevation To Second Reference Level: 1.71425 m; Bottom Elevation To First Reference Level: 1.16425 m; Bottom Elevation To Home Story: 1.16425 m; Bottom Elevation To Project Zero: 1.16425 m; Bottom Elevation To Sea Level: 10.5043 m; Bottom Elevation To Second Reference Level: 1.16425 m; Bottom Surface Area (Net): 1.91901 m2
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
Component Quantities - Concrete - Structural, Mass: 406.829 kg; Concrete - Structural, Component Volume (Net): 0.176882 m3; Concrete - Structural, Component Volume (Gross): 0.176882 m3
Component Properties - Concrete - Structural, Embodied Carbon: 80.5521 (kgCO₂); Concrete - Structural, Embodied Energy: 781.111 MJ
Name | Area (m2) = Top Surface Area (Net) (m2)
2 x SLA - 010 | 0.358385
SLA - 010 | 0.358384

# IfcBuildingElementProxy: Concrete - Structural 138 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Concrete - Structural
Component Quantities - Concrete - Structural, Component Thickness: 0.1375 m
5 AMB.Geometria - 503.AMB.Altura: 0.1375 m; 504.AMB.Gruix: 0.1375 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Elevation Bottom: 1.57675 m; Elevation Top: 1.71425 m; Height: 0.1375 m; Elevation to Project Zero: 1.71425 m; Elevation to 1st Reference Level: 1.71425 m; Elevation to 2nd Reference Level: 1.71425 m; Elevation to Sea Level: 11.0543 m; Elevation to Linked/Home Story: 1.71425 m; Home Offset: 1.71425 m; Thickness: 0.1375 m; Floor Plan Holes Perimeter: 0 m; Top Elevation To First Reference Level: 1.71425 m; Top Elevation To Home Story: 1.71425 m; Top Elevation To Project Zero: 1.71425 m; Top Elevation To Sea Level: 11.0543 m; Top Elevation To Second Reference Level: 1.71425 m; Bottom Elevation To First Reference Level: 1.57675 m; Bottom Elevation To Home Story: 1.57675 m; Bottom Elevation To Project Zero: 1.57675 m; Bottom Elevation To Sea Level: 10.9168 m; Bottom Elevation To Second Reference Level: 1.57675 m
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SLA - 010_; 109.AMB.CodiTipus: SLA - 010; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Reference Plane Location: Top; Element ID: SLA - 010; Hotlink and Element ID: SLA - 010; Layer: 00_PELDAÑOS; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Colliding Zones: Espai públic; Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Basic; Parent ID: SLA - 010; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Pavement - Terrazo; Cover Fill: Carpet; Number of Openings: 0; Top Surface: Pavement - Terrazo; Edge Surface: Concrete - Bush hammered; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Name | Concrete - Structural, Embodied Carbon | Concrete - Structural, Embodied Energy (MJ) | Concrete - Structural, Mass (kg) | Concrete - Structural, Projected Component Area (Net) (m2) = Area (m2) = Surface Area (m2) = Top Surface Area (Net) (m2) = Bottom Surface Area (Net) (m2) | Concrete - Structural, Projected Component Area (Gross) (m2) = Surface Area of the Slab Top (Conditional) (m2) = Top Surface Area (Conditional) (m2) = Bottom Surface Area (Conditional) (m2) | Concrete - Structural, Component Volume (Net) (m3) = Volume (Net) (m3) | Concrete - Structural, Component Volume (Gross) (m3) = Volume (Conditional) (m3) | Surface Area of the Slab Bottom (Gross) (m2) = Surface Area of the Slab Bottom (Gross, with holes) (m2) = Surface Area of the Slab Top (Gross) (m2) = Surface Area of the Slab Top (Gross, with holes) (m2) = Bottom Surface Area (Gross) (m2) = Top Surface Area (Gross) (m2) | Surface Area of the Slab Edges (Gross) (m2) = Surface Area of the Slab Edges (Gross, with holes) (m2) = Edge Surface Area (Gross) (m2) | Holes Surface Area (m2) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Edge Surface Area (Net) (m2)
SLA - 010 | 46.8865 (kgCO₂) | 454.657 | 236.8 | 0.748776 | 0.301973 | 0.102957 | 0.0415212 | 0.748947 | 0.602161 | 0.000171023 | 0.10298 | 4.37897 | 0.537631
SLA - 010 | 77.8243 (kgCO₂) | 754.66 | 393.052 | 1.24285 | 0.364567 | 0.170892 | 0.050128 | 1.24285 | 0.653223 | 0 | 0.170892 | 4.75071 | 0.653223

# IfcBuildingElementProxy: Concrete - Structural 148 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Concrete - Structural
ArchiCADProperties - Reference Plane Location: Top; Element ID: SLA - 010; Hotlink and Element ID: SLA - 010; Layer: 00_PELDAÑOS; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Colliding Zones: Espai públic; Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Basic; Parent ID: SLA - 010; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Pavement - Terrazo; Cover Fill: Carpet; Number of Openings: 0; Top Surface: Pavement - Terrazo; Edge Surface: Concrete - Bush hammered; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SLA - 010_; 109.AMB.CodiTipus: SLA - 010; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Concrete - Structural, Component Thickness: 0.147924 m
5 AMB.Geometria - 503.AMB.Altura: 0.147924 m; 504.AMB.Gruix: 0.147924 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Elevation Bottom: 1.42883 m; Elevation Top: 1.57675 m; Height: 0.147924 m; Elevation to Project Zero: 1.57675 m; Elevation to 1st Reference Level: 1.57675 m; Elevation to 2nd Reference Level: 1.57675 m; Elevation to Sea Level: 10.9168 m; Elevation to Linked/Home Story: 1.57675 m; Home Offset: 1.57675 m; Thickness: 0.147924 m; Floor Plan Holes Perimeter: 0 m; Top Elevation To First Reference Level: 1.57675 m; Top Elevation To Home Story: 1.57675 m; Top Elevation To Project Zero: 1.57675 m; Top Elevation To Sea Level: 10.9168 m; Top Elevation To Second Reference Level: 1.57675 m; Bottom Elevation To First Reference Level: 1.42883 m; Bottom Elevation To Home Story: 1.42883 m; Bottom Elevation To Project Zero: 1.42883 m; Bottom Elevation To Sea Level: 10.7688 m; Bottom Elevation To Second Reference Level: 1.42883 m
Name | Concrete - Structural, Embodied Carbon | Concrete - Structural, Embodied Energy (MJ) | Concrete - Structural, Mass (kg) | Concrete - Structural, Projected Component Area (Net) (m2) = Concrete - Structural, Projected Component Area (Gross) (m2) = Surface Area of the Slab Top (Conditional) (m2) = Area (m2) = Surface Area (m2) = Top Surface Area (Net) (m2) = Top Surface Area (Conditional) (m2) = Bottom Surface Area (Net) (m2) = Bottom Surface Area (Conditional) (m2) | Concrete - Structural, Component Volume (Net) (m3) = Concrete - Structural, Component Volume (Gross) (m3) = Volume (Net) (m3) = Volume (Conditional) (m3) | Surface Area of the Slab Bottom (Gross) (m2) = Surface Area of the Slab Bottom (Gross, with holes) (m2) = Surface Area of the Slab Top (Gross) (m2) = Surface Area of the Slab Top (Gross, with holes) (m2) = Bottom Surface Area (Gross) (m2) = Top Surface Area (Gross) (m2) | Surface Area of the Slab Edges (Gross) (m2) = Surface Area of the Slab Edges (Gross, with holes) (m2) = Edge Surface Area (Gross) (m2) | Holes Surface Area (m2) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Edge Surface Area (Net) (m2)
SLA - 010 | 66.5727 (kgCO₂) | 645.554 | 336.226 | 0.988244 | 0.146185 | 0.997419 | 0.743073 | 0.00917535 | 0.147542 | 5.02199 | 0.429674
SLA - 010 | 50.3251 (kgCO₂) | 488.001 | 254.167 | 0.747055 | 0.110508 | 0.78466 | 0.618652 | 0.0376041 | 0.11607 | 4.18222 | 0.375162

# IfcBuildingElementProxy: Concrete - Structural 200 (6)
In: planta coberta
Classification: 30.10.10.50 Remats de façanes (GuBIMclass CA); Material: Concrete - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Concrete - Bush hammered; Outside Face Surface: Concrete - Bush hammered; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F2; Hotlink and Element ID: F2; Layer: 00_MURO HORMIGON; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F2; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.50 Remats de façanes; 104.AMB.ClassificacioCodi: 30.10.10.50; 105.AMB.ClassificacioDescripcio: Remats de façanes; 107.AMB.NomTipus: F2_Mur_200_Formigo; 109.AMB.CodiTipus: F2; 111.AMB.DescripcioTipus: Ampit de formigó armat vist a dues cares amb un 20% d’àrids reciclats de maó; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Pset_BuildingElementProxyCommon - Status: NEW
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Mur_200_Formigo
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.2 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.2 m; Elevation to Project Zero: 4.5 m; Elevation to 1st Reference Level: 4.5 m; Elevation to 2nd Reference Level: 4.5 m; Elevation to Sea Level: 13.84 m; Elevation to Linked/Home Story: 0 m; Home Offset: 0 m; Top Offset: 0 m; Thickness: 0.2 m; Insulation Skin Thickness: 0 m; Bottom Elevation To First Reference Level: 4.5 m; Bottom Elevation To Home Story: 0 m; Bottom Elevation To Project Zero: 4.5 m; Bottom Elevation To Sea Level: 13.84 m; Bottom Elevation To Second Reference Level: 4.5 m
Component Quantities - Concrete - Structural, Component Thickness: 0.2 m; Concrete - Structural, Rectangular Component Width: 0.2 m
5 AMB.Geometria - 502.AMB.Amplada: 0.2 m; 504.AMB.Gruix: 0.2 m; 506.AMB.Profunditat: 0 m
Name | Colliding Zones | Concrete - Structural, Embodied Carbon | Concrete - Structural, Embodied Energy (MJ) | Maximum Height of the Wall (m) = Top Elevation To Home Story (m) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Length of Reference Line (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) = Length of the Wall on the Inside Face (m) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = Concrete - Structural, Rectangular Component Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) = Volume (Conditional) (m3) = Concrete - Structural, Component Volume (Net) (m3) = Concrete - Structural, Component Volume (Gross) (m3) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Concrete - Structural, Mass (kg) | Concrete - Structural, Projected Component Area (Net) (m2) = Concrete - Structural, Projected Component Area (Gross) (m2) | Concrete - Structural, Component Cross Section Area (m2)
F2 | Nau Santa Eulàlia | 253.849 (kgCO₂) | 2461.56 | 2 | 1.41463 | 2.7776 | 2.79659 | 1.52045 | 1.30882 | 2.7776 | 2.79659 | 0.302959 | 2 | 0.55742 | 1.52045 | 0.55742 | 3.32045 | 6.5 | 15.84 | 0.948599 | 1282.07 | 2.80021 | 0.4
F2 | Nau Santa Eulàlia | 660.016 (kgCO₂) | 6400.16 | 0.958342 | 7.76199 | 7.24477 | 7.24834 | 7.9643 | 7.55969 | 7.62895 | 7.63253 | 1.51231 | 0.958342 | 1.44931 | 7.57472 | 1.52615 | 16.0933 | 5.45834 | 14.7983 | 3.02462 | 3333.41 | 7.25917 | 0.191668
F2 | Nau Santa Eulàlia | 119.227 (kgCO₂) | 1156.15 | 1.21436 | 1.10549 | 1.31589 | 1.30219 | 1.2 | 1.01099 | 1.31589 | 1.30219 | 0.24113 | 2 | 0.261808 | 1.2113 | 0.261808 | 2.68617 | 5.71436 | 15.0544 | 0.729083 | 602.159 | 1.31589 | 0.4
F2 | Nau Santa Eulàlia | 1346.96 (kgCO₂) | 13061.4 | 2 | 7.67392 | 14.6342 | 14.9432 | 7.87249 | 7.47534 | 15.419 | 15.745 | 1.4947 | 2 | 2.95775 | 7.48665 | 3.1164 | 15.9118 | 6.5 | 15.84 | 3.02251 | 6802.82 | 14.973 | 0.4
F2 | Espai públic; Nau Santa Eulàlia | 117.759 (kgCO₂) | 1141.9 | 1.21167 | 1.0922 | 1.28382 | 1.30202 | 1.2 | 0.9844 | 1.28382 | 1.30202 | 0.238511 | 2 | 0.258583 | 1.2 | 0.258583 | 2.67848 | 5.71167 | 15.0517 | 0.724311 | 594.742 | 1.30202 | 0.4
F2 | Nau Santa Eulàlia | 257.179 (kgCO₂) | 2493.86 | 2 | 1.43613 | 2.83626 | 2.81106 | 1.52889 | 1.34336 | 2.83626 | 2.81106 | 0.307282 | 2 | 0.564733 | 1.54393 | 0.564733 | 3.34505 | 6.5 | 15.84 | 0.956507 | 1298.89 | 2.84114 | 0.4

# IfcBuildingElementProxy: Concrete - Structural 265 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Concrete - Structural
ArchiCADProperties - Reference Plane Location: Top; Element ID: SLA - 010; Hotlink and Element ID: SLA - 010; Layer: 00_PELDAÑOS; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Colliding Zones: Espai públic; Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Basic; Parent ID: SLA - 010; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Pavement - Terrazo; Cover Fill: Carpet; Number of Openings: 0; Top Surface: Pavement - Terrazo; Edge Surface: Concrete - Bush hammered; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SLA - 010_; 109.AMB.CodiTipus: SLA - 010; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Elevation Bottom: 1.16425 m; Elevation Top: 1.42883 m; Height: 0.264576 m; Elevation to Project Zero: 1.42883 m; Elevation to 1st Reference Level: 1.42883 m; Elevation to 2nd Reference Level: 1.42883 m; Elevation to Sea Level: 10.7688 m; Elevation to Linked/Home Story: 1.42883 m; Home Offset: 1.42883 m; Thickness: 0.264576 m; Floor Plan Holes Perimeter: 0 m; Top Elevation To First Reference Level: 1.42883 m; Top Elevation To Home Story: 1.42883 m; Top Elevation To Project Zero: 1.42883 m; Top Elevation To Sea Level: 10.7688 m; Top Elevation To Second Reference Level: 1.42883 m; Bottom Elevation To First Reference Level: 1.16425 m; Bottom Elevation To Home Story: 1.16425 m; Bottom Elevation To Project Zero: 1.16425 m; Bottom Elevation To Sea Level: 10.5043 m; Bottom Elevation To Second Reference Level: 1.16425 m
5 AMB.Geometria - 503.AMB.Altura: 0.264576 m; 504.AMB.Gruix: 0.264576 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete - Structural, Component Thickness: 0.264576 m
Name | Surface Area of the Slab Top (Conditional) (m2) = Area (m2) = Surface Area (m2) = Top Surface Area (Net) (m2) = Top Surface Area (Conditional) (m2) = Bottom Surface Area (Net) (m2) = Bottom Surface Area (Conditional) (m2) = Concrete - Structural, Projected Component Area (Net) (m2) = Concrete - Structural, Projected Component Area (Gross) (m2) | Surface Area of the Slab Bottom (Gross) (m2) = Surface Area of the Slab Bottom (Gross, with holes) (m2) = Surface Area of the Slab Top (Gross) (m2) = Surface Area of the Slab Top (Gross, with holes) (m2) = Bottom Surface Area (Gross) (m2) = Top Surface Area (Gross) (m2) | Surface Area of the Slab Edges (Gross) (m2) = Surface Area of the Slab Edges (Gross, with holes) (m2) = Edge Surface Area (Gross) (m2) | Holes Surface Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Concrete - Structural, Component Volume (Net) (m3) = Concrete - Structural, Component Volume (Gross) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Edge Surface Area (Net) (m2) | Concrete - Structural, Embodied Carbon | Concrete - Structural, Embodied Energy (MJ) | Concrete - Structural, Mass (kg)
SLA - 010 | 1.8185 | 1.8335 | 1.62553 | 0.0149952 | 0.481131 | 0.485099 | 6.14259 | 1.12884 | 219.107 (kgCO₂) | 2124.68 | 1106.6
SLA - 010 | 1.25233 | 1.28671 | 1.27277 | 0.0343759 | 0.331337 | 0.340432 | 4.8106 | 0.83835 | 150.891 (kgCO₂) | 1463.18 | 762.074

# IfcBuildingElementProxy: Concrete - Structural 400 (8)
In: planta baixa
Material: Concrete - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Concrete - Bush hammered; Outside Face Surface: Concrete - Bush hammered; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Building Materials (All): Concrete - Structural; Surfaces (All): Concrete - Bush hammered; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 20
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.4 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.4 m; Top Offset: 0 m; Thickness: 0.4 m; Insulation Skin Thickness: 0 m
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Si
5 AMB.Geometria - 502.AMB.Amplada: 0.4 m; 504.AMB.Gruix: 0.4 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete - Structural, Component Thickness: 0.4 m; Concrete - Structural, Rectangular Component Width: 0.4 m
