Properties of the parts of a building model (IFC2X3), part 36 of 99

# IfcBuildingElementProxy: Rhino_Object_129, Object_129
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_129 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_129_; 109.AMB.CodiTipus: Object_129; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1290, Object_1290
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1290; Hotlink and Element ID: Object_1290; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1290; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1290; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1290 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1290_; 109.AMB.CodiTipus: Object_1290; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23274 m; Elevation to 1st Reference Level: 1.23274 m; Elevation to 2nd Reference Level: 1.23274 m; Elevation to Sea Level: 10.5727 m; Elevation to Linked/Home Story: 1.23274 m; Home Offset: 1.23274 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35282 m; Top Elevation To Home Story: 1.35282 m; Top Elevation To Project Zero: 1.35282 m; Top Elevation To Sea Level: 10.6928 m; Top Elevation To Second Reference Level: 1.35282 m; Bottom Elevation To First Reference Level: 1.23274 m; Bottom Elevation To Home Story: 1.23274 m; Bottom Elevation To Project Zero: 1.23274 m; Bottom Elevation To Sea Level: 10.5727 m; Bottom Elevation To Second Reference Level: 1.23274 m; Survey Coordinate X: 426549 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5727 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1290 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1291, Object_1291
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1291 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1291; Hotlink and Element ID: Object_1291; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1291; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1291; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1291_; 109.AMB.CodiTipus: Object_1291; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23281 m; Elevation to 1st Reference Level: 1.23281 m; Elevation to 2nd Reference Level: 1.23281 m; Elevation to Sea Level: 10.5728 m; Elevation to Linked/Home Story: 1.23281 m; Home Offset: 1.23281 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.3529 m; Top Elevation To Home Story: 1.3529 m; Top Elevation To Project Zero: 1.3529 m; Top Elevation To Sea Level: 10.6929 m; Top Elevation To Second Reference Level: 1.3529 m; Bottom Elevation To First Reference Level: 1.23281 m; Bottom Elevation To Home Story: 1.23281 m; Bottom Elevation To Project Zero: 1.23281 m; Bottom Elevation To Sea Level: 10.5728 m; Bottom Elevation To Second Reference Level: 1.23281 m; Survey Coordinate X: 426549 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5728 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1291 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1292, Object_1292
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1292; Hotlink and Element ID: Object_1292; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1292; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1292; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1292 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1292_; 109.AMB.CodiTipus: Object_1292; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23289 m; Elevation to 1st Reference Level: 1.23289 m; Elevation to 2nd Reference Level: 1.23289 m; Elevation to Sea Level: 10.5729 m; Elevation to Linked/Home Story: 1.23289 m; Home Offset: 1.23289 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35297 m; Top Elevation To Home Story: 1.35297 m; Top Elevation To Project Zero: 1.35297 m; Top Elevation To Sea Level: 10.693 m; Top Elevation To Second Reference Level: 1.35297 m; Bottom Elevation To First Reference Level: 1.23289 m; Bottom Elevation To Home Story: 1.23289 m; Bottom Elevation To Project Zero: 1.23289 m; Bottom Elevation To Sea Level: 10.5729 m; Bottom Elevation To Second Reference Level: 1.23289 m; Survey Coordinate X: 426549 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5729 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1292 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1293, Object_1293
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1293; Hotlink and Element ID: Object_1293; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1293; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1293; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1293 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1293_; 109.AMB.CodiTipus: Object_1293; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23297 m; Elevation to 1st Reference Level: 1.23297 m; Elevation to 2nd Reference Level: 1.23297 m; Elevation to Sea Level: 10.573 m; Elevation to Linked/Home Story: 1.23297 m; Home Offset: 1.23297 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35305 m; Top Elevation To Home Story: 1.35305 m; Top Elevation To Project Zero: 1.35305 m; Top Elevation To Sea Level: 10.6931 m; Top Elevation To Second Reference Level: 1.35305 m; Bottom Elevation To First Reference Level: 1.23297 m; Bottom Elevation To Home Story: 1.23297 m; Bottom Elevation To Project Zero: 1.23297 m; Bottom Elevation To Sea Level: 10.573 m; Bottom Elevation To Second Reference Level: 1.23297 m; Survey Coordinate X: 426549 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.573 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1293 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1294, Object_1294
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1294; Hotlink and Element ID: Object_1294; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1294; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1294; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1294 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1294_; 109.AMB.CodiTipus: Object_1294; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23305 m; Elevation to 1st Reference Level: 1.23305 m; Elevation to 2nd Reference Level: 1.23305 m; Elevation to Sea Level: 10.5731 m; Elevation to Linked/Home Story: 1.23305 m; Home Offset: 1.23305 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35313 m; Top Elevation To Home Story: 1.35313 m; Top Elevation To Project Zero: 1.35313 m; Top Elevation To Sea Level: 10.6931 m; Top Elevation To Second Reference Level: 1.35313 m; Bottom Elevation To First Reference Level: 1.23305 m; Bottom Elevation To Home Story: 1.23305 m; Bottom Elevation To Project Zero: 1.23305 m; Bottom Elevation To Sea Level: 10.5731 m; Bottom Elevation To Second Reference Level: 1.23305 m; Survey Coordinate X: 426549 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5731 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1294 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1295, Object_1295
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1295; Hotlink and Element ID: Object_1295; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1295; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1295; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1295 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1295_; 109.AMB.CodiTipus: Object_1295; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23313 m; Elevation to 1st Reference Level: 1.23313 m; Elevation to 2nd Reference Level: 1.23313 m; Elevation to Sea Level: 10.5731 m; Elevation to Linked/Home Story: 1.23313 m; Home Offset: 1.23313 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35321 m; Top Elevation To Home Story: 1.35321 m; Top Elevation To Project Zero: 1.35321 m; Top Elevation To Sea Level: 10.6932 m; Top Elevation To Second Reference Level: 1.35321 m; Bottom Elevation To First Reference Level: 1.23313 m; Bottom Elevation To Home Story: 1.23313 m; Bottom Elevation To Project Zero: 1.23313 m; Bottom Elevation To Sea Level: 10.5731 m; Bottom Elevation To Second Reference Level: 1.23313 m; Survey Coordinate X: 426548 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5731 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1295 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1296, Object_1296
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1296; Hotlink and Element ID: Object_1296; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1296; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1296; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1296 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1296_; 109.AMB.CodiTipus: Object_1296; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23321 m; Elevation to 1st Reference Level: 1.23321 m; Elevation to 2nd Reference Level: 1.23321 m; Elevation to Sea Level: 10.5732 m; Elevation to Linked/Home Story: 1.23321 m; Home Offset: 1.23321 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35329 m; Top Elevation To Home Story: 1.35329 m; Top Elevation To Project Zero: 1.35329 m; Top Elevation To Sea Level: 10.6933 m; Top Elevation To Second Reference Level: 1.35329 m; Bottom Elevation To First Reference Level: 1.23321 m; Bottom Elevation To Home Story: 1.23321 m; Bottom Elevation To Project Zero: 1.23321 m; Bottom Elevation To Sea Level: 10.5732 m; Bottom Elevation To Second Reference Level: 1.23321 m; Survey Coordinate X: 426548 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5732 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1296 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1297, Object_1297
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1297; Hotlink and Element ID: Object_1297; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1297; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1297; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1297 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1297_; 109.AMB.CodiTipus: Object_1297; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23329 m; Elevation to 1st Reference Level: 1.23329 m; Elevation to 2nd Reference Level: 1.23329 m; Elevation to Sea Level: 10.5733 m; Elevation to Linked/Home Story: 1.23329 m; Home Offset: 1.23329 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35337 m; Top Elevation To Home Story: 1.35337 m; Top Elevation To Project Zero: 1.35337 m; Top Elevation To Sea Level: 10.6934 m; Top Elevation To Second Reference Level: 1.35337 m; Bottom Elevation To First Reference Level: 1.23329 m; Bottom Elevation To Home Story: 1.23329 m; Bottom Elevation To Project Zero: 1.23329 m; Bottom Elevation To Sea Level: 10.5733 m; Bottom Elevation To Second Reference Level: 1.23329 m; Survey Coordinate X: 426548 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5733 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1297 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1298, Object_1298
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1298; Hotlink and Element ID: Object_1298; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1298; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1298; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1298 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1298_; 109.AMB.CodiTipus: Object_1298; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23337 m; Elevation to 1st Reference Level: 1.23337 m; Elevation to 2nd Reference Level: 1.23337 m; Elevation to Sea Level: 10.5734 m; Elevation to Linked/Home Story: 1.23337 m; Home Offset: 1.23337 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35345 m; Top Elevation To Home Story: 1.35345 m; Top Elevation To Project Zero: 1.35345 m; Top Elevation To Sea Level: 10.6934 m; Top Elevation To Second Reference Level: 1.35345 m; Bottom Elevation To First Reference Level: 1.23337 m; Bottom Elevation To Home Story: 1.23337 m; Bottom Elevation To Project Zero: 1.23337 m; Bottom Elevation To Sea Level: 10.5734 m; Bottom Elevation To Second Reference Level: 1.23337 m; Survey Coordinate X: 426548 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5734 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1298 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1299, Object_1299
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1299; Hotlink and Element ID: Object_1299; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1299; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1299; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1299 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1299_; 109.AMB.CodiTipus: Object_1299; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23345 m; Elevation to 1st Reference Level: 1.23345 m; Elevation to 2nd Reference Level: 1.23345 m; Elevation to Sea Level: 10.5734 m; Elevation to Linked/Home Story: 1.23345 m; Home Offset: 1.23345 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35353 m; Top Elevation To Home Story: 1.35353 m; Top Elevation To Project Zero: 1.35353 m; Top Elevation To Sea Level: 10.6935 m; Top Elevation To Second Reference Level: 1.35353 m; Bottom Elevation To First Reference Level: 1.23345 m; Bottom Elevation To Home Story: 1.23345 m; Bottom Elevation To Project Zero: 1.23345 m; Bottom Elevation To Sea Level: 10.5734 m; Bottom Elevation To Second Reference Level: 1.23345 m; Survey Coordinate X: 426548 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5734 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1299 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_130, Object_130
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_130; Hotlink and Element ID: Object_130; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_130; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_130; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_130 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_130_; 109.AMB.CodiTipus: Object_130; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
AC_Equantity_Rhino_Object_130 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m

# IfcBuildingElementProxy: Rhino_Object_1300, Object_1300
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1300 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1300; Hotlink and Element ID: Object_1300; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1300; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1300; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1300_; 109.AMB.CodiTipus: Object_1300; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1300 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23352 m; Elevation to 1st Reference Level: 1.23352 m; Elevation to 2nd Reference Level: 1.23352 m; Elevation to Sea Level: 10.5735 m; Elevation to Linked/Home Story: 1.23352 m; Home Offset: 1.23352 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.3536 m; Top Elevation To Home Story: 1.3536 m; Top Elevation To Project Zero: 1.3536 m; Top Elevation To Sea Level: 10.6936 m; Top Elevation To Second Reference Level: 1.3536 m; Bottom Elevation To First Reference Level: 1.23352 m; Bottom Elevation To Home Story: 1.23352 m; Bottom Elevation To Project Zero: 1.23352 m; Bottom Elevation To Sea Level: 10.5735 m; Bottom Elevation To Second Reference Level: 1.23352 m; Survey Coordinate X: 426548 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5735 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2

# IfcBuildingElementProxy: Rhino_Object_1301, Object_1301
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1301; Hotlink and Element ID: Object_1301; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1301; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1301; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1301 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1301_; 109.AMB.CodiTipus: Object_1301; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.2336 m; Elevation to 1st Reference Level: 1.2336 m; Elevation to 2nd Reference Level: 1.2336 m; Elevation to Sea Level: 10.5736 m; Elevation to Linked/Home Story: 1.2336 m; Home Offset: 1.2336 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35368 m; Top Elevation To Home Story: 1.35368 m; Top Elevation To Project Zero: 1.35368 m; Top Elevation To Sea Level: 10.6937 m; Top Elevation To Second Reference Level: 1.35368 m; Bottom Elevation To First Reference Level: 1.2336 m; Bottom Elevation To Home Story: 1.2336 m; Bottom Elevation To Project Zero: 1.2336 m; Bottom Elevation To Sea Level: 10.5736 m; Bottom Elevation To Second Reference Level: 1.2336 m; Survey Coordinate X: 426547 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 10.5736 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1301 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1302, Object_1302
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1302; Hotlink and Element ID: Object_1302; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1302; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1302; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1302 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1302_; 109.AMB.CodiTipus: Object_1302; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23368 m; Elevation to 1st Reference Level: 1.23368 m; Elevation to 2nd Reference Level: 1.23368 m; Elevation to Sea Level: 10.5737 m; Elevation to Linked/Home Story: 1.23368 m; Home Offset: 1.23368 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35376 m; Top Elevation To Home Story: 1.35376 m; Top Elevation To Project Zero: 1.35376 m; Top Elevation To Sea Level: 10.6938 m; Top Elevation To Second Reference Level: 1.35376 m; Bottom Elevation To First Reference Level: 1.23368 m; Bottom Elevation To Home Story: 1.23368 m; Bottom Elevation To Project Zero: 1.23368 m; Bottom Elevation To Sea Level: 10.5737 m; Bottom Elevation To Second Reference Level: 1.23368 m; Survey Coordinate X: 426547 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 10.5737 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1302 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1303, Object_1303
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1303; Hotlink and Element ID: Object_1303; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1303; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1303; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1303 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1303_; 109.AMB.CodiTipus: Object_1303; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
