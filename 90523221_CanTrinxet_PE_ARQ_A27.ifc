Properties of the parts of a building model (IFC2X3), part 71 of 99

# IfcBuildingElementProxy: Rhino_Object_1809, Object_1809
AC_Pset_Rhino_Object_1809 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1809_; 109.AMB.CodiTipus: Object_1809; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1809 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426548 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1810, Object_1810
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1810; Hotlink and Element ID: Object_1810; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1810; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1810; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1810 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1810_; 109.AMB.CodiTipus: Object_1810; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426548 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1810 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1811, Object_1811
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1811; Hotlink and Element ID: Object_1811; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1811; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1811; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1811 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1811_; 109.AMB.CodiTipus: Object_1811; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426547 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1811 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1812, Object_1812
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1812 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1812_; 109.AMB.CodiTipus: Object_1812; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426546 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1812; Hotlink and Element ID: Object_1812; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1812; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1812; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
AC_Equantity_Rhino_Object_1812 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m

# IfcBuildingElementProxy: Rhino_Object_1813, Object_1813
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1813; Hotlink and Element ID: Object_1813; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1813; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1813; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1813 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1813_; 109.AMB.CodiTipus: Object_1813; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426546 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1813 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_1814, Object_1814
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1814; Hotlink and Element ID: Object_1814; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1814; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1814; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1814 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426545 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1814 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1814_; 109.AMB.CodiTipus: Object_1814; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1815, Object_1815
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1815; Hotlink and Element ID: Object_1815; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1815; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1815; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1815 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1815_; 109.AMB.CodiTipus: Object_1815; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1815 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1816, Object_1816
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1816; Hotlink and Element ID: Object_1816; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1816; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1816; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1816_; 109.AMB.CodiTipus: Object_1816; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1816 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
AC_Pset_Rhino_Object_1816 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1817, Object_1817
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1817; Hotlink and Element ID: Object_1817; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1817; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1817; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1817 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1817_; 109.AMB.CodiTipus: Object_1817; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1817 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1818, Object_1818
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1818; Hotlink and Element ID: Object_1818; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1818; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1818; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1818 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1818_; 109.AMB.CodiTipus: Object_1818; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426543 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1818 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1819, Object_1819
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1819; Hotlink and Element ID: Object_1819; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1819; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1819; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1819 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1819_; 109.AMB.CodiTipus: Object_1819; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1819 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1820, Object_1820
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1820 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1820_; 109.AMB.CodiTipus: Object_1820; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1820 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1820; Hotlink and Element ID: Object_1820; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1820; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1820; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_1821, Object_1821
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1821; Hotlink and Element ID: Object_1821; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1821; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1821; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1821 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1821_; 109.AMB.CodiTipus: Object_1821; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1821 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1822, Object_1822
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1822_; 109.AMB.CodiTipus: Object_1822; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1822 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1822; Hotlink and Element ID: Object_1822; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1822; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1822; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1822 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2

# IfcBuildingElementProxy: Rhino_Object_1823, Object_1823
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1823; Hotlink and Element ID: Object_1823; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1823; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1823; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1823 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1823_; 109.AMB.CodiTipus: Object_1823; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1823 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2

# IfcBuildingElementProxy: Rhino_Object_1824, Object_1824
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1824 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1824; Hotlink and Element ID: Object_1824; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1824; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1824; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
