Properties of the parts of a building model (IFC2X3), part 93 of 99

# IfcBuildingElementProxy: Steel Universal Section (1) 160 x 160 (76)
Name | Classification | 201.AMB.EsEstructural | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 109.AMB.CodiTipus = Element ID = Hotlink and Element ID = Parent ID | Layer | Element Type | Surfaces (All) | Slant Angle (deg) | AUX_104.AMB.ClassificacioCodiCateg | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | Area (m2) | Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) | Width (m) = Cross Section Width at Top/End (perpendicular) (m) = Cross Section Width at Bottom/Start (perpendicular) (m) = Cross Section Width at Top/End (cut) (m) = Cross Section Width at Bottom/Start (cut) (m) = 502.AMB.Amplada (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Cross Section Height at Top/End (cut) (m) | Cross Section Height at Bottom/Start (cut) (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) | Steel - Structural, Mass (kg) | Steel - Structural, Component Cross Section Area (m2) | Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3)
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 230.874 (kgCO₂) | 3490.92 | 0.502054 | 0.160001 | 0.0178308 | 0.16 | 5.43422 | 14.7742 | 2.94103 | 3.26119 | 0.0180758 | 5.4755 | 14.8155 | 4.58191 | 13.9219 | 0.165191 | 0.332225 | 0.0121266 | 0.00470811 | 0.953782 | 0.965909 | 139.081 | 0.0058402 | 0.0178308 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; Colliding Zones: Nau Santa Eulàlia; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0168347 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.476824 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.4932 m2; Volume (Conditional): 0.0178308 m3
CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 441.398 (kgCO₂) | 6674.14 | 0.0058402 | 5.83713 | 0.03409 | 0.16 | 0.27 | 9.61 | 5.51027 | 5.93698 | 0.03409 | 6.20698 | 15.547 | 0.27 | 9.61 | 0.255888 | 0.160001 | 0.0058402 | 0.00934019 | 0.00934019 | 5.51027 | 265.902 | 0.0058402 | 0.03409 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.03409 m3; Core Width: 0.16 m; Surface Area of the Column Core (Gross, without Top/Bottom): 5.51027 m2; Surface Area of the Column Core Top (Gross): 0.00934019 m2; Surface Area of the Column Core Bottom (Gross): 0.0058402 m2; Volume of the Column Core (Gross): 0.03409 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 5.93698 m; Minimum Height of the Column: 5.73728 m; Surface Area of the Column Core Bottom (Net): 0.0058402 m2; Surface Area of the Column Core (Net, without Top/Bottom): 5.51027 m2; Surface Area of the Column Core Top (Net): 0.00934019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00934019 m2
CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 441.049 (kgCO₂) | 6668.87 | 0.0058402 | 5.83252 | 0.0340631 | 0.16 | 0.27 | 9.61 | 5.50591 | 5.93236 | 0.0340631 | 6.20236 | 15.5424 | 0.27 | 9.61 | 0.255888 | 0.160001 | 0.0058402 | 0.00934019 | 0.00934019 | 5.50591 | 265.692 | 0.0058402 | 0.0340631 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0340631 m3; Core Width: 0.16 m; Surface Area of the Column Core (Gross, without Top/Bottom): 5.50591 m2; Surface Area of the Column Core Top (Gross): 0.00934019 m2; Surface Area of the Column Core Bottom (Gross): 0.0058402 m2; Volume of the Column Core (Gross): 0.0340631 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 5.93236 m; Minimum Height of the Column: 5.73267 m; Surface Area of the Column Core Bottom (Net): 0.0058402 m2; Surface Area of the Column Core (Net, without Top/Bottom): 5.50591 m2; Surface Area of the Column Core Top (Net): 0.00934019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00934019 m2
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 423.003 (kgCO₂) | 6396.01 | 0.912706 | 0.160001 | 0.0326694 | 0.16 | 6.10252 | 15.4425 | 5.42998 | 5.88943 | 0.0333895 | 6.20641 | 15.5464 | 4.61966 | 13.9597 | 0.207534 | 0.265864 | 0.00970431 | 0.0029047 | 1.77534 | 1.75451 | 254.821 | 0.0058402 | 0.0326694 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.012609 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.869661 m2; Length Left: 5.71718 m; Length Right: 5.71718 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.905855 m2; Volume (Conditional): 0.0326694 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 230.118 (kgCO₂) | 3479.49 | 0.500711 | 0.160001 | 0.0177725 | 0.16 | 5.43422 | 14.7742 | 2.93439 | 3.26119 | 0.0180758 | 5.4755 | 14.8155 | 4.58191 | 13.9219 | 0.165191 | 0.332225 | 0.0121266 | 0.00000574661 | 0.951137 | 0.963265 | 138.625 | 0.0058402 | 0.0177725 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; Colliding Zones: Nau Santa Eulàlia; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0121323 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.473997 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.492145 m2; Volume (Conditional): 0.0177725 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 415.721 (kgCO₂) | 6285.9 | 0.898499 | 0.160001 | 0.0321069 | 0.16 | 6.1 | 15.44 | 5.33316 | 5.80217 | 0.0328799 | 6.20389 | 15.5439 | 4.63884 | 13.9788 | 0.207534 | 0.265864 | 0.00513557 | 0.00757523 | 1.73887 | 1.72555 | 250.434 | 0.0058402 | 0.032107 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0127108 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.89239 m2; Length Left: 5.62992 m; Length Right: 5.62992 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.853221 m2; Volume (Conditional): 0.0321069 m3
10 x CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 441.236 (kgCO₂) | 6671.71 | 0.0058402 | 5.835 | 0.0340776 | 0.16 | 0.27 | 9.61 | 5.50826 | 5.93485 | 0.0340776 | 6.20485 | 15.5448 | 0.27 | 9.61 | 0.255888 | 0.160001 | 0.0058402 | 0.00934019 | 0.00934019 | 5.50826 | 265.805 | 0.0058402 | 0.0340776 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0340776 m3; Core Width: 0.16 m; Surface Area of the Column Core (Gross, without Top/Bottom): 5.50826 m2; Surface Area of the Column Core Top (Gross): 0.00934019 m2; Surface Area of the Column Core Bottom (Gross): 0.0058402 m2; Volume of the Column Core (Gross): 0.0340776 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 5.93485 m; Minimum Height of the Column: 5.73515 m; Surface Area of the Column Core Bottom (Net): 0.0058402 m2; Surface Area of the Column Core (Net, without Top/Bottom): 5.50826 m2; Surface Area of the Column Core Top (Net): 0.00934019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00934019 m2
10 x CRE - 008 | 20.20.10.10 Pilars (GuBIMclass CA) | Si | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | CRE - 008 | 00_ACERO PILARES | Column | Paint - Anthracite | 90 | 20 | 335.926 (kgCO₂) | 5079.37 | 0.00584021 | 4.44235 | 0.0259443 | 0.160001 | 0.27 | 9.61 | 4.1936 | 4.50061 | 0.0259443 | 4.77061 | 14.1106 | 0.27 | 9.61 | 0.197934 | 0.160001 | 0.00584021 | 0.00722481 | 0.00722481 | 4.1936 | 202.365 | 0.00584021 | 0.0259443 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; ArchiCADQuantities - Core Height / Diameter: 0.160001 m; Volume of the Column Core (Net): 0.0259443 m3; Core Width: 0.160001 m; Surface Area of the Column Core (Gross, without Top/Bottom): 4.1936 m2; Surface Area of the Column Core Top (Gross): 0.00722481 m2; Surface Area of the Column Core Bottom (Gross): 0.00584021 m2; Volume of the Column Core (Gross): 0.0259443 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 4.50061 m; Minimum Height of the Column: 4.38409 m; Surface Area of the Column Core Bottom (Net): 0.00584021 m2; Surface Area of the Column Core (Net, without Top/Bottom): 4.1936 m2; Surface Area of the Column Core Top (Net): 0.00722481 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 1.5672 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.00722481 m2
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 230.51 (kgCO₂) | 3485.43 | 0.501594 | 0.160001 | 0.0178028 | 0.16 | 5.43422 | 14.7742 | 2.93944 | 3.26119 | 0.0180758 | 5.4755 | 14.8155 | 4.58191 | 13.9219 | 0.165191 | 0.332225 | 0.0121266 | 8.31516e-07 | 0.952938 | 0.965065 | 138.862 | 0.0058402 | 0.0178028 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; Colliding Zones: Nau Santa Eulàlia; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0121274 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.474912 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.492889 m2; Volume (Conditional): 0.0178028 m3
6 x Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 229.527 (kgCO₂) | 3470.56 | 0.499564 | 0.160001 | 0.0177268 | 0.16 | 5.53811 | 14.8781 | 2.93991 | 3.26119 | 0.0180758 | 5.57939 | 14.9194 | 4.6858 | 14.0258 | 0.165191 | 0.332225 | 0.0121266 | 0.00602964 | 0.948848 | 0.960975 | 138.269 | 0.0058402 | 0.0177268 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0181562 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.491187 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.47281 m2; Volume (Conditional): 0.0177268 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 416.509 (kgCO₂) | 6297.82 | 0.899528 | 0.160001 | 0.0321678 | 0.16 | 6.1 | 15.44 | 5.34324 | 5.81395 | 0.0329486 | 6.20389 | 15.5439 | 4.63592 | 13.9759 | 0.207534 | 0.265864 | 0.00513557 | 0.00518205 | 1.74172 | 1.72922 | 250.909 | 0.0058402 | 0.0321678 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0103176 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.893576 m2; Length Left: 5.6417 m; Length Right: 5.6417 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.855028 m2; Volume (Conditional): 0.0321678 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 416.421 (kgCO₂) | 6296.49 | 0.899695 | 0.160001 | 0.032161 | 0.16 | 6.1 | 15.44 | 5.34202 | 5.812 | 0.0329372 | 6.20389 | 15.5439 | 4.6364 | 13.9764 | 0.207534 | 0.265864 | 0.00513557 | 0.00576518 | 1.74159 | 1.72861 | 250.856 | 0.0058402 | 0.0321611 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0109008 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.893624 m2; Length Left: 5.63975 m; Length Right: 5.63975 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.854755 m2; Volume (Conditional): 0.032161 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 416.559 (kgCO₂) | 6298.57 | 0.899925 | 0.160001 | 0.0321716 | 0.16 | 6.1 | 15.44 | 5.34381 | 5.81401 | 0.032949 | 6.20389 | 15.5439 | 4.6359 | 13.9759 | 0.207534 | 0.265864 | 0.00513557 | 0.00566605 | 1.74214 | 1.72924 | 250.939 | 0.0058402 | 0.0321717 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0108016 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.893833 m2; Length Left: 5.64176 m; Length Right: 5.64176 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.855065 m2; Volume (Conditional): 0.0321716 m3
2 x Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 229.601 (kgCO₂) | 3471.67 | 0.499574 | 0.160001 | 0.0177325 | 0.16 | 5.53811 | 14.8781 | 2.93991 | 3.26119 | 0.0180758 | 5.57939 | 14.9194 | 4.6858 | 14.0258 | 0.165191 | 0.332225 | 0.0121266 | 0.00602964 | 0.948825 | 0.960953 | 138.314 | 0.0058402 | 0.0177325 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0181562 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.491187 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.47281 m2; Volume (Conditional): 0.0177325 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 416.732 (kgCO₂) | 6301.19 | 0.900252 | 0.160001 | 0.032185 | 0.16 | 6.1 | 15.44 | 5.34605 | 5.81651 | 0.0329636 | 6.20389 | 15.5439 | 4.63528 | 13.9753 | 0.207534 | 0.265864 | 0.00514163 | 0.00559784 | 1.74283 | 1.73002 | 251.043 | 0.0058402 | 0.032185 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0107395 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.894797 m2; Length Left: 5.64426 m; Length Right: 5.64426 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.854765 m2; Volume (Conditional): 0.032185 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 229.52 (kgCO₂) | 3470.45 | 0.499563 | 0.160001 | 0.0177263 | 0.16 | 5.53811 | 14.8781 | 2.93991 | 3.26119 | 0.0180758 | 5.57939 | 14.9194 | 4.6858 | 14.0258 | 0.165191 | 0.332225 | 0.0121266 | 0.00602964 | 0.948849 | 0.960976 | 138.265 | 0.0058402 | 0.0177263 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0181562 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.491187 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.47281 m2; Volume (Conditional): 0.0177263 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 416.788 (kgCO₂) | 6302.04 | 0.900488 | 0.160001 | 0.0321894 | 0.16 | 6.1 | 15.44 | 5.34682 | 5.81708 | 0.0329669 | 6.20389 | 15.5439 | 4.63514 | 13.9751 | 0.207534 | 0.265864 | 0.00513557 | 0.00578577 | 1.74318 | 1.7302 | 251.077 | 0.0058402 | 0.0321894 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0109213 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.894285 m2; Length Left: 5.64482 m; Length Right: 5.64482 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.85555 m2; Volume (Conditional): 0.0321894 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 417.395 (kgCO₂) | 6311.21 | 0.900665 | 0.160001 | 0.0322362 | 0.16 | 6.1 | 15.44 | 5.35568 | 5.8306 | 0.0330459 | 6.20389 | 15.5439 | 4.63177 | 13.9718 | 0.207534 | 0.265864 | 0.00513557 | 0.00213595 | 1.74436 | 1.73442 | 251.443 | 0.0058402 | 0.0322362 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.00727152 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.894704 m2; Length Left: 5.65835 m; Length Right: 5.65835 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.857556 m2; Volume (Conditional): 0.0322362 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 417.437 (kgCO₂) | 6311.85 | 0.900757 | 0.160001 | 0.0322395 | 0.16 | 6.1 | 15.44 | 5.35623 | 5.83117 | 0.0330492 | 6.20389 | 15.5439 | 4.63163 | 13.9716 | 0.207534 | 0.265864 | 0.00513898 | 0.00214675 | 1.74454 | 1.73459 | 251.468 | 0.0058402 | 0.0322395 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.00728574 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.894879 m2; Length Left: 5.65892 m; Length Right: 5.65892 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.857546 m2; Volume (Conditional): 0.0322395 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 229.523 (kgCO₂) | 3470.49 | 0.499564 | 0.160001 | 0.0177265 | 0.16 | 5.53811 | 14.8781 | 2.93991 | 3.26119 | 0.0180758 | 5.57939 | 14.9194 | 4.6858 | 14.0258 | 0.165191 | 0.332225 | 0.0121266 | 0.00602964 | 0.948849 | 0.960976 | 138.267 | 0.0058402 | 0.0177265 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0181562 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.491187 m2; Length Left: 3.09507 m; Length Right: 3.09507 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.47281 m2; Volume (Conditional): 0.0177265 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 416.943 (kgCO₂) | 6304.38 | 0.900985 | 0.160001 | 0.0322013 | 0.16 | 6.1 | 15.44 | 5.3488 | 5.81894 | 0.0329779 | 6.20389 | 15.5439 | 4.63467 | 13.9747 | 0.207534 | 0.265864 | 0.00514107 | 0.00609251 | 1.74397 | 1.73078 | 251.171 | 0.0058402 | 0.0322013 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0112336 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.892261 m2; Length Left: 5.64671 m; Length Right: 5.64671 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.858229 m2; Volume (Conditional): 0.0322013 m3
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | No | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Cu1 | 00_ACERO VIGAS | Beam | Paint - Anthracite; Paint - Light Gray | -14.4 | 30 | 416.76 (kgCO₂) | 6301.62 | 0.900028 | 0.160001 | 0.0321872 | 0.16 | 6.1 | 15.44 | 5.34648 | 5.8175 | 0.0329695 | 6.20389 | 15.5439 | 4.63503 | 13.975 | 0.207534 | 0.265864 | 0.00514107 | 0.00512869 | 1.74277 | 1.73034 | 251.06 | 0.0058402 | 0.0321872 | ArchiCADProperties - Beam Cross Section: Profiled; Beam Slant Angle: -14.4 deg; Number of Openings: 0; 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; GENERAL PROPERTIES - AUX_107.NomTipus: BMR - 004; ArchiCADQuantities - Surface Area of Both Beam Ends: 0.0102698 m2; Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0.891609 m2; Length Left: 5.64527 m; Length Right: 5.64527 m; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0.857954 m2; Volume (Conditional): 0.0321872 m3

# IfcBuildingElementProxy: Stone - Structural, Object_3347
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Cast Shadow: yes; Receive Shadow: yes; Surface: Brick - Aged Natural; Element ID: Object_3347; Hotlink and Element ID: Object_3347; Layer: 00_ORNAMENTOS PLANTA; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Espai públic; Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Morph; Parent ID: Object_3347; Building Materials (All): Stone - Structural; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3347_; 109.AMB.CodiTipus: Object_3347; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Stone - Structural, Embodied Carbon: 170.927 (kgCO₂); Stone - Structural, Embodied Energy: 2848.78 MJ
ArchiCADQuantities - Area: 0.267141 m2; Volume (Net): 0.863268 m3; Elevation to Project Zero: 1.09731 m; Elevation to 1st Reference Level: 1.09731 m; Elevation to 2nd Reference Level: 1.09731 m; Elevation to Sea Level: 10.4373 m; Elevation to Linked/Home Story: 1.09731 m; Home Offset: 1.09731 m; Surface Area: 8.00614 m2; Floor Plan Perimeter: 2.06882 m; Top Elevation To First Reference Level: 4.98411 m; Top Elevation To Home Story: 4.98411 m; Top Elevation To Project Zero: 4.98411 m; Top Elevation To Sea Level: 14.3241 m; Top Elevation To Second Reference Level: 4.98411 m; Bottom Elevation To First Reference Level: 1.09731 m; Bottom Elevation To Home Story: 1.09731 m; Bottom Elevation To Project Zero: 1.09731 m; Bottom Elevation To Sea Level: 10.4373 m; Bottom Elevation To Second Reference Level: 1.09731 m; Top Surface Area (Net): 0.267141 m2; Bottom Surface Area (Net): 8.00614 m2
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Mass: 1899.19 kg; Stone - Structural, Component Volume (Net): 0.863268 m3; Stone - Structural, Component Volume (Gross): 0.863268 m3

# IfcBuildingElementProxy: Stone - Structural 150, SW - 052
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Paint - Anthracite; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: SW - 052; Hotlink and Element ID: SW - 052; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: SW - 052; Building Materials (All): Stone - Structural; Surfaces (All): Paint - Anthracite; Brick - Aged Natural; Stone - Wall; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SW - 052_; 109.AMB.CodiTipus: SW - 052; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Stone - Structural, Embodied Carbon: 1582.36 (kgCO₂); Stone - Structural, Embodied Energy: 26372.6 MJ
ArchiCADQuantities - Number of Doors: 1; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 2; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 8.40829 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 4.47208 m2; Combined Width of Doors: 1.72003 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 4.47208 m2; Analytic Surface Area of Openings on the Outside Face: 4.47208 m2; Average length of the Wall: 8.05901 m; Surface Area of the Wall Inside Face (Net): 55.6285 m2; Surface Area of the Wall Outside Face (Net): 53.2585 m2; Analytic Volume of the Openings: 0.670812 m3; Length of Reference Line: 8.6087 m; Length of the Wall Inside Face (Conditional): 6.33929 m; Surface Area of the Wall Inside Face (Conditional): 55.6285 m2; Length of the Wall Outside Face (Conditional): 6.33867 m; Surface Area of the Wall Outside Face (Conditional): 53.2585 m2; Surface Area of the Wall Inside Face (Gross): 60.7749 m2; Surface Area of the Wall Outside Face (Gross): 60.7715 m2; End Thickness of the Wall: 0.15 m; Length of the Wall at the Center: 8.05901 m; Length of the Wall on the Inside Face: 8.05932 m; Length of the Wall on the Outside Face: 8.0587 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 1.0333 m2; Height: 8.73211 m; Volume (Net): 7.9917 m3; Width: 0.15 m; Elevation to Project Zero: 1.71425 m; Elevation to 1st Reference Level: 1.71425 m; Elevation to 2nd Reference Level: 1.71425 m; Elevation to Sea Level: 11.0543 m; Elevation to Linked/Home Story: 1.71425 m; Home Offset: 1.71425 m; Top Offset: 0 m; Surface Area: 53.2585 m2; 3D Length: 8.60932 m; Thickness: 0.15 m; Volume (Conditional): 8.66252 m3; Volume (Gross): 9.11598 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 16.418 m; Top Elevation To First Reference Level: 10.1225 m; Top Elevation To Home Story: 10.1225 m; Top Elevation To Project Zero: 10.1225 m; Top Elevation To Sea Level: 19.4625 m; Top Elevation To Second Reference Level: 10.1225 m; Bottom Elevation To First Reference Level: 1.71425 m; Bottom Elevation To Home Story: 1.71425 m; Bottom Elevation To Project Zero: 1.71425 m; Bottom Elevation To Sea Level: 11.0543 m; Bottom Elevation To Second Reference Level: 1.71425 m; Top Surface Area (Net): 1.0333 m2; Edge Surface Area (Net): 3.56591 m2; Bottom Surface Area (Net): 53.2585 m2
5 AMB.Geometria - 501.AMB.Longitud: 8.6087 m; 502.AMB.Amplada: 0.15 m; 503.AMB.Altura: 8.73211 m; 504.AMB.Gruix: 0.15 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Mass: 17581.8 kg; Stone - Structural, Projected Component Area (Net): 55.6284 m2; Stone - Structural, Projected Component Area (Gross): 60.1005 m2; Stone - Structural, Component Thickness: 0.15 m; Stone - Structural, Rectangular Component Height: 8.73211 m; Stone - Structural, Rectangular Component Width: 0.15 m; Stone - Structural, Component Cross Section Area: 1.30982 m2; Stone - Structural, Component Volume (Net): 7.9917 m3; Stone - Structural, Component Volume (Gross): 8.66252 m3
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Stone - Structural 250, SLA - 010
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Reference Plane Location: Top; Element ID: SLA - 010; Hotlink and Element ID: SLA - 010; Layer: 00_PELDAÑOS; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Basic; Parent ID: SLA - 010; Building Materials (All): Stone - Structural; Surfaces (All): Stone - Rock; Cover Fill: Carpet; Number of Openings: 0; Top Surface: Stone - Rock; Edge Surface: Stone - Rock; Bottom Surface: Stone - Rock; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SLA - 010_; 109.AMB.CodiTipus: SLA - 010; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Stone - Structural, Embodied Carbon: 70.2311 (kgCO₂); Stone - Structural, Embodied Energy: 1170.52 MJ
ArchiCADQuantities - Elevation Bottom: 0.02 m; Surface Area of the Slab Top (Conditional): 1.41881 m2; Surface Area of the Slab Bottom (Gross): 1.41881 m2; Surface Area of the Slab Bottom (Gross, with holes): 1.41881 m2; Surface Area of the Slab Edges (Gross): 1.41526 m2; Surface Area of the Slab Edges (Gross, with holes): 1.41526 m2; Surface Area of the Slab Top (Gross): 1.41881 m2; Surface Area of the Slab Top (Gross, with holes): 1.41881 m2; Holes Surface Area: 0 m2; Elevation Top: 0.27 m; Area: 1.41881 m2; Height: 0.25 m; Volume (Net): 0.354703 m3; Elevation to Project Zero: 0.27 m; Elevation to 1st Reference Level: 0.27 m; Elevation to 2nd Reference Level: 0.27 m; Elevation to Sea Level: 9.61 m; Elevation to Linked/Home Story: 0.27 m; Home Offset: 0.27 m; Surface Area: 1.41881 m2; Thickness: 0.25 m; Volume (Conditional): 0.354703 m3; Volume (Gross): 0.354703 m3; Floor Plan Perimeter: 5.66104 m; Floor Plan Holes Perimeter: 0 m; Top Elevation To First Reference Level: 0.27 m; Top Elevation To Home Story: 0.27 m; Top Elevation To Project Zero: 0.27 m; Top Elevation To Sea Level: 9.61 m; Top Elevation To Second Reference Level: 0.27 m; Bottom Elevation To First Reference Level: 0.02 m; Bottom Elevation To Home Story: 0.02 m; Bottom Elevation To Project Zero: 0.02 m; Bottom Elevation To Sea Level: 9.36 m; Bottom Elevation To Second Reference Level: 0.02 m; Top Surface Area (Net): 1.41881 m2; Top Surface Area (Conditional): 1.41881 m2; Edge Surface Area (Net): 1.41526 m2; Bottom Surface Area (Net): 1.41881 m2; Bottom Surface Area (Conditional): 1.41881 m2; Bottom Surface Area (Gross): 1.41881 m2; Edge Surface Area (Gross): 1.41526 m2; Top Surface Area (Gross): 1.41881 m2
5 AMB.Geometria - 503.AMB.Altura: 0.25 m; 504.AMB.Gruix: 0.25 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Mass: 780.346 kg; Stone - Structural, Projected Component Area (Net): 1.41881 m2; Stone - Structural, Projected Component Area (Gross): 1.41881 m2; Stone - Structural, Component Thickness: 0.25 m; Stone - Structural, Component Volume (Net): 0.354703 m3; Stone - Structural, Component Volume (Gross): 0.354703 m3

# IfcBuildingElementProxy: Stone - Structural 300 x 150 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
Component Quantities - Stone - Structural, Component Thickness: 0.3 m; Stone - Structural, Rectangular Component Height: 0.15 m; Stone - Structural, Rectangular Component Width: 0.3 m; Stone - Structural, Component Cross Section Area: 0.045 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.3 m; 503.AMB.Altura: 8.00974 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Core Height / Diameter: 0.15 m; Core Width: 0.3 m; Surface Area of the Column Core Top (Gross): 0 m2; Surface Area of the Column Core Bottom (Gross): 0.045 m2; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Minimum Height of the Column: 0 m; Surface Area of the Column Core Bottom (Net): 0.045 m2; Surface Area of the Column Core Top (Net): 0 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 0.9 m; Volume of the Column Veneer (Net): 0 m3; Area: 0.045 m2; Height: 8.00974 m; Width: 0.3 m; Elevation to Project Zero: 1.71425 m; Elevation to 1st Reference Level: 1.71425 m; Elevation to 2nd Reference Level: 1.71425 m; Elevation to Sea Level: 11.0543 m; Elevation to Linked/Home Story: 1.71425 m; Home Offset: 1.71425 m; Top Offset: 1.44108 m; Bottom Elevation To First Reference Level: 1.71425 m; Bottom Elevation To Home Story: 1.71425 m; Bottom Elevation To Project Zero: 1.71425 m; Bottom Elevation To Sea Level: 11.0543 m; Bottom Elevation To Second Reference Level: 1.71425 m; Cross Section Height at Top/End (perpendicular): 0.15 m; Cross Section Height at Bottom/Start (perpendicular): 0.15 m; Cross Section Width at Top/End (perpendicular): 0.3 m; Cross Section Width at Bottom/Start (perpendicular): 0.3 m; Cross Section Height at Top/End (cut): 0.15 m; Cross Section Height at Bottom/Start (cut): 0.15 m; Cross Section Width at Top/End (cut): 0.3 m; Cross Section Width at Bottom/Start (cut): 0.3 m; Cross Section Area at Bottom/Start: 0.045 m2; Cross Section Area at Top/End: 0 m2; Number of Segments: 1; Top Surface Area (Net): 0 m2; Top Surface Area (Gross): 0 m2
Component Properties - Stone - Structural, Component Type: Core
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: CRE - 012_; 109.AMB.CodiTipus: CRE - 012; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Column Cross Section: Rectangular; Column Slant Angle: 90 deg; Extrusion Surface: Brick - Aged Natural; End Surface: Brick - Aged Natural; Element ID: CRE - 012; Hotlink and Element ID: CRE - 012; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Column; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: CRE - 012; Building Materials (All): Stone - Structural; Surfaces (All): Brick - Aged Natural; Cover Fill: Background; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Name | Stone - Structural, Mass (kg) | Stone - Structural, Component Volume (Net) (m3) = Stone - Structural, Component Volume (Gross) (m3) = Volume of the Column Core (Net) (m3) = Volume of the Column Core (Gross) (m3) = Volume (Net) (m3) = Volume (Gross) (m3) | Surface Area of the Column Core (Gross, without Top/Bottom) (m2) = Surface Area of the Column Core (Net, without Top/Bottom) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Maximum Height of the Column (m) = 3D Length (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Stone - Structural, Embodied Carbon | Stone - Structural, Embodied Energy (MJ)
CRE - 012 | 676.162 | 0.307347 | 6.14693 | 6.87716 | 8.59141 | 17.9314 | 60.8546 (kgCO₂) | 1014.24
CRE - 012 | 746.675 | 0.339398 | 6.78795 | 7.58941 | 9.30366 | 18.6437 | 67.2007 (kgCO₂) | 1120.01

# IfcBuildingElementProxy: Stone - Structural 307, SLA - 010
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Reference Plane Location: Top; Element ID: SLA - 010; Hotlink and Element ID: SLA - 010; Layer: 00_PELDAÑOS; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Basic; Parent ID: SLA - 010; Building Materials (All): Stone - Structural; Surfaces (All): Stone - Rock; Cover Fill: Carpet; Number of Openings: 0; Top Surface: Stone - Rock; Edge Surface: Stone - Rock; Bottom Surface: Stone - Rock; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SLA - 010_; 109.AMB.CodiTipus: SLA - 010; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Stone - Structural, Embodied Carbon: 66.8719 (kgCO₂); Stone - Structural, Embodied Energy: 1114.53 MJ
5 AMB.Geometria - 503.AMB.Altura: 0.307463 m; 504.AMB.Gruix: 0.307463 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Mass: 743.021 kg; Stone - Structural, Projected Component Area (Net): 1.09846 m2; Stone - Structural, Projected Component Area (Gross): 1.09846 m2; Stone - Structural, Component Thickness: 0.307463 m; Stone - Structural, Component Volume (Net): 0.337737 m3; Stone - Structural, Component Volume (Gross): 0.337737 m3
ArchiCADQuantities - Elevation Bottom: 0.0988536 m; Surface Area of the Slab Top (Conditional): 1.09846 m2; Surface Area of the Slab Bottom (Gross): 1.09846 m2; Surface Area of the Slab Bottom (Gross, with holes): 1.09846 m2; Surface Area of the Slab Edges (Gross): 1.34082 m2; Surface Area of the Slab Edges (Gross, with holes): 1.34082 m2; Surface Area of the Slab Top (Gross): 1.09846 m2; Surface Area of the Slab Top (Gross, with holes): 1.09846 m2; Holes Surface Area: 0 m2; Elevation Top: 0.406317 m; Area: 1.09846 m2; Height: 0.307463 m; Volume (Net): 0.337737 m3; Elevation to Project Zero: 0.406317 m; Elevation to 1st Reference Level: 0.406317 m; Elevation to 2nd Reference Level: 0.406317 m; Elevation to Sea Level: 9.74632 m; Elevation to Linked/Home Story: 0.406317 m; Home Offset: 0.406317 m; Surface Area: 1.09846 m2; Thickness: 0.307463 m; Volume (Conditional): 0.337737 m3; Volume (Gross): 0.337737 m3; Floor Plan Perimeter: 4.36092 m; Floor Plan Holes Perimeter: 0 m; Top Elevation To First Reference Level: 0.406317 m; Top Elevation To Home Story: 0.406317 m; Top Elevation To Project Zero: 0.406317 m; Top Elevation To Sea Level: 9.74632 m; Top Elevation To Second Reference Level: 0.406317 m; Bottom Elevation To First Reference Level: 0.0988536 m; Bottom Elevation To Home Story: 0.0988536 m; Bottom Elevation To Project Zero: 0.0988536 m; Bottom Elevation To Sea Level: 9.43885 m; Bottom Elevation To Second Reference Level: 0.0988536 m; Top Surface Area (Net): 1.09846 m2; Top Surface Area (Conditional): 1.09846 m2; Edge Surface Area (Net): 1.34082 m2; Bottom Surface Area (Net): 1.09846 m2; Bottom Surface Area (Conditional): 1.09846 m2; Bottom Surface Area (Gross): 1.09846 m2; Edge Surface Area (Gross): 1.34082 m2; Top Surface Area (Gross): 1.09846 m2

# IfcBuildingElementProxy: Stone - Structural 320, F8
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: F8_Mur_220_Mao; 109.AMB.CodiTipus: F8; 111.AMB.DescripcioTipus: Ampit de maó massís manual armat amb morter de calç 3,5 HL; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Brick - Aged Natural; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F8; Hotlink and Element ID: F8; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F8; Building Materials (All): Stone - Structural; Surfaces (All): Brick - Aged Natural; Stone - Wall; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00; AUX_107.NomTipus: Mur_220_Mao
Component Properties - Stone - Structural, Embodied Carbon: 8031.93 (kgCO₂); Stone - Structural, Embodied Energy: 133865 MJ
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 501.AMB.Longitud: 12.9997 m; 502.AMB.Amplada: 0.32 m; 503.AMB.Altura: 10.0611 m; 504.AMB.Gruix: 0.32 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 10.0611 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Average length of the Wall: 12.7997 m; Surface Area of the Wall Inside Face (Net): 126.767 m2; Surface Area of the Wall Outside Face (Net): 126.767 m2; Analytic Volume of the Openings: -4.26326e-14 m3; Length of Reference Line: 12.9997 m; Length of the Wall Inside Face (Conditional): 12.9997 m; Surface Area of the Wall Inside Face (Conditional): 126.767 m2; Length of the Wall Outside Face (Conditional): 12.5997 m; Surface Area of the Wall Outside Face (Conditional): 126.767 m2; Surface Area of the Wall Inside Face (Gross): 130.791 m2; Surface Area of the Wall Outside Face (Gross): 130.791 m2; End Thickness of the Wall: 0.32 m; Length of the Wall at the Center: 12.7997 m; Length of the Wall on the Inside Face: 12.9997 m; Length of the Wall on the Outside Face: 12.5997 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 4.03189 m2; Height: 10.0611 m; Volume (Net): 40.5653 m3; Width: 0.32 m; Elevation to Project Zero: -0.275747 m; Elevation to 1st Reference Level: -0.275747 m; Elevation to 2nd Reference Level: -0.275747 m; Elevation to Sea Level: 9.06425 m; Elevation to Linked/Home Story: -0.275747 m; Home Offset: -0.275747 m; Top Offset: 0 m; Surface Area: 126.767 m2; 3D Length: 12.5997 m; Thickness: 0.32 m; Volume (Conditional): 40.5653 m3; Volume (Gross): 41.8531 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 26.4316 m; Top Elevation To First Reference Level: 9.78536 m; Top Elevation To Home Story: 9.78536 m; Top Elevation To Project Zero: 9.78536 m; Top Elevation To Sea Level: 19.1254 m; Top Elevation To Second Reference Level: 9.78536 m; Bottom Elevation To First Reference Level: -0.275747 m; Bottom Elevation To Home Story: -0.275747 m; Bottom Elevation To Project Zero: -0.275747 m; Bottom Elevation To Sea Level: 9.06425 m; Bottom Elevation To Second Reference Level: -0.275747 m; Top Surface Area (Net): 4.03189 m2; Edge Surface Area (Net): 11.2833 m2; Bottom Surface Area (Net): 126.767 m2
Component Quantities - Stone - Structural, Mass: 89243.7 kg; Stone - Structural, Projected Component Area (Net): 126.767 m2; Stone - Structural, Projected Component Area (Gross): 126.767 m2; Stone - Structural, Component Thickness: 0.32 m; Stone - Structural, Rectangular Component Height: 10.0611 m; Stone - Structural, Rectangular Component Width: 0.32 m; Stone - Structural, Component Cross Section Area: 3.21956 m2; Stone - Structural, Component Volume (Net): 40.5653 m3; Stone - Structural, Component Volume (Gross): 40.5653 m3

# IfcBuildingElementProxy: Stone - Structural 400, F5
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Concrete - Bush hammered; Outside Face Surface: Paint - Stucco Yellow; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F5; Hotlink and Element ID: F5; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Espai públic; Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F5; Building Materials (All): Stone - Structural; Surfaces (All): Paint - Stucco Yellow; Concrete - Bush hammered; Stone - Wall; Slant Angle: 90 deg; ID of Connected Openings: OP - 003; OP - 004; OP - 003; OP - 003; OP - 003; OP - 003; Number of Openings: 6; Edge Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
