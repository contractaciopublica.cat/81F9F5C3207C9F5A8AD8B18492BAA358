Properties of the parts of a building model (IFC2X3), part 27 of 99

# IfcBuildingElementProxy: Rhino_Object_1163, Object_1163
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1163_; 109.AMB.CodiTipus: Object_1163; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.139899 m; Area: 0.010656 m2; Height: 2.14163 m; Volume (Net): 0 m3; Width: 0.0761688 m; Elevation to Project Zero: 1.51399 m; Elevation to 1st Reference Level: 1.51399 m; Elevation to 2nd Reference Level: 1.51399 m; Elevation to Sea Level: 10.854 m; Elevation to Linked/Home Story: 1.51399 m; Home Offset: 1.51399 m; Surface Area: 0.782401 m2; Top Elevation To First Reference Level: 3.65562 m; Top Elevation To Home Story: 3.65562 m; Top Elevation To Project Zero: 3.65562 m; Top Elevation To Sea Level: 12.9956 m; Top Elevation To Second Reference Level: 3.65562 m; Bottom Elevation To First Reference Level: 1.51399 m; Bottom Elevation To Home Story: 1.51399 m; Bottom Elevation To Project Zero: 1.51399 m; Bottom Elevation To Sea Level: 10.854 m; Bottom Elevation To Second Reference Level: 1.51399 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.854 m; Top Surface Area (Net): 0.010656 m2; Bottom Surface Area (Net): 0.782401 m2
AC_Equantity_Rhino_Object_1163 - Dimension 1: 0.139899 m; Dimension 2: 0.0761688 m; Height: 2.14163 m; Bottom Level: -2.22045e-16 m; Top Level: 2.14163 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0761688 m; 503.AMB.Altura: 2.14163 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1164, Object_1164
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1164; Hotlink and Element ID: Object_1164; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1164; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1164; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1164 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1164_; 109.AMB.CodiTipus: Object_1164; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.00393677 m; Area: 0.000255659 m2; Height: 0.997971 m; Volume (Net): 0 m3; Width: 0.0649414 m; Elevation to Project Zero: 1.51399 m; Elevation to 1st Reference Level: 1.51399 m; Elevation to 2nd Reference Level: 1.51399 m; Elevation to Sea Level: 10.854 m; Elevation to Linked/Home Story: 1.51399 m; Home Offset: 1.51399 m; Surface Area: 0.0648681 m2; Top Elevation To First Reference Level: 2.51196 m; Top Elevation To Home Story: 2.51196 m; Top Elevation To Project Zero: 2.51196 m; Top Elevation To Sea Level: 11.852 m; Top Elevation To Second Reference Level: 2.51196 m; Bottom Elevation To First Reference Level: 1.51399 m; Bottom Elevation To Home Story: 1.51399 m; Bottom Elevation To Project Zero: 1.51399 m; Bottom Elevation To Sea Level: 10.854 m; Bottom Elevation To Second Reference Level: 1.51399 m; Survey Coordinate X: 426587 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.854 m; Top Surface Area (Net): 0.000255659 m2; Bottom Surface Area (Net): 0.0648681 m2
AC_Equantity_Rhino_Object_1164 - Dimension 1: 0.00393677 m; Dimension 2: 0.0649414 m; Height: 0.997971 m; Bottom Level: -2.22045e-16 m; Top Level: 0.997971 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0649414 m; 503.AMB.Altura: 0.997971 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1165, Object_1165
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5804 deg; Surface: Brick - Aged Natural; Element ID: Object_1165; Hotlink and Element ID: Object_1165; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_1165; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1165; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1165 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1165_; 109.AMB.CodiTipus: Object_1165; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1165 - Dimension 1: 0.13968 m; Dimension 2: 0.0732422 m; Height: 2.14163 m; Bottom Level: -2.22045e-16 m; Top Level: 2.14163 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0732422 m; 503.AMB.Altura: 2.14163 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3
ArchiCADQuantities - Length (A): 0.13968 m; Area: 0.0102305 m2; Height: 2.14163 m; Volume (Net): 0 m3; Width: 0.0732422 m; Elevation to Project Zero: 1.51399 m; Elevation to 1st Reference Level: 1.51399 m; Elevation to 2nd Reference Level: 1.51399 m; Elevation to Sea Level: 10.854 m; Elevation to Linked/Home Story: 1.51399 m; Home Offset: 1.51399 m; Surface Area: 0.782401 m2; Top Elevation To First Reference Level: 3.65562 m; Top Elevation To Home Story: 3.65562 m; Top Elevation To Project Zero: 3.65562 m; Top Elevation To Sea Level: 12.9956 m; Top Elevation To Second Reference Level: 3.65562 m; Bottom Elevation To First Reference Level: 1.51399 m; Bottom Elevation To Home Story: 1.51399 m; Bottom Elevation To Project Zero: 1.51399 m; Bottom Elevation To Sea Level: 10.854 m; Bottom Elevation To Second Reference Level: 1.51399 m; Survey Coordinate X: 426587 m; Survey Coordinate Y: 4579793 m; Survey Coordinate Z: 10.854 m; Top Surface Area (Net): 0.0102305 m2; Bottom Surface Area (Net): 0.782401 m2

# IfcBuildingElementProxy: Rhino_Object_1166, Object_1166
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1166; Hotlink and Element ID: Object_1166; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1166; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1166; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1166 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1166_; 109.AMB.CodiTipus: Object_1166; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1166 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426572 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2

# IfcBuildingElementProxy: Rhino_Object_1167, Object_1167
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1167; Hotlink and Element ID: Object_1167; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1167; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1167; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1167 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1167_; 109.AMB.CodiTipus: Object_1167; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1167 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426572 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2

# IfcBuildingElementProxy: Rhino_Object_1168, Object_1168
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1168; Hotlink and Element ID: Object_1168; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1168; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1168; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1168_; 109.AMB.CodiTipus: Object_1168; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Pset_Rhino_Object_1168 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1168 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1169, Object_1169
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1169 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1169; Hotlink and Element ID: Object_1169; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1169; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1169; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1169_; 109.AMB.CodiTipus: Object_1169; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1169 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_117, Object_117
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_117 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_117_; 109.AMB.CodiTipus: Object_117; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_117; Hotlink and Element ID: Object_117; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_117; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_117; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
AC_Equantity_Rhino_Object_117 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m

# IfcBuildingElementProxy: Rhino_Object_1170, Object_1170
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1170; Hotlink and Element ID: Object_1170; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1170; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1170; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1170 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1170 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1170_; 109.AMB.CodiTipus: Object_1170; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1171, Object_1171
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1171; Hotlink and Element ID: Object_1171; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1171; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1171; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1171 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1171_; 109.AMB.CodiTipus: Object_1171; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1171 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_1172, Object_1172
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1172; Hotlink and Element ID: Object_1172; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1172; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1172; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1172 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1172_; 109.AMB.CodiTipus: Object_1172; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1172 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1173, Object_1173
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1173; Hotlink and Element ID: Object_1173; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1173; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1173; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1173 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1173_; 109.AMB.CodiTipus: Object_1173; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1173 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1174, Object_1174
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1174; Hotlink and Element ID: Object_1174; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1174; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1174; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1174 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1174_; 109.AMB.CodiTipus: Object_1174; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1174 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1175, Object_1175
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1175; Hotlink and Element ID: Object_1175; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1175; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1175; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1175 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1175_; 109.AMB.CodiTipus: Object_1175; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1175 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3

# IfcBuildingElementProxy: Rhino_Object_1176, Object_1176
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1176; Hotlink and Element ID: Object_1176; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1176; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1176; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1176 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1176_; 109.AMB.CodiTipus: Object_1176; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.22817 m; Elevation to 1st Reference Level: 1.22817 m; Elevation to 2nd Reference Level: 1.22817 m; Elevation to Sea Level: 10.5682 m; Elevation to Linked/Home Story: 1.22817 m; Home Offset: 1.22817 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.34817 m; Top Elevation To Home Story: 1.34817 m; Top Elevation To Project Zero: 1.34817 m; Top Elevation To Sea Level: 10.6882 m; Top Elevation To Second Reference Level: 1.34817 m; Bottom Elevation To First Reference Level: 1.22817 m; Bottom Elevation To Home Story: 1.22817 m; Bottom Elevation To Project Zero: 1.22817 m; Bottom Elevation To Sea Level: 10.5682 m; Bottom Elevation To Second Reference Level: 1.22817 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 10.5682 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_1176 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1177, Object_1177
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_1177; Hotlink and Element ID: Object_1177; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1177; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1177; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1177_; 109.AMB.CodiTipus: Object_1177; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_1177 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
