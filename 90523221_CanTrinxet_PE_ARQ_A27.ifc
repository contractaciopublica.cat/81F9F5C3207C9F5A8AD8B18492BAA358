Properties of the parts of a building model (IFC2X3), part 98 of 99

# IfcOpeningElement (289)
Name | Depth (m) | BaseQuantities, Height (m) | BaseQuantities, Width (m) | BaseQuantities, Area (m2) | Volume (m3) | Classification | Shape | Orientation | Limits | Cut Symbol Name | Uncut Symbol Name | IDs of Cut Elements | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Layer | Colliding Zones | Locked | Home Story Name = 115.AMB.Nivell | Home Story Number = Slant Angle (deg) = 506.AMB.Profunditat (m) = Opening End Surface Area (Net, total) (m2) | Element Type | Parent ID | Surfaces (All) | Design Option Name = Design Option Set Name = Design Option Status = Design Option Set | Position | Renovation Status | Show On Renovation Filter | 001.AMB.ExpedientNumero | 003.AMB.NomProjecte | 004.AMB.FaseProjecte | 007.AMB.ModelDisciplina | 008.AMB.Adreca | 009.AMB.Municipi | 010.AMB.AutorProjecte | 011.AMB.AutorProjecte2 | 012.AMB.AutorProjecte3 | 107.AMB.NomTipus | 117.AMB.Localitzacio | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | Status | 502.AMB.Amplada (m) = ArchiCADQuantities, Width (m) | 503.AMB.Altura (m) = ArchiCADQuantities, Height (m) | Sill Height to Home Story (m) = Sill Height to Project Zero (m) | Header Height to Home Story (m) = Header Height to Project Zero (m) | Total Thickness (m) | Number of Cut Elements | Center Height to Home Story (m) = Center Height to Project Zero (m) | Sill Height to Wall Bottom (m) | Sill Height to Wall Top (m) | Center Height to Wall Bottom (m) | Center Height to Wall Top (m) | Header Height to Wall Bottom (m) | Header Height to Wall Top (m) | Opening Extrusion Surface Area (Net) (m2) = Surface Area (m2) = Edge Surface Area (Net) (m2) = Bottom Surface Area (Net) (m2) | ArchiCADQuantities, Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) | Elevation to Sea Level (m) | Home Offset (m) | 3D Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m)
OP - 004 | 0.03 | 1.83457 | 0.452759 | 0.830617 | 0.0187256 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.452759 | 1.83457 | 1.49137 | 3.32594 | 0.03 | 1 | 2.40866 | 1.22137 | -1.37863 | 2.13866 | -0.461344 | 3.05594 | 0.45594 | 0.0549416 | 0.830617 | 0.0187256 | 3.32594 | 12.6659 | 1.49137 | 4.57465 | 2.87 | 12.21 | 1.49137 | 10.8314
PI012 | 0.16 | 3.46 | 2.12257 | 4.94986 | 0.0922897
T2 | 0.08 | 2.6 | 0.877 | 2.2802 | 0.074197
2 x T2 | 0.08 | 2.6 | 0.874068 | 2.27258 | 0.0740182
PI004 | 0.08 | 2.6 | 0.879423 | 2.2865 | 0.0382189
PI006 | 0.08 | 2.6 | 0.8 | 2.08 | 0.0606751
PI005 | 0.08 | 2.6 | 0.8 | 2.08 | 0.0606751
OP - 006 | 0.03 | 0.874 | 0.301704 | 0.263689 | 0.000886624 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 006 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ | Nau Santa Eulalia | Obra | NEW | 0.301704 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | 2.13347 | -0.466535 | 2.57047 | -0.0295345 | 3.00747 | 0.407466 | 0.0158965 | 0.263689 | 0.000886624 | 3.27747 | 12.6175 | 2.40347 | 2.35141 | 2.87 | 12.21 | 2.40347 | 11.7435
OP - 005 | 0.03 | 0.874 | 0.301704 | 0.263689 | 0.00331094 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 005 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.301704 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | 2.13347 | -0.466535 | 2.57047 | -0.0295345 | 3.00747 | 0.407466 | 0.0210929 | 0.263689 | 0.00331094 | 3.27747 | 12.6175 | 2.40347 | 2.35141 | 2.87 | 12.21 | 2.40347 | 11.7435
OP - 004 | 0.03 | 1.54246 | 0.547999 | 0.845268 | 0.0187668 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.54246 | 1.72847 | 3.27093 | 0.03 | 1 | 2.4997 | 1.45847 | -1.14153 | 2.2297 | -0.370303 | 3.00093 | 0.400928 | 0.084932 | 0.845268 | 0.0187668 | 3.27093 | 12.6109 | 1.72847 | 4.18092 | 2.87 | 12.21 | 1.72847 | 11.0685
OP - 004 | 0.03 | 0.874 | 0.316127 | 0.276295 | 0.00384535 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.316127 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | -0.468535 | -1.91546 | -0.0315345 | -1.47846 | 0.405466 | -1.04146 | 0.0216478 | 0.276295 | 0.00384535 | 3.27747 | 12.6175 | 2.40347 | 2.38025 | 3.27747 | 12.6175 | 2.872 | 12.212
OP - 004 | 0.03 | 0.874 | 0.301704 | 0.263689 | 0.00287754 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.301704 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | -0.468535 | -1.91546 | -0.0315345 | -1.47846 | 0.405466 | -1.04146 | 0.0192608 | 0.263689 | 0.00287754 | 3.27747 | 12.6175 | 2.40347 | 2.35141 | 3.27747 | 12.6175 | 2.872 | 12.212
OP - 004 | 0.03 | 1.47667 | 0.547999 | 0.809213 | 0.00666585 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.47667 | 1.8008 | 3.27747 | 0.03 | 1 | 2.53913 | -1.0712 | -2.51813 | -0.332869 | -1.7798 | 0.405466 | -1.04146 | 0.0407679 | 0.809213 | 0.00666585 | 3.27747 | 12.6175 | 1.8008 | 4.04934 | 3.27747 | 12.6175 | 2.872 | 12.212
OP - 004 | 0.03 | 0.874 | 0.301704 | 0.263689 | 0.000770566 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.301704 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | -0.468535 | -1.91546 | -0.0315345 | -1.47846 | 0.405466 | -1.04146 | 0.0140644 | 0.263689 | 0.000770566 | 3.27747 | 12.6175 | 2.40347 | 2.35141 | 3.27747 | 12.6175 | 2.872 | 12.212
OP - 004 | 0.03 | 1.54246 | 0.547999 | 0.845268 | 0.00655836 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.54246 | 1.72847 | 3.27093 | 0.03 | 1 | 2.4997 | -1.14353 | -2.59046 | -0.372303 | -1.81923 | 0.398928 | -1.048 | 0.0403756 | 0.845268 | 0.00655836 | 3.27093 | 12.6109 | 1.72847 | 4.18092 | 3.27093 | 12.6109 | 2.872 | 12.212
OP - 004 | 0.03 | 1.83374 | 0.316127 | 0.579695 | 0.00442452 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.316127 | 1.83374 | 2.40347 | 4.23721 | 0.03 | 1 | 3.32034 | 2.13347 | -0.466535 | 3.05034 | 0.450337 | 3.96721 | 1.36721 | 0.0234798 | 0.579695 | 0.00442452 | 4.23721 | 13.5772 | 2.40347 | 4.29974 | 2.87 | 12.21 | 2.40347 | 11.7435
OP - 004 | 0.03 | 1.478 | 0.547999 | 0.809943 | 0.0175996 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.478 | 1.79947 | 3.27747 | 0.03 | 1 | 2.53847 | 1.52947 | -1.07053 | 2.26847 | -0.331534 | 3.00747 | 0.407466 | 0.080672 | 0.809943 | 0.0175996 | 3.27747 | 12.6175 | 1.79947 | 4.052 | 2.87 | 12.21 | 1.79947 | 11.1395
OP - 003 | 0.03 | 1.708 | 0.929675 | 1.58789 | 0.0343199 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F6 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 0.929675 | 1.708 | 1.63947 | 3.34747 | 0.03 | 1 | 2.49347 | 1.36947 | -1.23053 | 2.22347 | -0.376534 | 3.07747 | 0.477466 | 0.101722 | 1.58789 | 0.0343199 | 1.63947 | 10.9795 | 1.63947 | 5.27535 | 2.87 | 12.21 | 1.63947 | 10.9795
OP - 003 | 0.03 | 1.708 | 0.929675 | 1.58789 | 0.0132609 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 0.929675 | 1.708 | 1.63947 | 3.34747 | 0.03 | 1 | 2.49347 | -1.23253 | -2.99711 | -0.378534 | -2.14311 | 0.475466 | -1.28911 | 0.0564182 | 1.58789 | 0.0132609 | 1.63947 | 10.9795 | 1.63947 | 5.27535 | 3.34747 | 12.6875 | 2.872 | 12.212
V022 | 0.16 | 1.549 | 0.542667 | 0.840591 | 0.0152948
V023 | 0.16 | 0.874 | 0.301704 | 0.263689 | 0.00550195
PE005 | 0.16 | 2.6 | 2.4 | 6.24 | 0.103757
PI001 | 0.11 | 2.6 | 0.8 | 2.08 | 0.101102
OP - 004 | 0.03 | 1.549 | 0.542999 | 0.841105 | 0.0185956 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side |  | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.542999 | 1.549 | 1.72847 | 3.27747 | 0.03 | 1 | 2.50297 | 1.45847 | -1.14153 | 2.23297 | -0.367034 | 3.00747 | 0.407465 | 0.084782 | 0.841105 | 0.0185956 | 3.27747 | 12.6175 | 1.72847 | 4.184 | 2.87 | 12.21 | 1.72847 | 11.0685
OP - 004 | 0.03 | 1.549 | 0.543 | 0.841107 | 0.00660503 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side |  | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.543 | 1.549 | 1.72847 | 3.27747 | 0.03 | 1 | 2.50297 | -1.14353 | -2.59046 | -0.369034 | -1.81596 | 0.405466 | -1.04146 | 0.0406179 | 0.841107 | 0.00660503 | 3.27747 | 12.6175 | 1.72847 | 4.184 | 3.27747 | 12.6175 | 2.872 | 12.212
OP - 004 | 0.03 | 0.874 | 0.3 | 0.2622 | 0.00419881 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side |  | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.3 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | 2.13347 | -0.466535 | 2.57047 | -0.0295344 | 3.00747 | 0.407466 | 0.0369921 | 0.2622 | 0.00419881 | 3.27747 | 12.6175 | 2.40347 | 2.348 | 2.87 | 12.21 | 2.40347 | 11.7435
OP - 004 | 0.03 | 0.874 | 0.3 | 0.2622 | 0.00364919 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.3 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | -0.468535 | -1.91546 | -0.0315345 | -1.47846 | 0.405466 | -1.04146 | 0.0333279 | 0.2622 | 0.00364919 | 3.27747 | 12.6175 | 2.40347 | 2.348 | 3.27747 | 12.6175 | 2.872 | 12.212
OP - 006 | 0 | 0.874 | 0.42 | 0.36708 | 0 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 006 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ |  | Preexistències | EXISTING | 0.42 | 0.874 | 2.40347 | 3.27747 | 0 | 1 | 2.84047 | 2.13347 | -0.466535 | 2.57047 | -0.0295345 | 3.00747 | 0.407466 | 0 | 0.36708 | 0 | 3.27747 | 12.6175 | 2.40347 | 2.588 | 0 | 9.34 | 0 | 9.34
OP - 015 | 0.03 | 0.861579 | 0.452644 | 0.389989 | 0.00271415 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 015 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 015_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | 2.19436 | -0.40564 | 2.62515 | 0.0251503 | 3.05594 | 0.45594 | 0.0188602 | 0.389989 | 0.00271415 | 3.32594 | 12.6659 | 2.46436 | 2.62845 | 2.87 | 12.21 | 2.46436 | 11.8044
OP - 016 | 0.03 | 0.861579 | 0.452644 | 0.389989 | 0.00275415 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 016 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 016_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | 2.19436 | -0.40564 | 2.62515 | 0.0251503 | 3.05594 | 0.45594 | 0.0189588 | 0.389989 | 0.00275415 | 3.32594 | 12.6659 | 2.46436 | 2.62845 | 2.87 | 12.21 | 2.46436 | 11.8044
OP - 013 | 0.03 | 1.83374 | 0.452644 | 0.830034 | 0.018631 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 013 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 013_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 1.83374 | 1.49251 | 3.32626 | 0.03 | 1 | 2.40939 | 1.22251 | -1.37749 | 2.13939 | -0.460614 | 3.05626 | 0.456258 | 0.05485 | 0.830034 | 0.018631 | 3.32626 | 12.6663 | 1.49251 | 4.57278 | 2.87 | 12.21 | 1.49251 | 10.8325
OP - 011 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0225425 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 011 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 011_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49251 | 3.32626 | 0.03 | 1 | 2.40939 | 1.22251 | -1.37749 | 2.13939 | -0.460614 | 3.05626 | 0.456258 | 0.0576895 | 1.00489 | 0.0225425 | 3.32626 | 12.6663 | 1.49251 | 4.76349 | 2.87 | 12.21 | 1.49251 | 10.8325
OP - 012 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0226458 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 012 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 012_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49251 | 3.32626 | 0.03 | 1 | 2.40939 | 1.22251 | -1.37749 | 2.13939 | -0.460614 | 3.05626 | 0.456258 | 0.0990891 | 1.00489 | 0.0226458 | 3.32626 | 12.6663 | 1.49251 | 4.76349 | 2.87 | 12.21 | 1.49251 | 10.8325
OP - 006 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0226614 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 006 | 00_PLAYWOOD | Espai d'atenció; Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49157 | 3.32531 | 0.03 | 1 | 2.40844 | 1.22157 | -1.37843 | 2.13844 | -0.461561 | 3.05531 | 0.45531 | 0.099146 | 1.00489 | 0.0226614 | 3.32531 | 12.6653 | 1.49157 | 4.76349 | 2.87 | 12.21 | 1.49157 | 10.8316
OP - 005 | 0 | 1.83374 | 0.547999 | 1.00489 | 0 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 005 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ |  | Preexistències | EXISTING | 0.547999 | 1.83374 | 0.935133 | 2.76888 | 0 | 1 | 1.852 | 0.665133 | -1.93487 | 1.582 | -1.018 | 2.49888 | -0.101123 | 0 | 1.00489 | 0 | 2.76888 | 12.1089 | 0.935133 | 4.76349 | 0 | 9.34 | 0 | 9.34
OP - 008 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0226437 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 008 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 008_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49157 | 3.32531 | 0.03 | 1 | 2.40844 | 1.22157 | -1.37843 | 2.13844 | -0.461561 | 3.05531 | 0.45531 | 0.0577801 | 1.00489 | 0.0226437 | 3.32531 | 12.6653 | 1.49157 | 4.76349 | 2.87 | 12.21 | 1.49157 | 10.8316
OP - 005 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.022558 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 005 | 00_PLAYWOOD | Espai d'atenció; Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49157 | 3.32531 | 0.03 | 1 | 2.40844 | 1.22157 | -1.37843 | 2.13844 | -0.461561 | 3.05531 | 0.45531 | 0.057718 | 1.00489 | 0.022558 | 3.32531 | 12.6653 | 1.49157 | 4.76349 | 2.87 | 12.21 | 1.49157 | 10.8316
OP - 005 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0226614 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 005 | 00_PLAYWOOD | Espai d'atenció; Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49157 | 3.32531 | 0.03 | 1 | 2.40844 | 1.22157 | -1.37843 | 2.13844 | -0.461561 | 3.05531 | 0.45531 | 0.099146 | 1.00489 | 0.0226614 | 3.32531 | 12.6653 | 1.49157 | 4.76349 | 2.87 | 12.21 | 1.49157 | 10.8316
OP - 010 | 0 | 1.83374 | 0.547999 | 1.00489 | 0 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 010 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 010_ |  | Preexistències | EXISTING | 0.547999 | 1.83374 | 0.799814 | 2.63356 | 0 | 1 | 1.71669 | 0.529813 | -2.07019 | 1.44669 | -1.15331 | 2.36356 | -0.236443 | 0 | 1.00489 | 0 | 2.63356 | 11.9736 | 0.799814 | 4.76349 | 0 | 9.34 | 0 | 9.34
OP - 005 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0226926 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 005 | 00_PLAYWOOD | Espai d'atenció; Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.48967 | 3.32342 | 0.03 | 1 | 2.40654 | 1.21967 | -1.38033 | 2.13654 | -0.463456 | 3.05342 | 0.453416 | 0.0578498 | 1.00489 | 0.0226926 | 3.32342 | 12.6634 | 1.48967 | 4.76349 | 2.87 | 12.21 | 1.48967 | 10.8297
OP - 004 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0226926 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.48967 | 3.32342 | 0.03 | 1 | 2.40654 | 1.21967 | -1.38033 | 2.13654 | -0.463456 | 3.05342 | 0.453416 | 0.0578498 | 1.00489 | 0.0226926 | 3.32342 | 12.6634 | 1.48967 | 4.76349 | 2.87 | 12.21 | 1.48967 | 10.8297
OP - 006 | 0 | 1.83374 | 0.547999 | 1.00489 | 0 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 006 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ |  | Preexistències | EXISTING | 0.547999 | 1.83374 | 1.03626 | 2.87 | 0 | 1 | 1.95313 | 0.766256 | -1.83374 | 1.68313 | -0.916872 | 2.6 | 1.02392e-07 | 0 | 1.00489 | 0 | 2.87 | 12.21 | 1.03626 | 4.76349 | 0 | 9.34 | 0 | 9.34
OP - 005 | 0 | 1.83374 | 0.547999 | 1.00489 | 0 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 005 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ |  | Preexistències | EXISTING | 0.547999 | 1.83374 | 1.03626 | 2.87 | 0 | 1 | 1.95313 | 0.766256 | -1.83374 | 1.68313 | -0.916872 | 2.6 | 1.02392e-07 | 0 | 1.00489 | 0 | 2.87 | 12.21 | 1.03626 | 4.76349 | 0 | 9.34 | 0 | 9.34
OP - 004 | 0.03 | 1.83343 | 0.452644 | 0.82989 | 0.0187053 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 1.83343 | 1.49251 | 3.32594 | 0.03 | 1 | 2.40923 | 1.22251 | -1.37749 | 2.13923 | -0.460773 | 3.05594 | 0.45594 | 0.0549039 | 0.82989 | 0.0187053 | 3.32594 | 12.6659 | 1.49251 | 4.57214 | 2.87 | 12.21 | 1.49251 | 10.8325
OP - 004 | 0.03 | 0.405639 | 0.452644 | 0.18361 | 0.00269225 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.405639 | 2.46436 | 2.87 | 0.03 | 1 | 2.66718 | 2.19436 | -0.40564 | 2.39718 | -0.20282 | 2.6 | 1.02392e-07 | 0.0188062 | 0.18361 | 0.00269225 | 2.87 | 12.21 | 2.46436 | 1.71657 | 2.87 | 12.21 | 2.46436 | 11.8044
OP - 004 | 0.03 | 0.405639 | 0.452644 | 0.18361 | 0.00277605 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.405639 | 2.46436 | 2.87 | 0.03 | 1 | 2.66718 | 2.19436 | -0.40564 | 2.39718 | -0.20282 | 2.6 | 1.02392e-07 | 0.0190128 | 0.18361 | 0.00277605 | 2.87 | 12.21 | 2.46436 | 1.71657 | 2.87 | 12.21 | 2.46436 | 11.8044
OP - 017 | 0 | 1.83374 | 0.547999 | 1.00489 | 0 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 017 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T6 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 017_ |  | Preexistències | EXISTING | 0.547999 | 1.83374 | 1.24787 | 3.08162 | 0 | 1 | 2.16475 | -1.62413 | -3.07113 | -0.707255 | -2.15425 | 0.209617 | -1.23738 | 0 | 1.00489 | 0 | 3.08162 | 12.4216 | 1.24787 | 4.76349 | 0 | 9.34 | 0 | 9.34
OP - 004 | 0.03 | 1.37749 | 0.449047 | 0.618555 | 0.0185567 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.449047 | 1.37749 | 1.49251 | 2.87 | 0.03 | 1 | 2.18126 | 1.22251 | -1.37749 | 1.91126 | -0.688743 | 2.6 | 1.02392e-07 | 0.054796 | 0.618555 | 0.0185567 | 2.87 | 12.21 | 1.49251 | 3.65307 | 2.87 | 12.21 | 1.49251 | 10.8325
OP - 014 | 0.03 | 1.83172 | 0.452644 | 0.829117 | 0.0061628 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 014 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 014_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 1.83172 | 1.49593 | 3.32765 | 0.03 | 1 | 2.41179 | -1.37607 | -2.82307 | -0.460211 | -1.90721 | 0.455648 | -0.991352 | 0.0271948 | 0.829117 | 0.0061628 | 3.32765 | 12.6676 | 1.49593 | 4.56872 | 3.32765 | 12.6676 | 2.872 | 12.212
OP - 020 | 0.03 | 0.861579 | 0.452644 | 0.389989 | 0.0030821 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 020 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 020_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | -0.40764 | -1.85464 | 0.0231503 | -1.42385 | 0.45394 | -0.99306 | 0.0204079 | 0.389989 | 0.0030821 | 3.32594 | 12.6659 | 2.46436 | 2.62845 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 013 | 0.03 | 1.83374 | 0.452644 | 0.830034 | 0.00613971 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 013 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 013_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | -1.3798 | -2.8268 | -0.462932 | -1.90993 | 0.45394 | -0.99306 | 0.0271436 | 0.830034 | 0.00613971 | 3.32594 | 12.6659 | 1.4922 | 4.57278 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 008 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00746799 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 008 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 008_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49251 | 3.32626 | 0.03 | 1 | 2.40939 | -1.37949 | -2.82649 | -0.462614 | -1.90961 | 0.454258 | -0.992742 | 0.0300677 | 1.00489 | 0.00746799 | 3.32626 | 12.6663 | 1.49251 | 4.76349 | 3.32626 | 12.6663 | 2.872 | 12.212
OP - 009 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00746276 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 009 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 009_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | -1.3798 | -2.8268 | -0.462932 | -1.90993 | 0.45394 | -0.99306 | 0.0436764 | 1.00489 | 0.00746276 | 3.32594 | 12.6659 | 1.4922 | 4.76349 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 006 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00745241 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 006 | 00_PLAYWOOD | Espai d'atenció; Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49157 | 3.32531 | 0.03 | 1 | 2.40844 | -1.38043 | -2.82743 | -0.463561 | -1.91056 | 0.45331 | -0.99369 | 0.0436386 | 1.00489 | 0.00745241 | 3.32531 | 12.6653 | 1.49157 | 4.76349 | 3.32531 | 12.6653 | 2.872 | 12.212
OP - 006 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00744138 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 006 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49125 | 3.32499 | 0.03 | 1 | 2.40812 | -1.38075 | -2.82775 | -0.463879 | -1.91088 | 0.452993 | -0.994007 | 0.0300169 | 1.00489 | 0.00744138 | 3.32499 | 12.665 | 1.49125 | 4.76349 | 3.32499 | 12.665 | 2.872 | 12.212
OP - 018 | 0 | 1.83374 | 0.547999 | 1.00489 | 0 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 018 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T6 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 018_ |  | Preexistències | EXISTING | 0.547999 | 1.83374 | 1.44838 | 3.28212 | 0 | 1 | 2.36525 | -1.42362 | -2.87062 | -0.50675 | -1.95375 | 0.410122 | -1.03688 | 0 | 1.00489 | 0 | 3.28212 | 12.6221 | 1.44838 | 4.76349 | 0 | 9.34 | 0 | 9.34
OP - 005 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00745241 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 005 | 00_PLAYWOOD | Espai d'atenció; Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49157 | 3.32531 | 0.03 | 1 | 2.40844 | -1.38043 | -2.82743 | -0.463561 | -1.91056 | 0.45331 | -0.99369 | 0.0436386 | 1.00489 | 0.00745241 | 3.32531 | 12.6653 | 1.49157 | 4.76349 | 3.32531 | 12.6653 | 2.872 | 12.212
OP - 006 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00745241 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 006 | 00_PLAYWOOD | Espai d'atenció; Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49157 | 3.32531 | 0.03 | 1 | 2.40844 | -1.38043 | -2.82743 | -0.463561 | -1.91056 | 0.45331 | -0.99369 | 0.0300393 | 1.00489 | 0.00745241 | 3.32531 | 12.6653 | 1.49157 | 4.76349 | 3.32531 | 12.6653 | 2.872 | 12.212
OP - 005 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00742126 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 005 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.48967 | 3.32342 | 0.03 | 1 | 2.40654 | -1.38233 | -2.82933 | -0.465456 | -1.91246 | 0.451416 | -0.995584 | 0.0299824 | 1.00489 | 0.00742126 | 3.32342 | 12.6634 | 1.48967 | 4.76349 | 3.32342 | 12.6634 | 2.872 | 12.212
OP - 005 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00742126 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 005 | 00_PLAYWOOD | Espai d'atenció; Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.48967 | 3.32342 | 0.03 | 1 | 2.40654 | -1.38233 | -2.82933 | -0.465456 | -1.91246 | 0.451416 | -0.995584 | 0.0299824 | 1.00489 | 0.00742126 | 3.32342 | 12.6634 | 1.48967 | 4.76349 | 3.32342 | 12.6634 | 2.872 | 12.212
OP - 005 | 0.03 | 0.861579 | 0.452644 | 0.389989 | 0.00301282 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 005 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | -0.40764 | -1.85464 | 0.0231503 | -1.42385 | 0.45394 | -0.99306 | 0.0202553 | 0.389989 | 0.00301282 | 3.32594 | 12.6659 | 2.46436 | 2.62845 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 005 | 0.03 | 0.861579 | 0.452644 | 0.389989 | 0.0031066 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 005 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | -0.40764 | -1.85464 | 0.0231503 | -1.42385 | 0.45394 | -0.99306 | 0.0204618 | 0.389989 | 0.0031066 | 3.32594 | 12.6659 | 2.46436 | 2.62845 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 004 | 0.03 | 1.83343 | 0.449047 | 0.823294 | 0.00606621 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.449047 | 1.83343 | 1.49251 | 3.32594 | 0.03 | 1 | 2.40923 | -1.37949 | -2.82649 | -0.462773 | -1.90977 | 0.45394 | -0.99306 | 0.0269817 | 0.823294 | 0.00606621 | 3.32594 | 12.6659 | 1.49251 | 4.56494 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 004 | 0.03 | 1.83343 | 0.452644 | 0.82989 | 0.0061642 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 1.83343 | 1.49251 | 3.32594 | 0.03 | 1 | 2.40923 | -1.37949 | -2.82649 | -0.462773 | -1.90977 | 0.45394 | -0.99306 | 0.0271975 | 0.82989 | 0.0061642 | 3.32594 | 12.6659 | 1.49251 | 4.57214 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 006 | 0 | 1.37749 | 0.452644 | 0.623511 | 0 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 006 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T6 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ |  | Preexistències | EXISTING | 0.452644 | 1.37749 | 1.90278 | 3.28027 | 0 | 1 | 2.59153 | -0.969216 | -2.41622 | -0.280473 | -1.72747 | 0.40827 | -1.03873 | 0 | 0.623511 | 0 | 3.28027 | 12.6203 | 1.90278 | 3.66026 | 0 | 9.34 | 0 | 9.34
OP - 019 | 0.03 | 0.861579 | 0.452644 | 0.389989 | 0.00303733 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 019 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 019_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | -0.40764 | -1.85464 | 0.0231503 | -1.42385 | 0.45394 | -0.99306 | 0.0203092 | 0.389989 | 0.00303733 | 3.32594 | 12.6659 | 2.46436 | 2.62845 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 004 | 0.03 | 1.549 | 0.542999 | 0.841105 | 0.00660502 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.542999 | 1.549 | 1.72847 | 3.27747 | 0.03 | 1 | 2.50297 | -1.14353 | -2.59046 | -0.369034 | -1.81596 | 0.405466 | -1.04146 | 0.0406179 | 0.841105 | 0.00660502 | 3.27747 | 12.6175 | 1.72847 | 4.184 | 3.27747 | 12.6175 | 2.872 | 12.212
OP - 004 | 0.03 | 1.549 | 0.543 | 0.841107 | 0.0185956 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.543 | 1.549 | 1.72847 | 3.27747 | 0.03 | 1 | 2.50297 | 1.45847 | -1.14153 | 2.23297 | -0.367034 | 3.00747 | 0.407466 | 0.084782 | 0.841107 | 0.0185956 | 3.27747 | 12.6175 | 1.72847 | 4.184 | 2.87 | 12.21 | 1.72847 | 11.0685
OP - 006 | 0.03 |  |  | 0.263707 | 0.00176803 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 006 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ | Nau Santa Eulalia | Obra | NEW | 0.301724 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | 2.13347 | -0.466535 | 2.57047 | -0.0295345 | 3.00747 | 0.407466 | 0.0177857 | 0.263707 | 0.00176803 | 3.27747 | 12.6175 | 2.40347 | 2.35145 | 2.87 | 12.21 | 2.40347 | 11.7435
OP - 014 | 0.03 | 1.83172 | 0.452644 | 0.829117 | 0.0186079 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 014 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 014_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 1.83172 | 1.49422 | 3.32594 | 0.03 | 1 | 2.41008 | 1.22422 | -1.37578 | 2.14008 | -0.459919 | 3.05594 | 0.45594 | 0.0547987 | 0.829117 | 0.0186079 | 3.32594 | 12.6659 | 1.49422 | 4.56872 | 2.87 | 12.21 | 1.49422 | 10.8342
OP - 006 | 0.03 |  |  | 0.2611 | 0.00240279 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 006 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ | Nau Santa Eulalia | Obra | NEW | 0.298741 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | 2.13347 | -0.466535 | 2.57047 | -0.0295345 | 3.00747 | 0.407466 | 0.0191463 | 0.2611 | 0.00240279 | 3.27747 | 12.6175 | 2.40347 | 2.34548 | 2.87 | 12.21 | 2.40347 | 11.7435
OP - 006 | 0.03 | 0.874 | 0.300465 | 0.262607 | 0.00152128 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 006 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ | Nau Santa Eulalia | Obra | NEW | 0.300465 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | -0.468535 | -1.91546 | -0.0315345 | -1.47846 | 0.405466 | -1.04146 | 0.0159159 | 0.262607 | 0.00152128 | 3.27747 | 12.6175 | 2.40347 | 2.34893 | 3.27747 | 12.6175 | 2.872 | 12.212
OP - 006 | 0.03 | 0.874 | 0.300465 | 0.262607 | 0.00208827 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 006 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ | Nau Santa Eulalia | Obra | NEW | 0.300465 | 0.874 | 2.40347 | 3.27747 | 0.03 | 1 | 2.84047 | -0.468535 | -1.91546 | -0.0315345 | -1.47846 | 0.405466 | -1.04146 | 0.0173143 | 0.262607 | 0.00208827 | 3.27747 | 12.6175 | 2.40347 | 2.34893 | 3.27747 | 12.6175 | 2.872 | 12.212
