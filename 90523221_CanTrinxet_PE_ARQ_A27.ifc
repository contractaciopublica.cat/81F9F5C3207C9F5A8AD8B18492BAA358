Properties of the parts of a building model (IFC2X3), part 99 of 99

# IfcOpeningElement (289)
Name | Depth (m) | BaseQuantities, Height (m) | BaseQuantities, Width (m) | BaseQuantities, Area (m2) | Volume (m3) | Classification | Shape | Orientation | Limits | Cut Symbol Name | Uncut Symbol Name | IDs of Cut Elements | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Layer | Colliding Zones | Locked | Home Story Name = 115.AMB.Nivell | Home Story Number = Slant Angle (deg) = 506.AMB.Profunditat (m) = Opening End Surface Area (Net, total) (m2) | Element Type | Parent ID | Surfaces (All) | Design Option Name = Design Option Set Name = Design Option Status = Design Option Set | Position | Renovation Status | Show On Renovation Filter | 001.AMB.ExpedientNumero | 003.AMB.NomProjecte | 004.AMB.FaseProjecte | 007.AMB.ModelDisciplina | 008.AMB.Adreca | 009.AMB.Municipi | 010.AMB.AutorProjecte | 011.AMB.AutorProjecte2 | 012.AMB.AutorProjecte3 | 107.AMB.NomTipus | 117.AMB.Localitzacio | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | Status | 502.AMB.Amplada (m) = ArchiCADQuantities, Width (m) | 503.AMB.Altura (m) = ArchiCADQuantities, Height (m) | Sill Height to Home Story (m) = Sill Height to Project Zero (m) | Header Height to Home Story (m) = Header Height to Project Zero (m) | Total Thickness (m) | Number of Cut Elements | Center Height to Home Story (m) = Center Height to Project Zero (m) | Sill Height to Wall Bottom (m) | Sill Height to Wall Top (m) | Center Height to Wall Bottom (m) | Center Height to Wall Top (m) | Header Height to Wall Bottom (m) | Header Height to Wall Top (m) | Opening Extrusion Surface Area (Net) (m2) = Surface Area (m2) = Edge Surface Area (Net) (m2) = Bottom Surface Area (Net) (m2) | ArchiCADQuantities, Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) | Elevation to Sea Level (m) | Home Offset (m) | 3D Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m)
3 x OP - 003 | 0.03 | 1.708 | 0.929675 | 1.58789 | 0.0343199 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 0.929675 | 1.708 | 1.63947 | 3.34747 | 0.03 | 1 | 2.49347 | 1.36947 | -1.23053 | 2.22347 | -0.376534 | 3.07747 | 0.477466 | 0.101722 | 1.58789 | 0.0343199 | 1.63947 | 10.9795 | 1.63947 | 5.27535 | 2.87 | 12.21 | 1.63947 | 10.9795
OP - 003 | 0.03 | 1.708 | 0.929675 | 1.58789 | 0.0132609 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 0.929675 | 1.708 | 1.63947 | 3.34747 | 0.03 | 1 | 2.49347 | -1.23253 | -3.4388 | -0.378534 | -2.5848 | 0.475466 | -1.7308 | 0.0564182 | 1.58789 | 0.0132609 | 1.63947 | 10.9795 | 1.63947 | 5.27535 | 3.34747 | 12.6875 | 2.872 | 12.212
OP - 003 | 0.03 |  |  | 0.328508 | 0.00986781 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 1.38693 | 0.289174 | 3.3559 | 3.64612 | 0.03 | 1 | 3.50101 | -1.24459e-07 | -1.72236 | 0.145109 | -1.57725 | 0.290218 | -1.43214 | 0.0430283 | 0.328508 | 0.00986781 | 3.64508 | 12.9851 | 3.3559 | 3.07892 | 3.64612 | 12.9861 | 3.48502 | 12.825
OP - 003 | 0.03 | 1.708 | 0.929675 | 1.58789 | 0.0132609 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 0.929675 | 1.708 | 1.63947 | 3.34747 | 0.03 | 1 | 2.49347 | -1.23253 | -3.42012 | -0.378534 | -2.56612 | 0.475466 | -1.71212 | 0.0564182 | 1.58789 | 0.0132609 | 1.63947 | 10.9795 | 1.63947 | 5.27535 | 3.34747 | 12.6875 | 2.872 | 12.212
OP - 003 | 0.03 |  |  | 0.149095 | 0.00448972 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 1.389 | 0.159344 | 3.48597 | 3.64643 | 0.03 | 1 | 3.5662 | -1.06973e-07 | -1.6529 | 0.0802283 | -1.57267 | 0.160457 | -1.49245 | 0.0431393 | 0.149095 | 0.00448972 | 3.64531 | 12.9853 | 3.48597 | 2.82624 | 3.64643 | 12.9864 | 3.48597 | 12.826
OP - 003 | 0.03 | 1.708 | 0.929675 | 1.58789 | 0.0132609 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 0.929675 | 1.708 | 1.63947 | 3.34747 | 0.03 | 1 | 2.49347 | -1.23253 | -3.49941 | -0.378534 | -2.64541 | 0.475466 | -1.79141 | 0.0564182 | 1.58789 | 0.0132609 | 1.63947 | 10.9795 | 1.63947 | 5.27535 | 3.34747 | 12.6875 | 2.872 | 12.212
PI002 | 0.14 | 2.6 | 0.8 | 2.08 | 0.10102
2 x V102 | 0.165 | 0.938204 | 0.527944 | 0.49532 | 0.00946111
PE101 | 0.165 | 2.68501 | 1.2 | 3.22201 | 0.184694
OP - 003 | 0.03 |  |  | 0.441786 | 0.00550954 | Empty Opening (ARCHICAD Classification) | Circle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 0.75 | 0.75 | 7.40004 | 8.15004 | 0.03 | 1 | 7.77504 | 0.237763 | -2.58027 | 0.612763 | -2.20527 | 0.987763 | -1.83026 | 0.0276816 | 0.441786 | 0.00550954 | 8.15004 | 17.49 | 7.40004 | 2.35619 | 8.09348 | 17.4335 | 7.40294 | 16.7429
OP - 003 | 0.03 |  |  | 1.13097 | 0.0338192 | Empty Opening (ARCHICAD Classification) | Circle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2; T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 1.2 | 1.2 | 7.14686 | 8.34686 | 0.03 | 2 | 7.74686 | -0.0154219 | -2.85942 | 0.584578 | -2.25942 | 1.18458 | -1.65942 | 0.104925 | 1.13097 | 0.0338192 | 8.34686 | 17.6869 | 7.14686 | 3.76991 | 8.34686 | 17.6869 | 7.16228 | 16.5023
OP - 003 | 0.03 |  |  | 4.32449 | 0.0370453 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2; T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 1.72397 | 2.55513 | 2.52609 | 5.08234 | 0.03 | 2 | 3.80421 | -1.79016 | -4.63416 | -0.51204 | -3.35604 | 0.766083 | -2.07792 | 0.0524737 | 4.32449 | 0.0370453 | 5.08122 | 14.4212 | 2.52609 | 8.30591 | 5.08234 | 14.4223 | 4.94026 | 14.2803
OP - 003 | 0.03 |  |  | 4.08138 | 0.0370399 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2; T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 1.72397 | 2.41406 | 2.66699 | 5.08217 | 0.03 | 2 | 3.87458 | -1.64926 | -4.49326 | -0.441673 | -3.28567 | 0.765913 | -2.07809 | 0.0524722 | 4.08138 | 0.0370399 | 5.08105 | 14.4211 | 2.66699 | 8.02403 | 5.08217 | 14.4222 | 4.93966 | 14.2797
DOO - 009 | 0.15 | 2.6 | 1.72003 | 4.47208 | 0.192643
OP - 003 | 0.03 |  |  | 0.0821031 | 0.00247338 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 0.783354 | 0.153143 | 6.16152 | 6.31551 | 0.03 | 1 | 6.23851 | -1.1395e-07 | -1.00076 | 0.07699 | -0.923766 | 0.15398 | -0.846776 | 0.0240841 | 0.0821031 | 0.00247338 | 6.16152 | 15.5015 | 6.16152 | 1.7402 | 6.3155 | 15.6555 | 6.16214 | 15.5021
OP - 003 | 0.03 |  |  | 1.17276 | 0.0175781 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 1.78748 | 0.725461 | 4.31425 | 5.04097 | 0.03 | 1 | 4.67761 | -6.85889e-08 | -2.84803 | 0.363356 | -2.48467 | 0.726712 | -2.12132 | 0.0277678 | 1.17276 | 0.0175781 | 4.31425 | 13.6543 | 4.31425 | 4.66697 | 5.04097 | 14.381 | 4.82783 | 14.1678
OP - 003 | 0.03 |  |  | 1.17248 | 0.0175734 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 1.78748 | 0.725241 | 4.31425 | 5.04075 | 0.03 | 1 | 4.6775 | -6.85889e-08 | -2.84803 | 0.363248 | -2.48478 | 0.726497 | -2.12153 | 0.0277656 | 1.17248 | 0.0175734 | 4.31425 | 13.6543 | 4.31425 | 4.66681 | 5.04055 | 14.3806 | 4.8278 | 14.1678
OP - 003 | 0.03 |  |  | 0.0827233 | 0.00248592 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 0.783354 | 0.15292 | 6.16152 | 6.31572 | 0.03 | 1 | 6.23862 | -1.1395e-07 | -1.00076 | 0.0770968 | -0.923659 | 0.154194 | -0.846562 | 0.0240985 | 0.0827233 | 0.00248592 | 6.16152 | 15.5015 | 6.16152 | 1.74002 | 6.31572 | 15.6557 | 6.16152 | 15.5015
OP - 003 | 0 |  |  | 1.13097 | 0 | Empty Opening (ARCHICAD Classification) | Circle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ |  | Preexistències | EXISTING | 1.2 | 1.2 | 7.14686 | 8.34686 | 0 | 1 | 7.74686 | -0.0154219 | -2.83345 | 0.584578 | -2.23345 | 1.18458 | -1.63345 | 0 | 1.13097 | 0 | 8.34686 | 17.6869 | 7.14686 | 3.76991 | 0 | 9.34 | 0 | 9.34
PE006 | 0.16 | 3.23889 | 1.39052 | 4.42874 | 0.0786049
V024 | 0.16 | 1.708 | 0.929675 | 1.58789 | 0.0126656
V019 | 0.16 | 1.708 | 0.929675 | 1.58789 | 0.0126656
PI011 | 0.16 | 3.46 | 1.737 | 4.9113 | 0.0922897
2 x V001 | 0.16 | 1.83343 | 0.452644 | 0.82989 | 0.0167819
V003 | 0.16 | 1.83172 | 0.549999 | 1.00744 | 0.0175136
V002 | 0.16 | 1.83172 | 0.549999 | 1.00744 | 0.0175136
V003 | 0.16 | 1.83343 | 0.55 | 1.00838 | 0.0175267
V004 | 0.16 | 1.83172 | 0.549999 | 1.00744 | 0.0175136
V004 | 0.16 | 1.83343 | 0.55 | 1.00838 | 0.0175267
V005 | 0.16 | 1.83172 | 0.549999 | 1.00744 | 0.0175136
2 x V006 | 0.16 | 1.83343 | 0.452644 | 0.82989 | 0.0167819
V005 | 0.16 | 1.83343 | 0.55 | 1.00838 | 0.0175267
V001 | 0.16 | 0.861579 | 0.452644 | 0.389989 | 0.0061807
V006 | 0.16 | 0.861579 | 0.452644 | 0.389989 | 0.0061807
V002 | 0.16 | 1.83343 | 0.55 | 1.00838 | 0.0175267
2 x OP - 003 | 0 |  |  | 0.423538 | 0 | Empty Opening (ARCHICAD Classification) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_TABIQUE |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ |  | Preexistències | EXISTING | 0.457933 | 1.04239 |  |  | 0 | 1 |  |  |  |  |  |  |  | 0 | 0.423538 | 0 | 4.73483 | 14.0748 | 4.73483 | 3.00064 | 0 | 9.34 | 0 | 9.34
2 x OP - 003 | 0 |  |  | 1.04194 | 0 | Empty Opening (ARCHICAD Classification) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_TABIQUE |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ |  | Preexistències | EXISTING | 0.55 | 2.02004 |  |  | 0 | 1 |  |  |  |  |  |  |  | 0 | 1.04194 | 0 | 4.73951 | 14.0795 | 4.73951 | 5.14009 | 0 | 9.34 | 0 | 9.34
OP - 003 | 0 |  |  | 0.859364 | 0 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_TABIQUE |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ |  | Preexistències | EXISTING | 0.452644 | 2.03962 | 1.49422 | 3.53384 | 0 | 1 | 2.51403 | 1.22422 | -4.71075 | 2.24403 | -3.69094 | 3.26384 | -2.67114 | 0 | 0.859364 | 0 | 3.53384 | 12.8738 | 1.49422 | 4.96754 | 0 | 9.34 | 0 | 9.34
2 x OP - 003 | 0 |  |  | 0.859364 | 0 | Empty Opening (ARCHICAD Classification) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_TABIQUE |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ |  | Preexistències | EXISTING | 0.452644 | 2.03962 |  |  | 0 | 1 |  |  |  |  |  |  |  | 0 | 0.859364 | 0 | 4.76192 | 14.1019 | 4.76192 | 4.96754 | 0 | 9.34 | 0 | 9.34
OP - 003 | 0 |  |  | 0.859539 | 0 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_TABIQUE |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ |  | Preexistències | EXISTING | 0.452644 | 2.03962 | 1.49422 | 3.53384 | 0 | 1 | 2.51403 | 1.22422 | -4.71075 | 2.24403 | -3.69094 | 3.26384 | -2.67114 | 0 | 0.859539 | 0 | 3.53384 | 12.8738 | 1.49422 | 4.96754 | 0 | 9.34 | 0 | 9.34
3 x OP - 003 | 0 |  |  | 1.04194 | 0 | Empty Opening (ARCHICAD Classification) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_TABIQUE |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ |  | Preexistències | EXISTING | 0.55 | 2.02004 |  |  | 0 | 1 |  |  |  |  |  |  |  | 0 | 1.04194 | 0 | 4.7414 | 14.0814 | 4.7414 | 5.14009 | 0 | 9.34 | 0 | 9.34
2 x OP - 003 | 0 |  |  | 1.04194 | 0 | Empty Opening (ARCHICAD Classification) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_TABIQUE |  | no | planta baixa | 0 | Opening | F1 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ |  | Preexistències | EXISTING | 0.55 | 2.02004 |  |  | 0 | 1 |  |  |  |  |  |  |  | 0 | 1.04194 | 0 | 4.74235 | 14.0823 | 4.74235 | 5.14009 | 0 | 9.34 | 0 | 9.34
V204 | 0.08 | 3.09484 | 1.59919 | 4.8626 | 0.0386325
PE201 | 0.08 | 3.32512 | 1.78948 | 5.82386 | 0.106502
V203 | 0.08 | 4.59898 | 1.59919 | 7.27326 | 0.159591
V206 | 0.08 | 0.75 | 0.75 | 0.440979 | 0.00548774
V201 | 0.08 | 2.41357 | 1.72397 | 4.07619 | 0.0281881
V202 | 0.08 | 2.41357 | 1.72397 | 4.07619 | 0.0281881
V205 | 0.08 | 1.2 | 1.2 | 1.12891 | 0.00901558
OP - 003 | 0.03 |  |  | 0.441786 | 0.00768663 | Empty Opening (ARCHICAD Classification) | Circle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 0.75 | 0.75 | 7.40004 | 8.15004 | 0.03 | 1 | 7.77504 | 0.237763 | -2.58027 | 0.612763 | -2.20527 | 0.987763 | -1.83026 | 0.0375231 | 0.441786 | 0.00768663 | 8.15004 | 17.49 | 7.40004 | 2.35619 | 8.15004 | 17.49 | 7.40004 | 16.74
OP - 003 | 0 | 3.09641 | 1.59919 | 4.95175 | 0 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T6 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ |  | Preexistències | EXISTING | 1.59919 | 3.09641 | 1.21784 | 4.31425 | 0 | 1 | 2.76605 | -3.09641 | -3.73441 | -1.54821 | -2.18621 | 4.08248e-07 | -0.638 | 0 | 4.95175 | 0 | 4.31425 | 13.6543 | 1.21784 | 9.3912 | 0 | 9.34 | 0 | 9.34
OP - 003 | 0.4 |  |  | 4.99818 | 1.9995 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | SW - 052 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | SW - 052 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 1.39291 | 3.64027 | 0.00428451 | 3.6457 | 0.4 | 1 | 1.82499 | 0.962367 | -5.68119 | 2.78308 | -3.86048 | 4.60379 | -2.03977 | 3.91868 | 4.99818 | 1.9995 | 3.64455 | 12.9846 | 0.00428451 | 9.79596 | 3.6457 | 12.9857 | 0.00428451 | 9.34428 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
V021 | 0.16 | 1.549 | 0.542667 | 0.840591 | 0.0152948
V020 | 0.16 | 0.874 | 0.29998 | 0.262182 | 0.0054935
OP - 003 | 0.08 |  |  | 4.47208 | 0.357766 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T4 | OP - 003 | 00_TABIQUE | Nau Lateral | no | planta baixa | 0 | Opening | T4 | Insulation - Cellulose | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 1.72003 | 2.6 | 1.71425 | 4.31425 | 0.08 | 1 | 3.01425 | -9.24308e-08 | -3.84 | 1.3 | -2.54 | 2.6 | -1.24 | 0.553602 | 4.47208 | 0.357766 | 4.31425 | 13.6543 | 1.71425 | 8.64006 | 4.31425 | 13.6543 | 1.71425 | 11.0543
V017 | 0.16 | 0.874 | 0.301704 | 0.263689 | 0.00550195
V016 | 0.16 | 1.54246 | 0.547999 | 0.845268 | 0.0152855
V015 | 0.16 | 1.478 | 0.546726 | 0.808061 | 0.0147827
V014 | 0.16 | 0.874 | 0.318126 | 0.278043 | 0.00558242
PE003 | 0.16 | 2.6 | 2.4 | 6.24 | 0.103757
OP - 003 | 0.4 | 0.874 | 0.318126 | 0.278043 | 0.111217 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F6; F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.318126 | 0.874 | 2.40347 | 3.27747 | 0.4 | 2 | 2.84047 | 3.36155 | -1.9055 | 3.79855 | -1.4685 | 4.23555 | -1.0315 | 0.953701 | 0.278043 | 0.111217 | 3.27747 | 12.6175 | 2.40347 | 2.38425 | 3.27747 | 12.6175 | 2.40347 | 11.7435 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 | 1.549 | 0.546726 | 0.846879 | 0.338752 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F6; F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.546726 | 1.549 | 1.72847 | 3.27747 | 0.4 | 2 | 2.50297 | 2.68655 | -2.5805 | 3.46105 | -1.806 | 4.23555 | -1.0315 | 1.67658 | 0.846879 | 0.338752 | 3.27747 | 12.6175 | 1.72847 | 4.19145 | 3.27747 | 12.6175 | 1.72847 | 11.0685 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
2 x OP - 003 | 0.4 | 0.77 | 0.6 | 0.462 | 0.1848 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F6; F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.6 | 0.77 | 2.05347 | 2.82347 | 0.4 | 2 | 2.43847 | 3.01155 | -2.2555 | 3.39655 | -1.8705 | 3.78155 | -1.4855 | 1.096 | 0.462 | 0.1848 | 2.82347 | 12.1635 | 2.05347 | 2.74 | 2.82347 | 12.1635 | 2.05347 | 11.3935 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 | 2.60747 | 2.4 | 6.25792 | 2.50317 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F6; F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 2.4 | 2.60747 | 0.27 | 2.87747 | 0.4 | 2 | 1.57373 | 1.22808 | -4.03897 | 2.53182 | -2.73523 | 3.83555 | -1.4315 | 4.00597 | 6.25792 | 2.50317 | 2.87747 | 12.2175 | 0.27 | 10.0149 | 2.87747 | 12.2175 | 0.27 | 9.61 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 | 0.874 | 0.301704 | 0.263689 | 0.105476 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F6; F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.301704 | 0.874 | 2.40347 | 3.27747 | 0.4 | 2 | 2.84047 | 3.36155 | -1.9055 | 3.79855 | -1.4685 | 4.23555 | -1.0315 | 0.940563 | 0.263689 | 0.105476 | 3.27747 | 12.6175 | 2.40347 | 2.35141 | 3.27747 | 12.6175 | 2.40347 | 11.7435 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
2 x V007 | 0.16 | 1.83172 | 0.452644 | 0.829117 | 0.0167689
OP - 003 | 0.4 | 1.47933 | 0.550123 | 0.813814 | 0.325526 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F6; F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.550123 | 1.47933 | 1.79947 | 3.2788 | 0.4 | 2 | 2.53913 | 2.75755 | -2.5095 | 3.49721 | -1.76983 | 4.23688 | -1.03017 | 1.62356 | 0.813814 | 0.325526 | 3.2788 | 12.6188 | 1.79947 | 4.05891 | 3.2788 | 12.6188 | 1.79947 | 11.1395 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
2 x V012 | 0.16 | 1.83172 | 0.452644 | 0.829117 | 0.0167689
V007 | 0.16 | 0.861579 | 0.457933 | 0.394546 | 0.00620661
2 x V008 | 0.16 | 1.83172 | 0.549999 | 1.00744 | 0.0175136
2 x V009 | 0.16 | 1.83172 | 0.549999 | 1.00744 | 0.0175136
2 x V010 | 0.16 | 1.83172 | 0.549999 | 1.00744 | 0.0175136
V012 | 0.16 | 0.861579 | 0.452644 | 0.389989 | 0.0061807
2 x V011 | 0.16 | 1.83172 | 0.549999 | 1.00744 | 0.0175136
