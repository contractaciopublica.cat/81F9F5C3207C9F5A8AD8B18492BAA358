Properties of the parts of a building model (IFC2X3), part 94 of 99

# IfcBuildingElementProxy: Stone - Structural 400, F5
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: F5_; 109.AMB.CodiTipus: F5; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Stone - Structural, Embodied Carbon: 5565.23 (kgCO₂); Stone - Structural, Embodied Energy: 92753.8 MJ
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 10.6827 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 20.1617 m2; Analytic Surface Area of Openings on the Outside Face: 20.1617 m2; Average length of the Wall: 8.43081 m; Surface Area of the Wall Inside Face (Net): 70.2755 m2; Surface Area of the Wall Outside Face (Net): 70.2606 m2; Analytic Volume of the Openings: 8.06468 m3; Length of Reference Line: 8.54481 m; Length of the Wall Inside Face (Conditional): 7.9968 m; Surface Area of the Wall Inside Face (Conditional): 71.8507 m2; Length of the Wall Outside Face (Conditional): 8.86481 m; Surface Area of the Wall Outside Face (Conditional): 71.8359 m2; Surface Area of the Wall Inside Face (Gross): 94.5165 m2; Surface Area of the Wall Outside Face (Gross): 94.5016 m2; End Thickness of the Wall: 0.4 m; Length of the Wall at the Center: 8.43081 m; Length of the Wall on the Inside Face: 7.9968 m; Length of the Wall on the Outside Face: 8.86481 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 3.54593 m2; Height: 10.6827 m; Volume (Net): 28.1072 m3; Width: 0.4 m; Elevation to Project Zero: -0.275747 m; Elevation to 1st Reference Level: -0.275747 m; Elevation to 2nd Reference Level: -0.275747 m; Elevation to Sea Level: 9.06425 m; Elevation to Linked/Home Story: -0.275747 m; Home Offset: -0.275747 m; Top Offset: 0 m; Surface Area: 70.2606 m2; 3D Length: 8.86481 m; Thickness: 0.4 m; Volume (Conditional): 32.0031 m3; Volume (Gross): 37.8036 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 18.0523 m; Top Elevation To First Reference Level: 10.407 m; Top Elevation To Home Story: 10.407 m; Top Elevation To Project Zero: 10.407 m; Top Elevation To Sea Level: 19.747 m; Top Elevation To Second Reference Level: 10.407 m; Bottom Elevation To First Reference Level: -0.275747 m; Bottom Elevation To Home Story: -0.275747 m; Bottom Elevation To Project Zero: -0.275747 m; Bottom Elevation To Sea Level: 9.06425 m; Bottom Elevation To Second Reference Level: -0.275747 m; Top Surface Area (Net): 3.54593 m2; Edge Surface Area (Net): 3.67865 m2; Bottom Surface Area (Net): 70.2606 m2
5 AMB.Geometria - 501.AMB.Longitud: 8.54481 m; 502.AMB.Amplada: 0.4 m; 503.AMB.Altura: 10.6827 m; 504.AMB.Gruix: 0.4 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Mass: 61835.9 kg; Stone - Structural, Projected Component Area (Net): 70.2755 m2; Stone - Structural, Projected Component Area (Gross): 90.4372 m2; Stone - Structural, Component Thickness: 0.4 m; Stone - Structural, Rectangular Component Height: 10.6827 m; Stone - Structural, Rectangular Component Width: 0.4 m; Stone - Structural, Component Cross Section Area: 4.2731 m2; Stone - Structural, Component Volume (Net): 28.1072 m3; Stone - Structural, Component Volume (Gross): 36.1719 m3

# IfcBuildingElementProxy: Stone - Structural 402, SLA - 010
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Reference Plane Location: Top; Element ID: SLA - 010; Hotlink and Element ID: SLA - 010; Layer: 00_PELDAÑOS; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Basic; Parent ID: SLA - 010; Building Materials (All): Stone - Structural; Surfaces (All): Stone - Rock; Cover Fill: Carpet; Number of Openings: 0; Top Surface: Stone - Rock; Edge Surface: Stone - Rock; Bottom Surface: Stone - Rock; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SLA - 010_; 109.AMB.CodiTipus: SLA - 010; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Stone - Structural, Embodied Carbon: 87.4403 (kgCO₂); Stone - Structural, Embodied Energy: 1457.34 MJ
ArchiCADQuantities - Elevation Bottom: 0.00428451 m; Surface Area of the Slab Top (Conditional): 1.09846 m2; Surface Area of the Slab Bottom (Gross): 1.09846 m2; Surface Area of the Slab Bottom (Gross, with holes): 1.09846 m2; Surface Area of the Slab Edges (Gross): 1.75323 m2; Surface Area of the Slab Edges (Gross, with holes): 1.75323 m2; Surface Area of the Slab Top (Gross): 1.09846 m2; Surface Area of the Slab Top (Gross, with holes): 1.09846 m2; Holes Surface Area: 0 m2; Elevation Top: 0.406317 m; Area: 1.09846 m2; Height: 0.402032 m; Volume (Net): 0.441617 m3; Elevation to Project Zero: 0.406317 m; Elevation to 1st Reference Level: 0.406317 m; Elevation to 2nd Reference Level: 0.406317 m; Elevation to Sea Level: 9.74632 m; Elevation to Linked/Home Story: 0.406317 m; Home Offset: 0.406317 m; Surface Area: 1.09846 m2; Thickness: 0.402032 m; Volume (Conditional): 0.441617 m3; Volume (Gross): 0.441617 m3; Floor Plan Perimeter: 4.36092 m; Floor Plan Holes Perimeter: 0 m; Top Elevation To First Reference Level: 0.406317 m; Top Elevation To Home Story: 0.406317 m; Top Elevation To Project Zero: 0.406317 m; Top Elevation To Sea Level: 9.74632 m; Top Elevation To Second Reference Level: 0.406317 m; Bottom Elevation To First Reference Level: 0.00428451 m; Bottom Elevation To Home Story: 0.00428451 m; Bottom Elevation To Project Zero: 0.00428451 m; Bottom Elevation To Sea Level: 9.34428 m; Bottom Elevation To Second Reference Level: 0.00428451 m; Top Surface Area (Net): 1.09846 m2; Top Surface Area (Conditional): 1.09846 m2; Edge Surface Area (Net): 1.75323 m2; Bottom Surface Area (Net): 1.09846 m2; Bottom Surface Area (Conditional): 1.09846 m2; Bottom Surface Area (Gross): 1.09846 m2; Edge Surface Area (Gross): 1.75323 m2; Top Surface Area (Gross): 1.09846 m2
5 AMB.Geometria - 503.AMB.Altura: 0.402032 m; 504.AMB.Gruix: 0.402032 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Mass: 971.558 kg; Stone - Structural, Projected Component Area (Net): 1.09846 m2; Stone - Structural, Projected Component Area (Gross): 1.09846 m2; Stone - Structural, Component Thickness: 0.402032 m; Stone - Structural, Component Volume (Net): 0.441617 m3; Stone - Structural, Component Volume (Gross): 0.441617 m3

# IfcBuildingElementProxy: Stone - Structural 50 (4)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Stone - Wall; Outside Face Surface: Stone - Wall; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: SW - 052; Hotlink and Element ID: SW - 052; Layer: 00_ORNAMENTOS; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Espai públic; Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: SW - 052; Building Materials (All): Stone - Structural; Surfaces (All): Stone - Wall; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Stone - Wall; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SW - 052_; 109.AMB.CodiTipus: SW - 052; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.05 m; 504.AMB.Gruix: 0.05 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.05 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.05 m; Elevation to Project Zero: 1.097 m; Elevation to 1st Reference Level: 1.097 m; Elevation to 2nd Reference Level: 1.097 m; Elevation to Sea Level: 10.437 m; Elevation to Linked/Home Story: 1.097 m; Home Offset: 1.097 m; Top Offset: 0 m; Thickness: 0.05 m; Insulation Skin Thickness: 0 m; Bottom Elevation To First Reference Level: 1.097 m; Bottom Elevation To Home Story: 1.097 m; Bottom Elevation To Project Zero: 1.097 m; Bottom Elevation To Sea Level: 10.437 m; Bottom Elevation To Second Reference Level: 1.097 m
Component Quantities - Stone - Structural, Component Thickness: 0.05 m; Stone - Structural, Rectangular Component Width: 0.05 m
Name | Stone - Structural, Embodied Carbon | Stone - Structural, Embodied Energy (MJ) | 501.AMB.Longitud (m) = Average length of the Wall (m) = Length of Reference Line (m) = Length of the Wall Inside Face (Conditional) (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall at the Center (m) = Length of the Wall on the Inside Face (m) = Length of the Wall on the Outside Face (m) = 3D Length (m) | 503.AMB.Altura (m) = Maximum Height of the Wall (m) = Minimum Height of the Wall (m) = Height (m) = Stone - Structural, Rectangular Component Height (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area of the Wall Inside Face (Gross) (m2) = Surface Area of the Wall Outside Face (Gross) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) = Stone - Structural, Projected Component Area (Net) (m2) = Stone - Structural, Projected Component Area (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Volume (Gross) (m3) = Stone - Structural, Component Volume (Net) (m3) = Stone - Structural, Component Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Stone - Structural, Mass (kg) | Stone - Structural, Component Cross Section Area (m2)
SW - 052 | 122.666 (kgCO₂) | 2044.43 | 7.11648 | 1.7411 | 12.3905 | 0.355824 | 0.619525 | 14.333 | 2.8381 | 12.1781 | 0.885758 | 1362.95 | 0.087055
SW - 052 | 33.1247 (kgCO₂) | 552.078 | 1.92173 | 1.7411 | 3.34593 | 0.0960867 | 0.167296 | 3.94347 | 2.8381 | 12.1781 | 0.366283 | 368.052 | 0.087055
SW - 052 | 114.884 (kgCO₂) | 1914.74 | 8.4112 | 1.37965 | 11.6045 | 0.42056 | 0.580225 | 16.9224 | 2.47665 | 11.8166 | 0.979085 | 1276.49 | 0.0689824
SW - 052 | 19.268 (kgCO₂) | 321.133 | 1.11783 | 1.7411 | 1.94626 | 0.0558917 | 0.0973131 | 2.33567 | 2.8381 | 12.1781 | 0.285893 | 214.089 | 0.087055

# IfcBuildingElementProxy: Stone - Structural 550, F5
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Concrete - Bush hammered; Outside Face Surface: Paint - Stucco Yellow; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F5; Hotlink and Element ID: F5; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Espai públic; Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F5; Building Materials (All): Stone - Structural; Surfaces (All): Brick - Aged Natural; Paint - Stucco Yellow; Concrete - Bush hammered; Slant Angle: 90 deg; ID of Connected Openings: OP - 003; OP - 003; OP - 003; Number of Openings: 3; Edge Surface: Paint - Stucco Yellow; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Properties - Stone - Structural, Embodied Carbon: 8485.33 (kgCO₂); Stone - Structural, Embodied Energy: 141422 MJ
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 7.4168 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 18.4362 m2; Analytic Surface Area of Openings on the Outside Face: 18.4362 m2; Average length of the Wall: 12.7914 m; Surface Area of the Wall Inside Face (Net): 77.9287 m2; Surface Area of the Wall Outside Face (Net): 77.9084 m2; Analytic Volume of the Openings: 10.1399 m3; Length of Reference Line: 12.99 m; Length of the Wall Inside Face (Conditional): 12.5928 m; Surface Area of the Wall Inside Face (Conditional): 77.9287 m2; Length of the Wall Outside Face (Conditional): 12.99 m; Surface Area of the Wall Outside Face (Conditional): 77.9084 m2; Surface Area of the Wall Inside Face (Gross): 96.3649 m2; Surface Area of the Wall Outside Face (Gross): 96.3445 m2; End Thickness of the Wall: 0.55 m; Length of the Wall at the Center: 12.7914 m; Length of the Wall on the Inside Face: 12.5928 m; Length of the Wall on the Outside Face: 12.99 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 7.14528 m2; Height: 7.4168 m; Volume (Net): 42.8552 m3; Width: 0.55 m; Elevation to Project Zero: -0.275747 m; Elevation to 1st Reference Level: -0.275747 m; Elevation to 2nd Reference Level: -0.275747 m; Elevation to Sea Level: 9.06425 m; Elevation to Linked/Home Story: -0.275747 m; Home Offset: -0.275747 m; Top Offset: 0 m; Surface Area: 77.9084 m2; 3D Length: 12.9928 m; Thickness: 0.55 m; Volume (Conditional): 42.8552 m3; Volume (Gross): 52.9951 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 26.8113 m; Top Elevation To First Reference Level: 7.14105 m; Top Elevation To Home Story: 7.14105 m; Top Elevation To Project Zero: 7.14105 m; Top Elevation To Sea Level: 16.481 m; Top Elevation To Second Reference Level: 7.14105 m; Bottom Elevation To First Reference Level: -0.275747 m; Bottom Elevation To Home Story: -0.275747 m; Bottom Elevation To Project Zero: -0.275747 m; Bottom Elevation To Sea Level: 9.06425 m; Bottom Elevation To Second Reference Level: -0.275747 m; Top Surface Area (Net): 7.14528 m2; Edge Surface Area (Net): 18.3698 m2; Bottom Surface Area (Net): 77.9084 m2
5 AMB.Geometria - 501.AMB.Longitud: 12.99 m; 502.AMB.Amplada: 0.55 m; 503.AMB.Altura: 7.4168 m; 504.AMB.Gruix: 0.55 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Mass: 94281.4 kg; Stone - Structural, Projected Component Area (Net): 77.9287 m2; Stone - Structural, Projected Component Area (Gross): 96.3649 m2; Stone - Structural, Component Thickness: 0.55 m; Stone - Structural, Rectangular Component Height: 7.4168 m; Stone - Structural, Rectangular Component Width: 0.55 m; Stone - Structural, Component Cross Section Area: 4.07924 m2; Stone - Structural, Component Volume (Net): 42.8552 m3; Stone - Structural, Component Volume (Gross): 52.9951 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: F5_; 109.AMB.CodiTipus: F5; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Stone - Structural 551 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA); Material: Stone - Structural
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Stone - Wall; Outside Face Surface: Stone - Wall; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: SW - 052; Hotlink and Element ID: SW - 052; Layer: 00_MURS PREEXISTENT; Building Material / Composite / Profile / Fill: Stone - Structural; Building Material: Stone - Structural; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: SW - 052; Building Materials (All): Stone - Structural; Surfaces (All): Stone - Wall; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Stone - Wall; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: SW - 052_; 109.AMB.CodiTipus: SW - 052; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 2.24338 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.551 m; Surface Area of Empty Openings in the Wall: 0 m2; Height: 2.24338 m; Width: 0.551 m; Elevation to Project Zero: -0.958082 m; Elevation to 1st Reference Level: -0.958082 m; Elevation to 2nd Reference Level: -0.958082 m; Elevation to Sea Level: 8.38192 m; Elevation to Linked/Home Story: -0.958082 m; Home Offset: -0.958082 m; Top Offset: 0 m; Thickness: 0.551 m; Insulation Skin Thickness: 0 m; Top Elevation To First Reference Level: 1.2853 m; Top Elevation To Home Story: 1.2853 m; Top Elevation To Project Zero: 1.2853 m; Top Elevation To Sea Level: 10.6253 m; Top Elevation To Second Reference Level: 1.2853 m; Bottom Elevation To First Reference Level: -0.958082 m; Bottom Elevation To Home Story: -0.958082 m; Bottom Elevation To Project Zero: -0.958082 m; Bottom Elevation To Sea Level: 8.38192 m; Bottom Elevation To Second Reference Level: -0.958082 m
5 AMB.Geometria - 502.AMB.Amplada: 0.551 m; 503.AMB.Altura: 2.24338 m; 504.AMB.Gruix: 0.551 m; 506.AMB.Profunditat: 0 m
Component Quantities - Stone - Structural, Component Thickness: 0.551 m; Stone - Structural, Rectangular Component Height: 2.24338 m; Stone - Structural, Rectangular Component Width: 0.551 m; Stone - Structural, Component Cross Section Area: 1.2361 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Name | Stone - Structural, Embodied Carbon | Stone - Structural, Embodied Energy (MJ) | Minimum Height of the Wall (m) | Average length of the Wall (m) = Length of Reference Line (m) = Length of the Wall Inside Face (Conditional) (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall at the Center (m) = Length of the Wall on the Inside Face (m) = Length of the Wall on the Outside Face (m) = 3D Length (m) = 501.AMB.Longitud (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) = Surface Area of the Wall Inside Face (Gross) (m2) = Surface Area of the Wall Outside Face (Gross) (m2) = Stone - Structural, Projected Component Area (Net) (m2) = Stone - Structural, Projected Component Area (Gross) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Stone - Structural, Component Volume (Net) (m3) = Stone - Structural, Component Volume (Gross) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Edge Surface Area (Net) (m2) | Stone - Structural, Mass (kg)
SW - 052 | 841.659 (kgCO₂) | 14027.7 | 2.24338 | 3.43887 | 7.71471 | 7.71471 | 1.89482 | 4.2508 | 4.2508 | 7.97974 | 6.26184 | 9351.77
SW - 052 | 841.36 (kgCO₂) | 14022.7 | 0.978082 | 3.43766 | 7.71199 | 7.71197 | 1.89415 | 4.2493 | 4.24931 | 7.97731 | 6.12277 | 9348.45

# IfcBuildingElementProxy: Storefront Window 27 (3)
In: planta baixa
Classification: 40.10.10 Compartimentació interior vertical (GuBIMclass CA)
AC_Pset_Storefront_Window_27 - Wall Contours (0-None,1-Full,2-Side,3-Length): 0; Hotspots 0-None,1-2D,2-3D,3-All: 3; Show 2D Hotspots in 3D: yes; Floor Plan Display Option: 3; Hole Position Angle: 0 deg; Hole has Wall's Side Surface: yes; Hole Surface's Split is Curved in Curved Walls: no; Wall Type: 1; Wall Direction Type: 2; Reveal Anchor Position: 2; Opening Direction: 0; Demolition / New construction: 1; New Wall Fill Type: Masonry Block; New Wall Fill Pen: General - General; New Wall Fill Background Pen: Backgrounds - color 1; Show new construction on Wall: no; Demolition line type: 4; Show Demolition/New parameter: no; Show Editable Hotspots: yes; Show Reveal on Symbol: 1; 2D Detail Level: 1; 3D Detail Level: 8; Unit Size: Custom Size; Nominal Size: 0; Set Wallhole Size as Nominal Size: yes; Set Reveal Size as Nominal Size: no; Set Unit Size as Nominal Size: no; Transfer Current Nominal Size to Selection: no; End Frame Profile on Left (endFrameLeft): Normal; End Frame Profile on Left (iEndFrameLeft): 1; Joint Left: no; Left Angle: 90 deg; End Frame Profile on Right (endFrameRight): Normal; End Frame Profile on Right (iEndFrameRight): 1; Joint Right: no; Right Angle: 90 deg; Joint Lower: no; Joint Upper: no; Frame Style on Left Side: Visible Mullions; Frame Style on Right Side: Visible Mullions; Frame Thickness=Wall Thickness: no; Upper Transom: no; Middle Rail (bMiddleRail): no; Side Panel 1: no; Side Panel 2: no; Panel Division Type (divisionMethod): Number of Divisions; Panel Division Type (iDivisionMethod): 1; Horizontal Div. Number: 1; Horizontal Mullion Number: 0; Bottom Vert. Div. Number: 2; Bottom Vert. Mull. Number: 0; Middle Vert. Div. Number: 1; Middle Vert. Mull. Number: 0; Top Vert. Div. Number: 2; Top Vert. Mull. Number: 0; Frame Style on Mullion: Butt Glazed; Grid Depth=Frame Depth: no; Glass Setback=1/2 Mullion Depth: no; Natural Ventilation: no; Natural Ventilation Type: 2; Reveal Type (gs_reveal_type_new): No Reveal; Reveal Type (gs_reveal_type_int): 2; Bottom Reveal Type (gs_reveal_type_bottom): Uniform; Bottom Reveal Type (gs_reveal_type_bottom_int): 1; Outer Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleOuterTypeInt): 0; Inner Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleInnerTypeInt): 0; Uniform Jamb Depth: yes; Angle Side 2: 20 deg; Angle Side: 20 deg; Upper Side Angle: 20 deg; Bottom Side Angle: 20 deg; Use Wall Finish Component: no; Auto Turn Inside Face Plaster: yes; Turn Inside Face Plaster: 0; Auto Turn Outside Face Plaster: yes; Turn Outside Face Plaster: 0; Dimensionable on 2D: no; Show in 3D: no; Closure Type (gs_closure_type): No Closure; Closure Type (gs_closure_type_int): 1; Turn Skin on Side (gs_cavity_side): Both; Turn Skin on Side (iCavityClosureSide): 1; Number of Skins to Turn: 1; Number from (gs_nTurnDir): Outside Face; Number from (iCavityClosureTurnDir): 1; Place Closer on Side 2: yes; Place Closer on Side 1: yes; Place Closer on Top: no; Place Closer on Bottom: no; Place Closer to Skin: 1; Place Closer from Side (gs_cc_dutch_ClosureToSide): 1; Gap at Outside Skin: yes; Turn Skin to Closer: no; Insert Insulation Strip: yes; Show Insulation Strip: yes; Contour Pen (gs_penJoint): Openings - Cut Non-Structural; Contour Line Type (gs_ltJoint): 1; Fill Type (gs_fillJoint): Rigid Insulation; Fill Pen (gs_penJointFg): General - General; Fill Background Pen (gs_penJointBg): 2D Elements - Drafting; Custom Surface: no; Surface: Wood - Pine Grained Horizontal; Contour Pen (gs_penPlug): Openings - Cut Non-Structural; Contour Line Type (gs_ltPlug): 1; Fill Type (gs_fillPlug): Rigid Insulation; Fill Pen (gs_penPlugFg): General - General; Fill Background Pen (gs_penPlugBg): 2D Elements - Drafting; Edited Jamb Side: 1; Edited Wall Side: 1; Edited Skin Number: 1; Turn-in Skin: no; Consider Skin as Plaster: no; Turn-in Thickness: 1; Hatch Orientation: 1; Separating Line at Turn-in: no; Separating Line Pen: General - General; Last Selected Side: no; Closure Method Changed Automatically: no; Frame Pen (gs_pen_2D): Openings - Cut Structural; Grid Pen: Openings - Cut Non-Structural; Glass Pen (gs_pen_glass): Openings - Cut Non-Structural; Wall Contour Line (gs_wcont_line): Both Sides; Wall Contour Line (iWallContourLine): 4; Wall Contour Line Type Inside: 1; Wall Contour Line Type Outside: 1; Hidden Wall Contour Line Type Inside: 4; Hidden Wall Contour Line Type Outside: 4; Wall Contour Line Pen: Openings - General; Use Fills: yes; Uncut Fill Type: Background; Uncut Fill Pen: Backgrounds - color 1; Uncut Fill Background Pen: Backgrounds - color 1; Frame Fill Type: Aluminium; Frame Fill Pen: Openings - Cut Fills; Frame Fill Background Pen: Backgrounds - color 1; Glass Section Fill Type: Background; Glass Section Fill Pen: Backgrounds - color 1; Glass Section Fill Background Pen: Backgrounds - color 1; Plan Symbol Fill Type: Background; Plan Symbol Fill Pen: Backgrounds - color 1; Plan Symbol Fill Background Pen: Backgrounds - color 1; Ventilation Section Fill Type: Air Space; Ventilation Section Fill Pen: Backgrounds - color 1; Ventilation Section Fill Background Pen: Backgrounds - color 1; Frame Element Joinery: 2; Frame Pen (gs_frame_pen): Openings - General; Leaf Pen: Openings - General; Glass Pen (gs_glass_pen): Openings - General; Uniform Window Surfaces: yes; Frame (gs_frame_mat): Wood - Pine Grained Horizontal; Middle Rail (gs_midrail_mat): Wood - Pine Grained Horizontal; Horizontal Mullion: Wood - Pine Grained Horizontal; Vertical Mullion: Wood - Pine Grained Horizontal; Glass: Glass - Clear Fast; Ventilation Profile: Metal - Aluminium; Head Depth on Symbol: no; Head Depth Symbol Line Type: 21; Head Depth Symbol Pen: Annotation Text - General; Window belongs to the Zone into which it opens: no; Cost: 0; Total Glazed Area (gs_list_glassarea_tmp): 0; Override Glazed Area: no; Total Glass Perimeter: 0; Self-Closing: no; Self-Closing Index: 2; Free Air Performance (mm2/l/m): 0; Group Type (FM_Type): Default Objects; Group Type (iFMType): 1; Serial No.: Off; Object Weight: 0; Object Weight Unit: kg; Window Orientation Definition: 1; IFC Operation (ifc_optypestr): Single; IFC Operation (ifc_optype): 1; Zone Number Inside Value: Custom; Zone Number Outside Value: Custom
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 40.10.10 Compartimentació interior vertical; 104.AMB.ClassificacioCodi: 40.10.10; 105.AMB.ClassificacioDescripcio: Compartimentació interior vertical; 107.AMB.NomTipus: T2_PortaIntTipusA; 109.AMB.CodiTipus: T2; 111.AMB.DescripcioTipus: Porta de pi amb fulla de 72.5cm; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0; Status: NEW
ArchiCADProperties - Wall Structure: Insulation; Opening Library Part Name: Storefront Window 27; Opening Side Fill Index: Background; Element ID: T2; Hotlink and Element ID: T2; Layer: 00_TABIQUE; Library Part Name: Storefront Window 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Window; Parent ID: T1; Surfaces (All): Wood - Pine Grained Horizontal; Glass - Clear Fast; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40; AUX_107.NomTipus: PortaIntTipusA
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
ArchiCADQuantities - W/D Opening Height on the Reveal Side: 2.6 m; W/D Opening Height on the Side Opposite to the Reveal Side: 2.6 m; Nominal W/D Opening Height on the Reveal Side: 2.6 m; Nominal W/D Opening Height on the Side Opposite to the Reveal Side: 2.6 m; Sill/Header Value: 0.27 m; W/D Nominal Sill Height: 0.27 m; W/D Sill Height on the Reveal Side: 0 m; W/D Sill Height on the Side Opposite to the Reveal Side: 0 m; W/D Nominal Head Height: 2.87 m; W/D Head Height on the Reveal Side: 2.5 m; W/D Head Height on the Side Opposite to the Reveal Side: 2.5 m; Wall Thickness: 0.08 m; Frame Thickness: 0.05 m; Height: 2.6 m; Elevation to Project Zero: 0.27 m; Elevation to 1st Reference Level: 0.27 m; Elevation to 2nd Reference Level: 0.27 m; Elevation to Sea Level: 9.61 m; Elevation to Linked/Home Story: 0.27 m; Home Offset: 0.27 m; Top Elevation To First Reference Level: 2.87 m; Top Elevation To Home Story: 2.87 m; Top Elevation To Project Zero: 2.87 m; Top Elevation To Sea Level: 12.21 m; Top Elevation To Second Reference Level: 2.87 m; Bottom Elevation To First Reference Level: 0.27 m; Bottom Elevation To Home Story: 0.27 m; Bottom Elevation To Project Zero: 0.27 m; Bottom Elevation To Sea Level: 9.61 m; Bottom Elevation To Second Reference Level: 0.27 m
5 AMB.Geometria - 503.AMB.Altura: 2.6 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Storefront_Window_27 - Height: 2.6 m; Z Dimension: 1 m; Bottom Level: 1 m; Top Level: 0 m; Sill Height to Current Story: 0.27 m; Reveal to Wall Core: 0.015 m; New Wall Fill Width Right: 0.15 m; New Wall Fill Width Left: 0.15 m; Tolerance: 0 m; Tolerance Left: 0 m; Tolerance Right: 0 m; Tolerance Upper: 0 m; Tolerance Lower: 0 m; Wallhole Height: 2.6 m; Reveal Height: 2.6 m; Unit Height: 2.6 m; Frame Thickness: 0.05 m; Frame Width: 0.15 m; Middle Rail Width: 0.15 m; Bottom Rail Width: 0.15 m; Frame W. on Left Side: 0.15 m; Frame W. on Right Side: 0.15 m; Frame Width Lower: 0.15 m; Frame Width Upper: 0.15 m; Transom Height (transomHeight): 0 m; Middle Rail Elevation: 0 m; Side Panel Width 1: 0 m; Side Panel Width 2: 0 m; Horizontal Div. Width (0=No): 0.3 m; Bottom Vert. Div. Width (0=No): 0.3 m; Middle Vert. Div. Width (0=No): 0.3 m; Top Vert. Div. Width (0=No): 0.3 m; Transom Height (middlePanelHeight): 0 m; Horizontal Mullion Width: 0.04 m; Horizontal Mullion Thickness: -0.05 m; Vertical Mullion Width: 0.04 m; Vertical Mullion Thickness: -0.05 m; Sash Frame Thickness: 0.0500063 m; Sash Frame Width: 0.05 m; Glass Thickness: 0.02 m; Glass Setback: 0.025 m; Butt Glazed Joint: 0.01 m; Left Opening Oversize: 0 m; Right Opening Oversize: 0 m; Upper Opening Oversize: 0 m; Lower Opening Oversize: 0 m; Profile Height: 0.065 m; Profile Thickness: 0.11 m; Reveal Depth (gs_wido_sill): 0.015 m; Reveal Depth (AC_wido_sill): 0.015 m; Jamb Depth Side 2: 0.06 m; Jamb Depth: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_splayed_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_splayed_innerRight): 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_double_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_double_innerRight): 0.06 m; Head Jamb Depth: 0.06 m; Sill Jamb Depth: 0.06 m; Inner Head Depth (gs_reveal_splayed_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_splayed_innerBottom): 0.06 m; Inner Head Depth (gs_reveal_double_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_double_innerBottom): 0.06 m; Outer Jamb Depth: 0.08 m; Plaster Thickness Limit: 0.04 m; Distance of Skin from Closer: 0 m; Closer Width: 0.038 m; Closer Thickness: 0.1 m; Strip Thickness: 0.025 m; Profile Width: 0.075 m; Custom Thickness: 0.015 m; Skin Overhang to Frame Depth: 0 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Name | Total Glazed Area (gs_list_glassarea) | Reveal Dimensions = Wallhole Dimensions = Unit Dimensions = Nominal W x H Size | Nominal W x H x T Size | W/D Opening Opening Volume (m3) = W/D Opening Nominal Volume (m3) | W/D Opening Surface Area (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | W/D Opening Nominal Surface Area (m2) = W/D Opening Surface Area on the Reveal Side (m2) = W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | W/D Opening Width on the Reveal Side (m) = W/D Opening Width on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Width on the Reveal Side (m) = Nominal W/D Opening Width on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Width (m) = 502.AMB.Amplada (m) = AC_Equantity_Storefront_Window_27, Width (m) = Wallhole Width (m) = Reveal Width (m) = Unit Width (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3)
T2 | 1.3271 | 877,0×2.600,0 | 877,0×2.600,0×80,0 | 0.182416 | 5.37088 | 2.2802 | 0.877 | 0.074197
2 x T2 | 1.32036 | 874,1×2.600,0 | 874,1×2.600,0×80,0 | 0.181806 | 5.35493 | 2.27258 | 0.874068 | 0.0740182

# IfcBuildingElementProxy: TEJA 179 x 60 (325)
In: planta baixa
Material: Fiberboard
ArchiCADProperties - Beam Cross Section: Profiled; End Surface: Roof Tiles - Dutch; Extrusion Surface: Roof Tiles - Dutch; Layer: 00_TEJAS; Building Material / Composite / Profile / Fill: TEJA; Complex Profile: TEJA; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Beam; Structure Type: Complex Profile; Profile Category: TEJA; Building Materials (All): Fiberboard; Surfaces (All): Roof Tiles - Dutch; Cover Fill: Background; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 115.AMB.Nivell: planta baixa
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30
Component Properties - Fiberboard, Component Type: Core
ArchiCADQuantities - Hole Number: 0; Holes Edge Surface Area: 0 m2; Holes Surface Area: 0 m2; Holes Volume: 0 m3; Surface Area of the Beam Left Side (Net): 0 m2; Offset: 0 m; Surface Area of the Beam Right Side (Net): 0 m2; Height: 0.0602756 m; Width: 0.179 m; Cross Section Height at Top/End (perpendicular): 0.0602756 m; Cross Section Height at Bottom/Start (perpendicular): 0.0602756 m; Cross Section Width at Top/End (perpendicular): 0.179 m; Cross Section Width at Bottom/Start (perpendicular): 0.179 m; Cross Section Width at Top/End (cut): 0.179 m; Cross Section Width at Bottom/Start (cut): 0.179 m; Number of Segments: 1
5 AMB.Geometria - 502.AMB.Amplada: 0.179 m; 503.AMB.Altura: 0.0602756 m; 506.AMB.Profunditat: 0 m
Component Quantities - Fiberboard, Component Cross Section Area: 0.00387202 m2
Name | Classification | Beam Slant Angle (deg) = Slant Angle (deg) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Renovation Status | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | AUX_107.NomTipus | Status | Fiberboard, Embodied Carbon | Fiberboard, Embodied Energy (MJ) | Surface Area of Both Beam Ends (m2) | Length Left (m) = Length Right (m) | Area (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Volume (Gross) (m3) = Fiberboard, Component Volume (Net) (m3) = Fiberboard, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Top Elevation To Sea Level (m) | Surface Area (m2) | 3D Length (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Cross Section Height at Top/End (cut) (m) | Cross Section Height at Bottom/Start (cut) (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) | Fiberboard, Mass (kg)
95 x Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 19.1228 (kgCO₂) | 286.842 | 0.00794075 | 6.75625 | 1.17137 | 0.0259821 | 6.40825 | 15.7483 | 2.96137 | 6.77151 | 4.66667 | 14.0067 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.41084 | 1.54259 | 20.7857
91 x Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 19.1228 (kgCO₂) | 286.842 | 0.00794075 | 6.75625 | 1.17137 | 0.0259821 | 6.40771 | 15.7477 | 2.96137 | 6.77151 | 4.66613 | 14.0061 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.41084 | 1.54259 | 20.7857
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55277 | 13.8928 | 0.554409 | 1.26 | 4.10696 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55277 | 13.8928 | 0.554409 | 1.26 | 4.10697 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55278 | 13.8928 | 0.554409 | 1.26 | 4.10697 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55278 | 13.8928 | 0.554409 | 1.26 | 4.10698 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55279 | 13.8928 | 0.554409 | 1.26 | 4.10698 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55279 | 13.8928 | 0.554409 | 1.26 | 4.10699 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.5528 | 13.8928 | 0.554409 | 1.26 | 4.10699 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55281 | 13.8928 | 0.554409 | 1.26 | 4.107 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.5528 | 13.8928 | 0.554409 | 1.26 | 4.107 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55276 | 13.8928 | 0.554409 | 1.26 | 4.10695 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55276 | 13.8928 | 0.554409 | 1.26 | 4.10696 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55277 | 13.8928 | 0.554409 | 1.26 | 4.10696 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55277 | 13.8928 | 0.554409 | 1.26 | 4.10697 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55278 | 13.8928 | 0.554409 | 1.26 | 4.10697 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55278 | 13.8928 | 0.554409 | 1.26 | 4.10698 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55279 | 13.8928 | 0.554409 | 1.26 | 4.10698 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55279 | 13.8928 | 0.554409 | 1.26 | 4.10699 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.5528 | 13.8928 | 0.554409 | 1.26 | 4.10699 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.5528 | 13.8928 | 0.554409 | 1.26 | 4.107 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55281 | 13.8928 | 0.554409 | 1.26 | 4.107 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55276 | 13.8928 | 0.554409 | 1.26 | 4.10696 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | -17.9958 | Cu1 | New | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_ | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra |  | NEW | 3.53609 (kgCO₂) | 53.0413 | 0.00788909 | 1.26 | 0.213321 | 0.00480447 | 4.55276 | 13.8928 | 0.554409 | 1.26 | 4.10695 | 13.447 | 0.0602756 | 0.063376 | 0.00404345 | 0.00384564 | 0.26171 | 0.28481 | 3.84357 | ArchiCADProperties - Colliding Zones: Espai públic; Nau Santa Eulàlia
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 13.2717 (kgCO₂) | 199.076 | 0.00794075 | 4.689 | 0.812962 | 0.0180322 | 6.40825 | 15.7483 | 2.05769 | 4.70426 | 5.18078 | 14.5208 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 0.979156 | 1.0706 | 14.4258
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 14.0101 (kgCO₂) | 210.152 | 0.00794075 | 4.94988 | 0.858193 | 0.0190355 | 6.40825 | 15.7483 | 2.17174 | 4.96515 | 5.1159 | 14.4559 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.03363 | 1.13016 | 15.2284
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 14.7485 (kgCO₂) | 221.228 | 0.00794075 | 5.21077 | 0.903424 | 0.0200387 | 6.40825 | 15.7483 | 2.28578 | 5.22603 | 5.05102 | 14.391 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.08811 | 1.18973 | 16.031
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 15.4869 (kgCO₂) | 232.304 | 0.00794075 | 5.47165 | 0.948655 | 0.021042 | 6.40825 | 15.7483 | 2.39982 | 5.48691 | 4.98614 | 14.3261 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.14259 | 1.24929 | 16.8336
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 16.2253 (kgCO₂) | 243.38 | 0.00794075 | 5.73253 | 0.993886 | 0.0220452 | 6.40825 | 15.7483 | 2.51386 | 5.74779 | 4.92126 | 14.2613 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.19707 | 1.30886 | 17.6362
Cu1 | 30.20.10 Cobertes (GuBIMclass CA) | -14.4 | Cu1 | New | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu1_BMR - 004 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | BMR - 004 | NEW | 15.1253 (kgCO₂) | 226.88 | 0.00794075 | 5.3439 | 0.926506 | 0.0205507 | 6.40825 | 15.7483 | 2.34398 | 5.35916 | 5.01791 | 14.3579 | 0.0622307 | 0.0622307 | 0.00397038 | 0.00397038 | 1.11591 | 1.22012 | 16.4406
