Properties of the parts of a building model (IFC2X3), part 72 of 99

# IfcBuildingElementProxy: Rhino_Object_1824, Object_1824
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1824_; 109.AMB.CodiTipus: Object_1824; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426557 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1824 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1825, Object_1825
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1825; Hotlink and Element ID: Object_1825; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1825; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1825; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1825 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1825_; 109.AMB.CodiTipus: Object_1825; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1825 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1826, Object_1826
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1826 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1826; Hotlink and Element ID: Object_1826; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1826; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1826; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1826_; 109.AMB.CodiTipus: Object_1826; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
AC_Equantity_Rhino_Object_1826 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m

# IfcBuildingElementProxy: Rhino_Object_1827, Object_1827
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1827; Hotlink and Element ID: Object_1827; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1827; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1827; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1827 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1827 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1827_; 109.AMB.CodiTipus: Object_1827; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Rhino_Object_1828, Object_1828
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1828; Hotlink and Element ID: Object_1828; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1828; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1828; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1828 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1828 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1828_; 109.AMB.CodiTipus: Object_1828; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1829, Object_1829
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1829; Hotlink and Element ID: Object_1829; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1829; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1829; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1829 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1829_; 109.AMB.CodiTipus: Object_1829; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1829 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1830, Object_1830
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1830; Hotlink and Element ID: Object_1830; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1830; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1830; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1830 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1830_; 109.AMB.CodiTipus: Object_1830; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3
AC_Equantity_Rhino_Object_1830 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m

# IfcBuildingElementProxy: Rhino_Object_1831, Object_1831
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1831; Hotlink and Element ID: Object_1831; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1831; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1831; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1831 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1831_; 109.AMB.CodiTipus: Object_1831; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1831 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1832, Object_1832
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1832 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1832_; 109.AMB.CodiTipus: Object_1832; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1832 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1832; Hotlink and Element ID: Object_1832; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1832; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1832; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3

# IfcBuildingElementProxy: Rhino_Object_1833, Object_1833
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1833; Hotlink and Element ID: Object_1833; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1833; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1833; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1833 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1833_; 109.AMB.CodiTipus: Object_1833; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1833 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1834, Object_1834
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1834; Hotlink and Element ID: Object_1834; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1834; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1834; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1834 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1834_; 109.AMB.CodiTipus: Object_1834; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1834 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3

# IfcBuildingElementProxy: Rhino_Object_1835, Object_1835
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1835; Hotlink and Element ID: Object_1835; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1835; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1835; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1835 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1835_; 109.AMB.CodiTipus: Object_1835; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1835 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1836, Object_1836
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1836; Hotlink and Element ID: Object_1836; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1836; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1836; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1836 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1836_; 109.AMB.CodiTipus: Object_1836; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.471808 m; Area: 0.0607874 m2; Height: 0.177265 m; Volume (Net): 0.00447878 m3; Width: 0.128839 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.218326 m2; Top Elevation To First Reference Level: 4.42952 m; Top Elevation To Home Story: 4.42952 m; Top Elevation To Project Zero: 4.42952 m; Top Elevation To Sea Level: 13.7695 m; Top Elevation To Second Reference Level: 4.42952 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0607874 m2; Bottom Surface Area (Net): 0.218326 m2
AC_Equantity_Rhino_Object_1836 - Dimension 1: 0.471808 m; Dimension 2: 0.128839 m; Height: 0.177265 m; Bottom Level: -1.51701e-11 m; Top Level: 0.177265 m
5 AMB.Geometria - 502.AMB.Amplada: 0.128839 m; 503.AMB.Altura: 0.177265 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00447878 m3; Component, Component Volume (Gross): 0.00447878 m3

# IfcBuildingElementProxy: Rhino_Object_1837, Object_1837
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1837; Hotlink and Element ID: Object_1837; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1837; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1837; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1837 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1837_; 109.AMB.CodiTipus: Object_1837; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1837 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1838, Object_1838
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1838; Hotlink and Element ID: Object_1838; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1838; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1838; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1838 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1838 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1838_; 109.AMB.CodiTipus: Object_1838; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3

# IfcBuildingElementProxy: Rhino_Object_1839, Object_1839
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1839 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1839; Hotlink and Element ID: Object_1839; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1839; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1839; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
