Properties of the parts of a building model (IFC2X3), part 41 of 99

# IfcBuildingElementProxy: Rhino_Object_136, Object_136
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_136_; 109.AMB.CodiTipus: Object_136; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_136 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_1360, Object_1360
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1360; Hotlink and Element ID: Object_1360; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1360; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1360; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1360 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1360_; 109.AMB.CodiTipus: Object_1360; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1360 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23005 m; Elevation to 1st Reference Level: 1.23005 m; Elevation to 2nd Reference Level: 1.23005 m; Elevation to Sea Level: 10.5701 m; Elevation to Linked/Home Story: 1.23005 m; Home Offset: 1.23005 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35014 m; Top Elevation To Home Story: 1.35014 m; Top Elevation To Project Zero: 1.35014 m; Top Elevation To Sea Level: 10.6901 m; Top Elevation To Second Reference Level: 1.35014 m; Bottom Elevation To First Reference Level: 1.23005 m; Bottom Elevation To Home Story: 1.23005 m; Bottom Elevation To Project Zero: 1.23005 m; Bottom Elevation To Sea Level: 10.5701 m; Bottom Elevation To Second Reference Level: 1.23005 m; Survey Coordinate X: 426556 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 10.5701 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1361, Object_1361
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1361; Hotlink and Element ID: Object_1361; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1361; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1361; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1361 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1361_; 109.AMB.CodiTipus: Object_1361; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23013 m; Elevation to 1st Reference Level: 1.23013 m; Elevation to 2nd Reference Level: 1.23013 m; Elevation to Sea Level: 10.5701 m; Elevation to Linked/Home Story: 1.23013 m; Home Offset: 1.23013 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35021 m; Top Elevation To Home Story: 1.35021 m; Top Elevation To Project Zero: 1.35021 m; Top Elevation To Sea Level: 10.6902 m; Top Elevation To Second Reference Level: 1.35021 m; Bottom Elevation To First Reference Level: 1.23013 m; Bottom Elevation To Home Story: 1.23013 m; Bottom Elevation To Project Zero: 1.23013 m; Bottom Elevation To Sea Level: 10.5701 m; Bottom Elevation To Second Reference Level: 1.23013 m; Survey Coordinate X: 426556 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 10.5701 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1361 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1362, Object_1362
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1362 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1362; Hotlink and Element ID: Object_1362; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1362; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1362; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1362_; 109.AMB.CodiTipus: Object_1362; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23021 m; Elevation to 1st Reference Level: 1.23021 m; Elevation to 2nd Reference Level: 1.23021 m; Elevation to Sea Level: 10.5702 m; Elevation to Linked/Home Story: 1.23021 m; Home Offset: 1.23021 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35029 m; Top Elevation To Home Story: 1.35029 m; Top Elevation To Project Zero: 1.35029 m; Top Elevation To Sea Level: 10.6903 m; Top Elevation To Second Reference Level: 1.35029 m; Bottom Elevation To First Reference Level: 1.23021 m; Bottom Elevation To Home Story: 1.23021 m; Bottom Elevation To Project Zero: 1.23021 m; Bottom Elevation To Sea Level: 10.5702 m; Bottom Elevation To Second Reference Level: 1.23021 m; Survey Coordinate X: 426556 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 10.5702 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1362 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1363, Object_1363
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1363; Hotlink and Element ID: Object_1363; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1363; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1363; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1363 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1363_; 109.AMB.CodiTipus: Object_1363; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23029 m; Elevation to 1st Reference Level: 1.23029 m; Elevation to 2nd Reference Level: 1.23029 m; Elevation to Sea Level: 10.5703 m; Elevation to Linked/Home Story: 1.23029 m; Home Offset: 1.23029 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35037 m; Top Elevation To Home Story: 1.35037 m; Top Elevation To Project Zero: 1.35037 m; Top Elevation To Sea Level: 10.6904 m; Top Elevation To Second Reference Level: 1.35037 m; Bottom Elevation To First Reference Level: 1.23029 m; Bottom Elevation To Home Story: 1.23029 m; Bottom Elevation To Project Zero: 1.23029 m; Bottom Elevation To Sea Level: 10.5703 m; Bottom Elevation To Second Reference Level: 1.23029 m; Survey Coordinate X: 426555 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 10.5703 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1363 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1364, Object_1364
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1364 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1364_; 109.AMB.CodiTipus: Object_1364; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23037 m; Elevation to 1st Reference Level: 1.23037 m; Elevation to 2nd Reference Level: 1.23037 m; Elevation to Sea Level: 10.5704 m; Elevation to Linked/Home Story: 1.23037 m; Home Offset: 1.23037 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35045 m; Top Elevation To Home Story: 1.35045 m; Top Elevation To Project Zero: 1.35045 m; Top Elevation To Sea Level: 10.6905 m; Top Elevation To Second Reference Level: 1.35045 m; Bottom Elevation To First Reference Level: 1.23037 m; Bottom Elevation To Home Story: 1.23037 m; Bottom Elevation To Project Zero: 1.23037 m; Bottom Elevation To Sea Level: 10.5704 m; Bottom Elevation To Second Reference Level: 1.23037 m; Survey Coordinate X: 426555 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 10.5704 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1364 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1364; Hotlink and Element ID: Object_1364; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1364; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1364; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1365, Object_1365
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1365 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1365; Hotlink and Element ID: Object_1365; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1365; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1365; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23045 m; Elevation to 1st Reference Level: 1.23045 m; Elevation to 2nd Reference Level: 1.23045 m; Elevation to Sea Level: 10.5704 m; Elevation to Linked/Home Story: 1.23045 m; Home Offset: 1.23045 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35053 m; Top Elevation To Home Story: 1.35053 m; Top Elevation To Project Zero: 1.35053 m; Top Elevation To Sea Level: 10.6905 m; Top Elevation To Second Reference Level: 1.35053 m; Bottom Elevation To First Reference Level: 1.23045 m; Bottom Elevation To Home Story: 1.23045 m; Bottom Elevation To Project Zero: 1.23045 m; Bottom Elevation To Sea Level: 10.5704 m; Bottom Elevation To Second Reference Level: 1.23045 m; Survey Coordinate X: 426555 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 10.5704 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1365 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1365_; 109.AMB.CodiTipus: Object_1365; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1366, Object_1366
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1366; Hotlink and Element ID: Object_1366; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1366; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1366; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1366 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1366_; 109.AMB.CodiTipus: Object_1366; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.22895 m; Elevation to 1st Reference Level: 1.22895 m; Elevation to 2nd Reference Level: 1.22895 m; Elevation to Sea Level: 10.569 m; Elevation to Linked/Home Story: 1.22895 m; Home Offset: 1.22895 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.34903 m; Top Elevation To Home Story: 1.34903 m; Top Elevation To Project Zero: 1.34903 m; Top Elevation To Sea Level: 10.689 m; Top Elevation To Second Reference Level: 1.34903 m; Bottom Elevation To First Reference Level: 1.22895 m; Bottom Elevation To Home Story: 1.22895 m; Bottom Elevation To Project Zero: 1.22895 m; Bottom Elevation To Sea Level: 10.569 m; Bottom Elevation To Second Reference Level: 1.22895 m; Survey Coordinate X: 426559 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 10.569 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1366 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1367, Object_1367
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1367; Hotlink and Element ID: Object_1367; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1367; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1367; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1367 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1367_; 109.AMB.CodiTipus: Object_1367; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1367 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.22903 m; Elevation to 1st Reference Level: 1.22903 m; Elevation to 2nd Reference Level: 1.22903 m; Elevation to Sea Level: 10.569 m; Elevation to Linked/Home Story: 1.22903 m; Home Offset: 1.22903 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.34911 m; Top Elevation To Home Story: 1.34911 m; Top Elevation To Project Zero: 1.34911 m; Top Elevation To Sea Level: 10.6891 m; Top Elevation To Second Reference Level: 1.34911 m; Bottom Elevation To First Reference Level: 1.22903 m; Bottom Elevation To Home Story: 1.22903 m; Bottom Elevation To Project Zero: 1.22903 m; Bottom Elevation To Sea Level: 10.569 m; Bottom Elevation To Second Reference Level: 1.22903 m; Survey Coordinate X: 426558 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 10.569 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1368, Object_1368
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1368; Hotlink and Element ID: Object_1368; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1368; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1368; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1368 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1368_; 109.AMB.CodiTipus: Object_1368; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.22911 m; Elevation to 1st Reference Level: 1.22911 m; Elevation to 2nd Reference Level: 1.22911 m; Elevation to Sea Level: 10.5691 m; Elevation to Linked/Home Story: 1.22911 m; Home Offset: 1.22911 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.34919 m; Top Elevation To Home Story: 1.34919 m; Top Elevation To Project Zero: 1.34919 m; Top Elevation To Sea Level: 10.6892 m; Top Elevation To Second Reference Level: 1.34919 m; Bottom Elevation To First Reference Level: 1.22911 m; Bottom Elevation To Home Story: 1.22911 m; Bottom Elevation To Project Zero: 1.22911 m; Bottom Elevation To Sea Level: 10.5691 m; Bottom Elevation To Second Reference Level: 1.22911 m; Survey Coordinate X: 426558 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 10.5691 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1368 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1369, Object_1369
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1369 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1369; Hotlink and Element ID: Object_1369; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1369; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1369; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.22919 m; Elevation to 1st Reference Level: 1.22919 m; Elevation to 2nd Reference Level: 1.22919 m; Elevation to Sea Level: 10.5692 m; Elevation to Linked/Home Story: 1.22919 m; Home Offset: 1.22919 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.34927 m; Top Elevation To Home Story: 1.34927 m; Top Elevation To Project Zero: 1.34927 m; Top Elevation To Sea Level: 10.6893 m; Top Elevation To Second Reference Level: 1.34927 m; Bottom Elevation To First Reference Level: 1.22919 m; Bottom Elevation To Home Story: 1.22919 m; Bottom Elevation To Project Zero: 1.22919 m; Bottom Elevation To Sea Level: 10.5692 m; Bottom Elevation To Second Reference Level: 1.22919 m; Survey Coordinate X: 426558 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 10.5692 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1369 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1369_; 109.AMB.CodiTipus: Object_1369; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_137, Object_137
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_137; Hotlink and Element ID: Object_137; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_137; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_137; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_137 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_137 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_137_; 109.AMB.CodiTipus: Object_137; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1370, Object_1370
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1370; Hotlink and Element ID: Object_1370; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1370; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1370; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1370 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1370_; 109.AMB.CodiTipus: Object_1370; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.22927 m; Elevation to 1st Reference Level: 1.22927 m; Elevation to 2nd Reference Level: 1.22927 m; Elevation to Sea Level: 10.5693 m; Elevation to Linked/Home Story: 1.22927 m; Home Offset: 1.22927 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.34935 m; Top Elevation To Home Story: 1.34935 m; Top Elevation To Project Zero: 1.34935 m; Top Elevation To Sea Level: 10.6893 m; Top Elevation To Second Reference Level: 1.34935 m; Bottom Elevation To First Reference Level: 1.22927 m; Bottom Elevation To Home Story: 1.22927 m; Bottom Elevation To Project Zero: 1.22927 m; Bottom Elevation To Sea Level: 10.5693 m; Bottom Elevation To Second Reference Level: 1.22927 m; Survey Coordinate X: 426558 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 10.5693 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
AC_Equantity_Rhino_Object_1370 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m

# IfcBuildingElementProxy: Rhino_Object_1371, Object_1371
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1371; Hotlink and Element ID: Object_1371; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1371; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1371; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1371 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1371_; 109.AMB.CodiTipus: Object_1371; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1371 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.22966 m; Elevation to 1st Reference Level: 1.22966 m; Elevation to 2nd Reference Level: 1.22966 m; Elevation to Sea Level: 10.5697 m; Elevation to Linked/Home Story: 1.22966 m; Home Offset: 1.22966 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.34974 m; Top Elevation To Home Story: 1.34974 m; Top Elevation To Project Zero: 1.34974 m; Top Elevation To Sea Level: 10.6897 m; Top Elevation To Second Reference Level: 1.34974 m; Bottom Elevation To First Reference Level: 1.22966 m; Bottom Elevation To Home Story: 1.22966 m; Bottom Elevation To Project Zero: 1.22966 m; Bottom Elevation To Sea Level: 10.5697 m; Bottom Elevation To Second Reference Level: 1.22966 m; Survey Coordinate X: 426557 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 10.5697 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2

# IfcBuildingElementProxy: Rhino_Object_1374 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1374; Hotlink and Element ID: Object_1374; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1374; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1374; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1374 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1374_; 109.AMB.CodiTipus: Object_1374; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.22832 m; Elevation to 1st Reference Level: 1.22832 m; Elevation to 2nd Reference Level: 1.22832 m; Elevation to Sea Level: 10.5683 m; Elevation to Linked/Home Story: 1.22832 m; Home Offset: 1.22832 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.3484 m; Top Elevation To Home Story: 1.3484 m; Top Elevation To Project Zero: 1.3484 m; Top Elevation To Sea Level: 10.6884 m; Top Elevation To Second Reference Level: 1.3484 m; Bottom Elevation To First Reference Level: 1.22832 m; Bottom Elevation To Home Story: 1.22832 m; Bottom Elevation To Project Zero: 1.22832 m; Bottom Elevation To Sea Level: 10.5683 m; Bottom Elevation To Second Reference Level: 1.22832 m; Survey Coordinate X: 426560 m; Survey Coordinate Z: 10.5683 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1374 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
Name | Survey Coordinate Y (m)
Object_1374 | 4579784
Object_1374 | 4579785

# IfcBuildingElementProxy: Rhino_Object_1375, Object_1375
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1375; Hotlink and Element ID: Object_1375; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1375; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1375; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1375 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1375_; 109.AMB.CodiTipus: Object_1375; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
