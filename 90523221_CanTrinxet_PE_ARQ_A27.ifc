Properties of the parts of a building model (IFC2X3), part 73 of 99

# IfcBuildingElementProxy: Rhino_Object_1839, Object_1839
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1839 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1839_; 109.AMB.CodiTipus: Object_1839; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1840, Object_1840
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1840; Hotlink and Element ID: Object_1840; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1840; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1840; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1840 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1840_; 109.AMB.CodiTipus: Object_1840; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1840 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3

# IfcBuildingElementProxy: Rhino_Object_1841, Object_1841
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1841; Hotlink and Element ID: Object_1841; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1841; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1841; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1841 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1841_; 109.AMB.CodiTipus: Object_1841; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1841 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1842, Object_1842
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1842; Hotlink and Element ID: Object_1842; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1842; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1842; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1842 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.169373 m; Area: 0.0186276 m2; Height: 0.0575 m; Volume (Net): 0.00093993 m3; Width: 0.10998 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0629918 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0186276 m2; Bottom Surface Area (Net): 0.0629918 m2
AC_Equantity_Rhino_Object_1842 - Dimension 1: 0.169373 m; Dimension 2: 0.10998 m; Height: 0.0575 m; Bottom Level: -2.14939e-13 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.10998 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00093993 m3; Component, Component Volume (Gross): 0.00093993 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1842_; 109.AMB.CodiTipus: Object_1842; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1843, Object_1843
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1843; Hotlink and Element ID: Object_1843; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1843; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1843; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1843 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1843_; 109.AMB.CodiTipus: Object_1843; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0977527 m; Area: 0.0103143 m2; Height: 0.0575 m; Volume (Net): 0.000527314 m3; Width: 0.105514 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0403876 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426558 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0103143 m2; Bottom Surface Area (Net): 0.0403876 m2
Component Quantities - Component, Component Volume (Net): 0.000527314 m3; Component, Component Volume (Gross): 0.000527314 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.105514 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1843 - Dimension 1: 0.0977527 m; Dimension 2: 0.105514 m; Height: 0.0575 m; Bottom Level: -7.01661e-14 m; Top Level: 0.0575 m

# IfcBuildingElementProxy: Rhino_Object_1844, Object_1844
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1844; Hotlink and Element ID: Object_1844; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_1844; Building Material / Composite / Profile / Fill: Common Brick; Fill Type: Common Brick; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1844; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1844 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: Roofs/Shells - Outlines and Cover Fills; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1844_; 109.AMB.CodiTipus: Object_1844; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.588094 m; Area: 0.265157 m2; Height: 5.95556 m; Volume (Net): 1.21349 m3; Width: 0.450875 m; Elevation to Project Zero: -0.00170784 m; Elevation to 1st Reference Level: -0.00170784 m; Elevation to 2nd Reference Level: -0.00170784 m; Elevation to Sea Level: 9.33829 m; Elevation to Linked/Home Story: -0.00170784 m; Home Offset: -0.00170784 m; Surface Area: 12.2122 m2; Top Elevation To First Reference Level: 5.95385 m; Top Elevation To Home Story: 5.95385 m; Top Elevation To Project Zero: 5.95385 m; Top Elevation To Sea Level: 15.2939 m; Top Elevation To Second Reference Level: 5.95385 m; Bottom Elevation To First Reference Level: -0.00170784 m; Bottom Elevation To Home Story: -0.00170784 m; Bottom Elevation To Project Zero: -0.00170784 m; Bottom Elevation To Sea Level: 9.33829 m; Bottom Elevation To Second Reference Level: -0.00170784 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 9.33829 m; Top Surface Area (Net): 0.265157 m2; Bottom Surface Area (Net): 12.2122 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.450875 m; 503.AMB.Altura: 5.95556 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 1.21349 m3; Component, Component Volume (Gross): 1.21349 m3
AC_Equantity_Rhino_Object_1844 - Dimension 1: 0.588094 m; Dimension 2: 0.450875 m; Height: 5.95556 m; Bottom Level: 0 m; Top Level: 5.95556 m

# IfcBuildingElementProxy: Rhino_Object_1846, Object_1846
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.8055 deg; Surface: Brick - Aged Natural; Element ID: Object_1846; Hotlink and Element ID: Object_1846; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_1846; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1846; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1846 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1846_; 109.AMB.CodiTipus: Object_1846; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.109298 m; Area: 0.231307 m2; Height: 3.84526 m; Volume (Net): 0.103939 m3; Width: 2.1163 m; Elevation to Project Zero: 0.235227 m; Elevation to 1st Reference Level: 0.235227 m; Elevation to 2nd Reference Level: 0.235227 m; Elevation to Sea Level: 9.57523 m; Elevation to Linked/Home Story: 0.235227 m; Home Offset: 0.235227 m; Surface Area: 4.62008 m2; Top Elevation To First Reference Level: 3.90325 m; Top Elevation To Home Story: 3.90325 m; Top Elevation To Project Zero: 3.90325 m; Top Elevation To Sea Level: 13.2433 m; Top Elevation To Second Reference Level: 3.90325 m; Bottom Elevation To First Reference Level: 0.235227 m; Bottom Elevation To Home Story: 0.235227 m; Bottom Elevation To Project Zero: 0.235227 m; Bottom Elevation To Sea Level: 9.57523 m; Bottom Elevation To Second Reference Level: 0.235227 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 9.57523 m; Top Surface Area (Net): 0.231307 m2; Bottom Surface Area (Net): 4.62008 m2
AC_Equantity_Rhino_Object_1846 - Dimension 1: 0.109298 m; Dimension 2: 2.1163 m; Height: 3.84526 m; Bottom Level: -2.82885e-13 m; Top Level: 3.84526 m
5 AMB.Geometria - 502.AMB.Amplada: 2.1163 m; 503.AMB.Altura: 3.84526 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.103939 m3; Component, Component Volume (Gross): 0.103939 m3

# IfcBuildingElementProxy: Rhino_Object_1847, Object_1847
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.8076 deg; Surface: Brick - Aged Natural; Element ID: Object_1847; Hotlink and Element ID: Object_1847; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1847; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1847; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1847 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1847_; 109.AMB.CodiTipus: Object_1847; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.142309 m; Area: 0.319697 m2; Height: 0.405923 m; Volume (Net): 0.0133998 m3; Width: 2.2465 m; Elevation to Project Zero: 3.73912 m; Elevation to 1st Reference Level: 3.73912 m; Elevation to 2nd Reference Level: 3.73912 m; Elevation to Sea Level: 13.0791 m; Elevation to Linked/Home Story: 3.73912 m; Home Offset: 3.73912 m; Surface Area: 0.721084 m2; Top Elevation To First Reference Level: 3.96825 m; Top Elevation To Home Story: 3.96825 m; Top Elevation To Project Zero: 3.96825 m; Top Elevation To Sea Level: 13.3083 m; Top Elevation To Second Reference Level: 3.96825 m; Bottom Elevation To First Reference Level: 3.73912 m; Bottom Elevation To Home Story: 3.73912 m; Bottom Elevation To Project Zero: 3.73912 m; Bottom Elevation To Sea Level: 13.0791 m; Bottom Elevation To Second Reference Level: 3.73912 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.0791 m; Top Surface Area (Net): 0.319697 m2; Bottom Surface Area (Net): 0.721084 m2
5 AMB.Geometria - 502.AMB.Amplada: 2.2465 m; 503.AMB.Altura: 0.405923 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1847 - Dimension 1: 0.142309 m; Dimension 2: 2.2465 m; Height: 0.405923 m; Bottom Level: 0 m; Top Level: 0.405923 m
Component Quantities - Component, Component Volume (Net): 0.0133998 m3; Component, Component Volume (Gross): 0.0133998 m3

# IfcBuildingElementProxy: Rhino_Object_1848, Object_1848
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.8033 deg; Surface: Brick - Aged Natural; Element ID: Object_1848; Hotlink and Element ID: Object_1848; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1848; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1848; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1848 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1848_; 109.AMB.CodiTipus: Object_1848; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.1737 m; Area: 0.400755 m2; Height: 0.370731 m; Volume (Net): 0.00845994 m3; Width: 2.30717 m; Elevation to Project Zero: 3.80412 m; Elevation to 1st Reference Level: 3.80412 m; Elevation to 2nd Reference Level: 3.80412 m; Elevation to Sea Level: 13.1441 m; Elevation to Linked/Home Story: 3.80412 m; Home Offset: 3.80412 m; Surface Area: 0.711295 m2; Top Elevation To First Reference Level: 3.99825 m; Top Elevation To Home Story: 3.99825 m; Top Elevation To Project Zero: 3.99825 m; Top Elevation To Sea Level: 13.3383 m; Top Elevation To Second Reference Level: 3.99825 m; Bottom Elevation To First Reference Level: 3.80412 m; Bottom Elevation To Home Story: 3.80412 m; Bottom Elevation To Project Zero: 3.80412 m; Bottom Elevation To Sea Level: 13.1441 m; Bottom Elevation To Second Reference Level: 3.80412 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.1441 m; Top Surface Area (Net): 0.400755 m2; Bottom Surface Area (Net): 0.711295 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1848 - Dimension 1: 0.1737 m; Dimension 2: 2.30717 m; Height: 0.370731 m; Bottom Level: 0 m; Top Level: 0.370731 m
Component Quantities - Component, Component Volume (Net): 0.00845994 m3; Component, Component Volume (Gross): 0.00845994 m3
5 AMB.Geometria - 502.AMB.Amplada: 2.30717 m; 503.AMB.Altura: 0.370731 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1849 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7227 deg; Surface: Brick - Aged Natural; Element ID: Object_1849; Hotlink and Element ID: Object_1849; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1849; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1849; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1849 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1849_; 109.AMB.CodiTipus: Object_1849; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0522002 m; Area: 0.00766433 m2; Height: 0.352018 m; Volume (Net): 0.00257039 m3; Width: 0.146826 m; Surface Area: 0.15262 m2; Top Surface Area (Net): 0.00766433 m2; Bottom Surface Area (Net): 0.15262 m2
AC_Equantity_Rhino_Object_1849 - Dimension 1: 0.0522002 m; Dimension 2: 0.146826 m; Height: 0.352018 m; Bottom Level: 0 m; Top Level: 0.352018 m
5 AMB.Geometria - 502.AMB.Amplada: 0.146826 m; 503.AMB.Altura: 0.352018 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00257039 m3; Component, Component Volume (Gross): 0.00257039 m3
Name | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_1849 | 5.33327 | 14.6733 | 5.68529 | 15.0253 | 426568 | 4579789
Object_1849 | 5.81658 | 15.1566 | 6.1686 | 15.5086 | 426569 | 4579787

# IfcBuildingElementProxy: Rhino_Object_1850, Object_1850
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7227 deg; Surface: Brick - Aged Natural; Element ID: Object_1850; Hotlink and Element ID: Object_1850; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1850; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1850; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1850 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1850_; 109.AMB.CodiTipus: Object_1850; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0522002 m; Area: 0.00766433 m2; Height: 0.352018 m; Volume (Net): 0.00257039 m3; Width: 0.146826 m; Elevation to Project Zero: 4.9065 m; Elevation to 1st Reference Level: 4.9065 m; Elevation to 2nd Reference Level: 4.9065 m; Elevation to Sea Level: 14.2465 m; Elevation to Linked/Home Story: 4.9065 m; Home Offset: 4.9065 m; Surface Area: 0.15262 m2; Top Elevation To First Reference Level: 5.25852 m; Top Elevation To Home Story: 5.25852 m; Top Elevation To Project Zero: 5.25852 m; Top Elevation To Sea Level: 14.5985 m; Top Elevation To Second Reference Level: 5.25852 m; Bottom Elevation To First Reference Level: 4.9065 m; Bottom Elevation To Home Story: 4.9065 m; Bottom Elevation To Project Zero: 4.9065 m; Bottom Elevation To Sea Level: 14.2465 m; Bottom Elevation To Second Reference Level: 4.9065 m; Survey Coordinate X: 426568 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 14.2465 m; Top Surface Area (Net): 0.00766433 m2; Bottom Surface Area (Net): 0.15262 m2
AC_Equantity_Rhino_Object_1850 - Dimension 1: 0.0522002 m; Dimension 2: 0.146826 m; Height: 0.352018 m; Bottom Level: -1.77636e-15 m; Top Level: 0.352018 m
5 AMB.Geometria - 502.AMB.Amplada: 0.146826 m; 503.AMB.Altura: 0.352018 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00257039 m3; Component, Component Volume (Gross): 0.00257039 m3

# IfcBuildingElementProxy: Rhino_Object_1851, Object_1851
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7227 deg; Surface: Brick - Aged Natural; Element ID: Object_1851; Hotlink and Element ID: Object_1851; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1851; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1851; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1851 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1851_; 109.AMB.CodiTipus: Object_1851; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.466271 m; Area: 12.7553 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3559 m; Elevation to Project Zero: 5.90597 m; Elevation to 1st Reference Level: 5.90597 m; Elevation to 2nd Reference Level: 5.90597 m; Elevation to Sea Level: 15.246 m; Elevation to Linked/Home Story: 5.90597 m; Home Offset: 5.90597 m; Surface Area: 0.443443 m2; Top Elevation To First Reference Level: 6.01251 m; Top Elevation To Home Story: 6.01251 m; Top Elevation To Project Zero: 6.01251 m; Top Elevation To Sea Level: 15.3525 m; Top Elevation To Second Reference Level: 6.01251 m; Bottom Elevation To First Reference Level: 5.90597 m; Bottom Elevation To Home Story: 5.90597 m; Bottom Elevation To Project Zero: 5.90597 m; Bottom Elevation To Sea Level: 15.246 m; Bottom Elevation To Second Reference Level: 5.90597 m; Survey Coordinate X: 426568 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 15.246 m; Top Surface Area (Net): 12.7553 m2; Bottom Surface Area (Net): 0.443443 m2
AC_Equantity_Rhino_Object_1851 - Dimension 1: 0.466271 m; Dimension 2: 27.3559 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3559 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1852, Object_1852
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7227 deg; Surface: Brick - Aged Natural; Element ID: Object_1852; Hotlink and Element ID: Object_1852; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1852; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1852; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1852 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1852_; 109.AMB.CodiTipus: Object_1852; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.466271 m; Area: 12.7553 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3559 m; Elevation to Project Zero: 5.42267 m; Elevation to 1st Reference Level: 5.42267 m; Elevation to 2nd Reference Level: 5.42267 m; Elevation to Sea Level: 14.7627 m; Elevation to Linked/Home Story: 5.42267 m; Home Offset: 5.42267 m; Surface Area: 0.454836 m2; Top Elevation To First Reference Level: 5.52921 m; Top Elevation To Home Story: 5.52921 m; Top Elevation To Project Zero: 5.52921 m; Top Elevation To Sea Level: 14.8692 m; Top Elevation To Second Reference Level: 5.52921 m; Bottom Elevation To First Reference Level: 5.42267 m; Bottom Elevation To Home Story: 5.42267 m; Bottom Elevation To Project Zero: 5.42267 m; Bottom Elevation To Sea Level: 14.7627 m; Bottom Elevation To Second Reference Level: 5.42267 m; Survey Coordinate X: 426568 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 14.7627 m; Top Surface Area (Net): 12.7553 m2; Bottom Surface Area (Net): 0.454836 m2
AC_Equantity_Rhino_Object_1852 - Dimension 1: 0.466271 m; Dimension 2: 27.3559 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3559 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1853, Object_1853
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7227 deg; Surface: Brick - Aged Natural; Element ID: Object_1853; Hotlink and Element ID: Object_1853; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1853; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1853; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1853 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1853_; 109.AMB.CodiTipus: Object_1853; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.466271 m; Area: 12.7553 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3559 m; Elevation to Project Zero: 4.99594 m; Elevation to 1st Reference Level: 4.99594 m; Elevation to 2nd Reference Level: 4.99594 m; Elevation to Sea Level: 14.3359 m; Elevation to Linked/Home Story: 4.99594 m; Home Offset: 4.99594 m; Surface Area: 0.426456 m2; Top Elevation To First Reference Level: 5.10249 m; Top Elevation To Home Story: 5.10249 m; Top Elevation To Project Zero: 5.10249 m; Top Elevation To Sea Level: 14.4425 m; Top Elevation To Second Reference Level: 5.10249 m; Bottom Elevation To First Reference Level: 4.99594 m; Bottom Elevation To Home Story: 4.99594 m; Bottom Elevation To Project Zero: 4.99594 m; Bottom Elevation To Sea Level: 14.3359 m; Bottom Elevation To Second Reference Level: 4.99594 m; Survey Coordinate X: 426568 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 14.3359 m; Top Surface Area (Net): 12.7553 m2; Bottom Surface Area (Net): 0.426456 m2
AC_Equantity_Rhino_Object_1853 - Dimension 1: 0.466271 m; Dimension 2: 27.3559 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3559 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1854, Object_1854
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.7227 deg; Surface: Brick - Aged Natural; Element ID: Object_1854; Hotlink and Element ID: Object_1854; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1854; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1854; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1854_; 109.AMB.CodiTipus: Object_1854; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.0725722 m; Area: 0.110353 m2; Height: 0.156183 m; Volume (Net): 0.011856 m3; Width: 1.52059 m; Elevation to Project Zero: 5.99649 m; Elevation to 1st Reference Level: 5.99649 m; Elevation to 2nd Reference Level: 5.99649 m; Elevation to Sea Level: 15.3365 m; Elevation to Linked/Home Story: 5.99649 m; Home Offset: 5.99649 m; Surface Area: 0.64184 m2; Top Elevation To First Reference Level: 6.15267 m; Top Elevation To Home Story: 6.15267 m; Top Elevation To Project Zero: 6.15267 m; Top Elevation To Sea Level: 15.4927 m; Top Elevation To Second Reference Level: 6.15267 m; Bottom Elevation To First Reference Level: 5.99649 m; Bottom Elevation To Home Story: 5.99649 m; Bottom Elevation To Project Zero: 5.99649 m; Bottom Elevation To Sea Level: 15.3365 m; Bottom Elevation To Second Reference Level: 5.99649 m; Survey Coordinate X: 426569 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 15.3365 m; Top Surface Area (Net): 0.110353 m2; Bottom Surface Area (Net): 0.64184 m2
AC_Equantity_Rhino_Object_1854 - Dimension 1: 0.0725722 m; Dimension 2: 1.52059 m; Height: 0.156183 m; Bottom Level: -1.06581e-14 m; Top Level: 0.156183 m
5 AMB.Geometria - 502.AMB.Amplada: 1.52059 m; 503.AMB.Altura: 0.156183 m; 506.AMB.Profunditat: 0 m
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Pset_Rhino_Object_1854 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Component Quantities - Component, Component Volume (Net): 0.011856 m3; Component, Component Volume (Gross): 0.011856 m3

# IfcBuildingElementProxy: Rhino_Object_1855, Object_1855
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7227 deg; Surface: Brick - Aged Natural; Element ID: Object_1855; Hotlink and Element ID: Object_1855; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1855; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1855; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1855 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1855_; 109.AMB.CodiTipus: Object_1855; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0737153 m; Area: 0.117763 m2; Height: 0.156192 m; Volume (Net): 0.0124562 m3; Width: 1.59754 m; Elevation to Project Zero: 5.52921 m; Elevation to 1st Reference Level: 5.52921 m; Elevation to 2nd Reference Level: 5.52921 m; Elevation to Sea Level: 14.8692 m; Elevation to Linked/Home Story: 5.52921 m; Home Offset: 5.52921 m; Surface Area: 0.673545 m2; Top Elevation To First Reference Level: 5.6854 m; Top Elevation To Home Story: 5.6854 m; Top Elevation To Project Zero: 5.6854 m; Top Elevation To Sea Level: 15.0254 m; Top Elevation To Second Reference Level: 5.6854 m; Bottom Elevation To First Reference Level: 5.52921 m; Bottom Elevation To Home Story: 5.52921 m; Bottom Elevation To Project Zero: 5.52921 m; Bottom Elevation To Sea Level: 14.8692 m; Bottom Elevation To Second Reference Level: 5.52921 m; Survey Coordinate X: 426568 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 14.8692 m; Top Surface Area (Net): 0.117763 m2; Bottom Surface Area (Net): 0.673545 m2
