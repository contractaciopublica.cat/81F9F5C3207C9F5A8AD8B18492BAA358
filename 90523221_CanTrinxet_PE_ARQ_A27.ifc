Properties of the parts of a building model (IFC2X3), part 77 of 99

# IfcBuildingElementProxy: Rhino_Object_1898, Object_1898
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1898_; 109.AMB.CodiTipus: Object_1898; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1898 - Dimension 1: 6.45992 m; Dimension 2: 23.6545 m; Height: 2.66414 m; Bottom Level: -1.05194 m; Top Level: 1.6122 m
5 AMB.Geometria - 502.AMB.Amplada: 23.6545 m; 503.AMB.Altura: 2.66414 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00766206 m3; Component, Component Volume (Gross): 0.00766206 m3
ArchiCADQuantities - Length (A): 6.45992 m; Area: 152.806 m2; Height: 2.66414 m; Volume (Net): 0.00766206 m3; Width: 23.6545 m; Elevation to Project Zero: 4.2598 m; Elevation to 1st Reference Level: 4.2598 m; Elevation to 2nd Reference Level: 4.2598 m; Elevation to Sea Level: 13.5998 m; Elevation to Linked/Home Story: 4.2598 m; Home Offset: 4.2598 m; Surface Area: 0.820439 m2; Top Elevation To First Reference Level: 4.3098 m; Top Elevation To Home Story: 4.3098 m; Top Elevation To Project Zero: 4.3098 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.3098 m; Bottom Elevation To First Reference Level: 4.2598 m; Bottom Elevation To Home Story: 4.2598 m; Bottom Elevation To Project Zero: 4.2598 m; Bottom Elevation To Sea Level: 13.5998 m; Bottom Elevation To Second Reference Level: 4.2598 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 13.5998 m; Top Surface Area (Net): 152.806 m2; Bottom Surface Area (Net): 0.820439 m2

# IfcBuildingElementProxy: Rhino_Object_1899, Object_1899
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.8038 deg; Surface: Brick - Aged Natural; Element ID: Object_1899; Hotlink and Element ID: Object_1899; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1899; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1899; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1899 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1899_; 109.AMB.CodiTipus: Object_1899; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 6.45992 m; Area: 152.817 m2; Height: 2.66414 m; Volume (Net): 0.0604208 m3; Width: 23.6562 m; Elevation to Project Zero: 4.3698 m; Elevation to 1st Reference Level: 4.3698 m; Elevation to 2nd Reference Level: 4.3698 m; Elevation to Sea Level: 13.7098 m; Elevation to Linked/Home Story: 4.3698 m; Home Offset: 4.3698 m; Surface Area: 2.48272 m2; Top Elevation To First Reference Level: 4.53993 m; Top Elevation To Home Story: 4.53993 m; Top Elevation To Project Zero: 4.53993 m; Top Elevation To Sea Level: 13.8799 m; Top Elevation To Second Reference Level: 4.53993 m; Bottom Elevation To First Reference Level: 4.3698 m; Bottom Elevation To Home Story: 4.3698 m; Bottom Elevation To Project Zero: 4.3698 m; Bottom Elevation To Sea Level: 13.7098 m; Bottom Elevation To Second Reference Level: 4.3698 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 13.7098 m; Top Surface Area (Net): 152.817 m2; Bottom Surface Area (Net): 2.48272 m2
AC_Equantity_Rhino_Object_1899 - Dimension 1: 6.45992 m; Dimension 2: 23.6562 m; Height: 2.66414 m; Bottom Level: -1.16194 m; Top Level: 1.5022 m
5 AMB.Geometria - 502.AMB.Amplada: 23.6562 m; 503.AMB.Altura: 2.66414 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0604208 m3; Component, Component Volume (Gross): 0.0604208 m3
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Rhino_Object_190, Object_190
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_190; Hotlink and Element ID: Object_190; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_190; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_190; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_190 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_190_; 109.AMB.CodiTipus: Object_190; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_190 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: 0 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.015273 m3; Component, Component Volume (Gross): 0.015273 m3
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.015273 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.693152 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693152 m2

# IfcBuildingElementProxy: Rhino_Object_1901, Object_1901
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Component Quantities - Component, Component Volume (Net): 0.000254171 m3; Component, Component Volume (Gross): 0.000254171 m3
5 AMB.Geometria - 502.AMB.Amplada: 2.79901 m; 503.AMB.Altura: 2.66414 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1901 - Dimension 1: 6.45992 m; Dimension 2: 2.79901 m; Height: 2.66414 m; Bottom Level: -1.10194 m; Top Level: 1.5622 m
ArchiCADQuantities - Length (A): 6.45992 m; Area: 18.0814 m2; Height: 2.66414 m; Volume (Net): 0.000254171 m3; Width: 2.79901 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0279552 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426536 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 18.0814 m2; Bottom Surface Area (Net): 0.0279552 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1901_; 109.AMB.CodiTipus: Object_1901; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1901 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 12.8038 deg; Surface: Brick - Aged Natural; Element ID: Object_1901; Hotlink and Element ID: Object_1901; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1901; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1901; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1902, Object_1902
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.0373 deg; Surface: Brick - Aged Natural; Element ID: Object_1902; Hotlink and Element ID: Object_1902; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1902; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1902; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1902 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1902_; 109.AMB.CodiTipus: Object_1902; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.09247 m; Area: 4.89507 m2; Height: 8.45006 m; Volume (Net): 0.000308546 m3; Width: 2.33938 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0309197 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579784 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 4.89507 m2; Bottom Surface Area (Net): 0.0309197 m2
5 AMB.Geometria - 502.AMB.Amplada: 2.33938 m; 503.AMB.Altura: 8.45006 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1902 - Dimension 1: 2.09247 m; Dimension 2: 2.33938 m; Height: 8.45006 m; Bottom Level: -1.3447 m; Top Level: 7.10537 m
Component Quantities - Component, Component Volume (Net): 0.000308546 m3; Component, Component Volume (Gross): 0.000308546 m3

# IfcBuildingElementProxy: Rhino_Object_1903, Object_1903
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.0375 deg; Surface: Brick - Aged Natural; Element ID: Object_1903; Hotlink and Element ID: Object_1903; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1903; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1903; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1903 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1903_; 109.AMB.CodiTipus: Object_1903; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 18.3341 m; Area: 290.561 m2; Height: 8.45006 m; Volume (Net): 0.017838 m3; Width: 15.8481 m; Elevation to Project Zero: 4.36964 m; Elevation to 1st Reference Level: 4.36964 m; Elevation to 2nd Reference Level: 4.36964 m; Elevation to Sea Level: 13.7096 m; Elevation to Linked/Home Story: 4.36964 m; Home Offset: 4.36964 m; Surface Area: 0.749478 m2; Top Elevation To First Reference Level: 4.53977 m; Top Elevation To Home Story: 4.53977 m; Top Elevation To Project Zero: 4.53977 m; Top Elevation To Sea Level: 13.8798 m; Top Elevation To Second Reference Level: 4.53977 m; Bottom Elevation To First Reference Level: 4.36964 m; Bottom Elevation To Home Story: 4.36964 m; Bottom Elevation To Project Zero: 4.36964 m; Bottom Elevation To Sea Level: 13.7096 m; Bottom Elevation To Second Reference Level: 4.36964 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 13.7096 m; Top Surface Area (Net): 290.561 m2; Bottom Surface Area (Net): 0.749478 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1903 - Dimension 1: 18.3341 m; Dimension 2: 15.8481 m; Height: 8.45006 m; Bottom Level: -1.4047 m; Top Level: 7.04537 m
5 AMB.Geometria - 502.AMB.Amplada: 15.8481 m; 503.AMB.Altura: 8.45006 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.017838 m3; Component, Component Volume (Gross): 0.017838 m3

# IfcBuildingElementProxy: Rhino_Object_1904, Object_1904
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.0373 deg; Surface: Brick - Aged Natural; Element ID: Object_1904; Hotlink and Element ID: Object_1904; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1904; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1904; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1904 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1904_; 109.AMB.CodiTipus: Object_1904; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADQuantities - Length (A): 18.3341 m; Area: 289.608 m2; Height: 8.45006 m; Volume (Net): 0.0022677 m3; Width: 15.7962 m; Elevation to Project Zero: 4.2598 m; Elevation to 1st Reference Level: 4.2598 m; Elevation to 2nd Reference Level: 4.2598 m; Elevation to Sea Level: 13.5998 m; Elevation to Linked/Home Story: 4.2598 m; Home Offset: 4.2598 m; Surface Area: 0.244888 m2; Top Elevation To First Reference Level: 4.3098 m; Top Elevation To Home Story: 4.3098 m; Top Elevation To Project Zero: 4.3098 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.3098 m; Bottom Elevation To First Reference Level: 4.2598 m; Bottom Elevation To Home Story: 4.2598 m; Bottom Elevation To Project Zero: 4.2598 m; Bottom Elevation To Sea Level: 13.5998 m; Bottom Elevation To Second Reference Level: 4.2598 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 13.5998 m; Top Surface Area (Net): 289.608 m2; Bottom Surface Area (Net): 0.244888 m2
AC_Equantity_Rhino_Object_1904 - Dimension 1: 18.3341 m; Dimension 2: 15.7962 m; Height: 8.45006 m; Bottom Level: -1.2947 m; Top Level: 7.15537 m
5 AMB.Geometria - 502.AMB.Amplada: 15.7962 m; 503.AMB.Altura: 8.45006 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0022677 m3; Component, Component Volume (Gross): 0.0022677 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1928, Object_1928
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Component Quantities - Component, Component Volume (Net): 0.14619 m3; Component, Component Volume (Gross): 0.14619 m3
5 AMB.Geometria - 502.AMB.Amplada: 1.30119 m; 503.AMB.Altura: 0.317008 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1928 - Dimension 1: 1.36578 m; Dimension 2: 1.30119 m; Height: 0.317008 m; Bottom Level: -2.86076e-07 m; Top Level: 0.317008 m
ArchiCADQuantities - Length (A): 1.36578 m; Area: 1.77714 m2; Height: 0.317008 m; Volume (Net): 0.14619 m3; Width: 1.30119 m; Elevation to Project Zero: 5.25683 m; Elevation to 1st Reference Level: 5.25683 m; Elevation to 2nd Reference Level: 5.25683 m; Elevation to Sea Level: 14.5968 m; Elevation to Linked/Home Story: 5.25683 m; Home Offset: 5.25683 m; Surface Area: 2.1841 m2; Top Elevation To First Reference Level: 5.57383 m; Top Elevation To Home Story: 5.57383 m; Top Elevation To Project Zero: 5.57383 m; Top Elevation To Sea Level: 14.9138 m; Top Elevation To Second Reference Level: 5.57383 m; Bottom Elevation To First Reference Level: 5.25683 m; Bottom Elevation To Home Story: 5.25683 m; Bottom Elevation To Project Zero: 5.25683 m; Bottom Elevation To Sea Level: 14.5968 m; Bottom Elevation To Second Reference Level: 5.25683 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 14.5968 m; Top Surface Area (Net): 1.77714 m2; Bottom Surface Area (Net): 2.1841 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1928_; 109.AMB.CodiTipus: Object_1928; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1928 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 1; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 5; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 12.0375 deg; Surface: Brick - Aged Natural; Element ID: Object_1928; Hotlink and Element ID: Object_1928; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_1928; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1928; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_206, Object_206
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4898 deg; Surface: Brick - Aged Natural; Element ID: Object_206; Hotlink and Element ID: Object_206; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_206; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_206; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_206 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_206_; 109.AMB.CodiTipus: Object_206; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.78819 m; Area: 0.649978 m2; Height: 2.61918 m; Volume (Net): 0.0927896 m3; Width: 0.233118 m; Elevation to Project Zero: 1.53196 m; Elevation to 1st Reference Level: 1.53196 m; Elevation to 2nd Reference Level: 1.53196 m; Elevation to Sea Level: 10.872 m; Elevation to Linked/Home Story: 1.53196 m; Home Offset: 1.53196 m; Surface Area: 3.83868 m2; Top Elevation To First Reference Level: 3.9044 m; Top Elevation To Home Story: 3.9044 m; Top Elevation To Project Zero: 3.9044 m; Top Elevation To Sea Level: 13.2444 m; Top Elevation To Second Reference Level: 3.9044 m; Bottom Elevation To First Reference Level: 1.53196 m; Bottom Elevation To Home Story: 1.53196 m; Bottom Elevation To Project Zero: 1.53196 m; Bottom Elevation To Sea Level: 10.872 m; Bottom Elevation To Second Reference Level: 1.53196 m; Survey Coordinate X: 426571 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 10.872 m; Top Surface Area (Net): 0.649978 m2; Bottom Surface Area (Net): 3.83868 m2
AC_Equantity_Rhino_Object_206 - Dimension 1: 2.78819 m; Dimension 2: 0.233118 m; Height: 2.61918 m; Bottom Level: -4.44089e-16 m; Top Level: 2.61918 m
5 AMB.Geometria - 502.AMB.Amplada: 0.233118 m; 503.AMB.Altura: 2.61918 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0927896 m3; Component, Component Volume (Gross): 0.0927896 m3

# IfcBuildingElementProxy: Rhino_Object_207, Object_207
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.6775 deg; Surface: Brick - Aged Natural; Element ID: Object_207; Hotlink and Element ID: Object_207; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_207; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_207; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_207 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_207_; 109.AMB.CodiTipus: Object_207; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.97209 m; Area: 0.854729 m2; Height: 0.516507 m; Volume (Net): 0.00795521 m3; Width: 0.287585 m; Elevation to Project Zero: 3.73569 m; Elevation to 1st Reference Level: 3.73569 m; Elevation to 2nd Reference Level: 3.73569 m; Elevation to Sea Level: 13.0757 m; Elevation to Linked/Home Story: 3.73569 m; Home Offset: 3.73569 m; Surface Area: 0.864871 m2; Top Elevation To First Reference Level: 3.99592 m; Top Elevation To Home Story: 3.99592 m; Top Elevation To Project Zero: 3.99592 m; Top Elevation To Sea Level: 13.3359 m; Top Elevation To Second Reference Level: 3.99592 m; Bottom Elevation To First Reference Level: 3.73569 m; Bottom Elevation To Home Story: 3.73569 m; Bottom Elevation To Project Zero: 3.73569 m; Bottom Elevation To Sea Level: 13.0757 m; Bottom Elevation To Second Reference Level: 3.73569 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.0757 m; Top Surface Area (Net): 0.854729 m2; Bottom Surface Area (Net): 0.864871 m2
AC_Equantity_Rhino_Object_207 - Dimension 1: 2.97209 m; Dimension 2: 0.287585 m; Height: 0.516507 m; Bottom Level: -2.30926e-14 m; Top Level: 0.516507 m
5 AMB.Geometria - 502.AMB.Amplada: 0.287585 m; 503.AMB.Altura: 0.516507 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00795521 m3; Component, Component Volume (Gross): 0.00795521 m3

# IfcBuildingElementProxy: Rhino_Object_208, Object_208
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.6775 deg; Surface: Brick - Aged Natural; Element ID: Object_208; Hotlink and Element ID: Object_208; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_208; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_208; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_208 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_208_; 109.AMB.CodiTipus: Object_208; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Equantity_Rhino_Object_208 - Dimension 1: 2.91425 m; Dimension 2: 0.254425 m; Height: 0.556165 m; Bottom Level: -2.66454e-15 m; Top Level: 0.556165 m
5 AMB.Geometria - 502.AMB.Amplada: 0.254425 m; 503.AMB.Altura: 0.556165 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0177179 m3; Component, Component Volume (Gross): 0.0177179 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 2.91425 m; Area: 0.741458 m2; Height: 0.556165 m; Volume (Net): 0.0177179 m3; Width: 0.254425 m; Elevation to Project Zero: 3.67427 m; Elevation to 1st Reference Level: 3.67427 m; Elevation to 2nd Reference Level: 3.67427 m; Elevation to Sea Level: 13.0143 m; Elevation to Linked/Home Story: 3.67427 m; Home Offset: 3.67427 m; Surface Area: 0.939599 m2; Top Elevation To First Reference Level: 3.97403 m; Top Elevation To Home Story: 3.97403 m; Top Elevation To Project Zero: 3.97403 m; Top Elevation To Sea Level: 13.314 m; Top Elevation To Second Reference Level: 3.97403 m; Bottom Elevation To First Reference Level: 3.67427 m; Bottom Elevation To Home Story: 3.67427 m; Bottom Elevation To Project Zero: 3.67427 m; Bottom Elevation To Sea Level: 13.0143 m; Bottom Elevation To Second Reference Level: 3.67427 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.0143 m; Top Surface Area (Net): 0.741458 m2; Bottom Surface Area (Net): 0.939599 m2

# IfcBuildingElementProxy: Rhino_Object_211, Object_211
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_211; Hotlink and Element ID: Object_211; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_211; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_211; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_211 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_211_; 109.AMB.CodiTipus: Object_211; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.18017 m; Area: 0.442314 m2; Height: 2.71628 m; Volume (Net): 0.118769 m3; Width: 0.20288 m; Elevation to Project Zero: 1.51416 m; Elevation to 1st Reference Level: 1.51416 m; Elevation to 2nd Reference Level: 1.51416 m; Elevation to Sea Level: 10.8542 m; Elevation to Linked/Home Story: 1.51416 m; Home Offset: 1.51416 m; Surface Area: 4.65039 m2; Top Elevation To First Reference Level: 3.93107 m; Top Elevation To Home Story: 3.93107 m; Top Elevation To Project Zero: 3.93107 m; Top Elevation To Sea Level: 13.2711 m; Top Elevation To Second Reference Level: 3.93107 m; Bottom Elevation To First Reference Level: 1.51416 m; Bottom Elevation To Home Story: 1.51416 m; Bottom Elevation To Project Zero: 1.51416 m; Bottom Elevation To Sea Level: 10.8542 m; Bottom Elevation To Second Reference Level: 1.51416 m; Survey Coordinate X: 426583 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 10.8542 m; Top Surface Area (Net): 0.442314 m2; Bottom Surface Area (Net): 4.65039 m2
AC_Equantity_Rhino_Object_211 - Dimension 1: 2.18017 m; Dimension 2: 0.20288 m; Height: 2.71628 m; Bottom Level: -4.88498e-15 m; Top Level: 2.71628 m
5 AMB.Geometria - 502.AMB.Amplada: 0.20288 m; 503.AMB.Altura: 2.71628 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.118769 m3; Component, Component Volume (Gross): 0.118769 m3

# IfcBuildingElementProxy: Rhino_Object_212, Object_212
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_212; Hotlink and Element ID: Object_212; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_212; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_212; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_212 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_212_; 109.AMB.CodiTipus: Object_212; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.36359 m; Area: 0.623544 m2; Height: 0.591492 m; Volume (Net): 0.00633563 m3; Width: 0.263812 m; Elevation to Project Zero: 3.73569 m; Elevation to 1st Reference Level: 3.73569 m; Elevation to 2nd Reference Level: 3.73569 m; Elevation to Sea Level: 13.0757 m; Elevation to Linked/Home Story: 3.73569 m; Home Offset: 3.73569 m; Surface Area: 0.700057 m2; Top Elevation To First Reference Level: 4.0212 m; Top Elevation To Home Story: 4.0212 m; Top Elevation To Project Zero: 4.0212 m; Top Elevation To Sea Level: 13.3612 m; Top Elevation To Second Reference Level: 4.0212 m; Bottom Elevation To First Reference Level: 3.73569 m; Bottom Elevation To Home Story: 3.73569 m; Bottom Elevation To Project Zero: 3.73569 m; Bottom Elevation To Sea Level: 13.0757 m; Bottom Elevation To Second Reference Level: 3.73569 m; Survey Coordinate X: 426582 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.0757 m; Top Surface Area (Net): 0.623544 m2; Bottom Surface Area (Net): 0.700057 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.263812 m; 503.AMB.Altura: 0.591492 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00633563 m3; Component, Component Volume (Gross): 0.00633563 m3
AC_Equantity_Rhino_Object_212 - Dimension 1: 2.36359 m; Dimension 2: 0.263812 m; Height: 0.591492 m; Bottom Level: -9.76996e-15 m; Top Level: 0.591492 m

# IfcBuildingElementProxy: Rhino_Object_213, Object_213
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_213; Hotlink and Element ID: Object_213; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_213; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_213; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_213 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_213_; 109.AMB.CodiTipus: Object_213; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Component Quantities - Component, Component Volume (Net): 0.0146995 m3; Component, Component Volume (Gross): 0.0146995 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.230437 m; 503.AMB.Altura: 0.63198 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_213 - Dimension 1: 2.30563 m; Dimension 2: 0.230437 m; Height: 0.63198 m; Bottom Level: -9.76996e-15 m; Top Level: 0.63198 m
ArchiCADQuantities - Length (A): 2.30563 m; Area: 0.531304 m2; Height: 0.63198 m; Volume (Net): 0.0146995 m3; Width: 0.230437 m; Elevation to Project Zero: 3.67427 m; Elevation to 1st Reference Level: 3.67427 m; Elevation to 2nd Reference Level: 3.67427 m; Elevation to Sea Level: 13.0143 m; Elevation to Linked/Home Story: 3.67427 m; Home Offset: 3.67427 m; Surface Area: 0.769371 m2; Top Elevation To First Reference Level: 3.99953 m; Top Elevation To Home Story: 3.99953 m; Top Elevation To Project Zero: 3.99953 m; Top Elevation To Sea Level: 13.3395 m; Top Elevation To Second Reference Level: 3.99953 m; Bottom Elevation To First Reference Level: 3.67427 m; Bottom Elevation To Home Story: 3.67427 m; Bottom Elevation To Project Zero: 3.67427 m; Bottom Elevation To Sea Level: 13.0143 m; Bottom Elevation To Second Reference Level: 3.67427 m; Survey Coordinate X: 426582 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.0143 m; Top Surface Area (Net): 0.531304 m2; Bottom Surface Area (Net): 0.769371 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_214, Object_214
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_214; Hotlink and Element ID: Object_214; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_214; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_214; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_214 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_214_; 109.AMB.CodiTipus: Object_214; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 2.18017 m; Area: 0.442314 m2; Height: 2.71628 m; Volume (Net): 0.118769 m3; Width: 0.20288 m; Elevation to Project Zero: 1.51416 m; Elevation to 1st Reference Level: 1.51416 m; Elevation to 2nd Reference Level: 1.51416 m; Elevation to Sea Level: 10.8542 m; Elevation to Linked/Home Story: 1.51416 m; Home Offset: 1.51416 m; Surface Area: 4.65039 m2; Top Elevation To First Reference Level: 3.93107 m; Top Elevation To Home Story: 3.93107 m; Top Elevation To Project Zero: 3.93107 m; Top Elevation To Sea Level: 13.2711 m; Top Elevation To Second Reference Level: 3.93107 m; Bottom Elevation To First Reference Level: 1.51416 m; Bottom Elevation To Home Story: 1.51416 m; Bottom Elevation To Project Zero: 1.51416 m; Bottom Elevation To Sea Level: 10.8542 m; Bottom Elevation To Second Reference Level: 1.51416 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 10.8542 m; Top Surface Area (Net): 0.442314 m2; Bottom Surface Area (Net): 4.65039 m2
AC_Equantity_Rhino_Object_214 - Dimension 1: 2.18017 m; Dimension 2: 0.20288 m; Height: 2.71628 m; Bottom Level: -4.88498e-15 m; Top Level: 2.71628 m
5 AMB.Geometria - 502.AMB.Amplada: 0.20288 m; 503.AMB.Altura: 2.71628 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.118769 m3; Component, Component Volume (Gross): 0.118769 m3

# IfcBuildingElementProxy: Rhino_Object_215, Object_215
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_215; Hotlink and Element ID: Object_215; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_215; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_215; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_215 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 6; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_215_; 109.AMB.CodiTipus: Object_215; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
