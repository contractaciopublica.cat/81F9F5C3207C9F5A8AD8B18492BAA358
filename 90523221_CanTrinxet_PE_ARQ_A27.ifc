Properties of the parts of a building model (IFC2X3), part 9 of 99

# IfcBuildingElementProxy: Fire Hose Cabinet 27 (7)
5 AMB.Geometria - 502.AMB.Amplada: 0.28 m; 506.AMB.Profunditat: 0 m
Name | Rotation Angle (deg) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Colliding Zones | Surfaces (All) | Tool Types in Cabinet | 107.AMB.NomTipus | 117.AMB.Localitzacio | Length (A) (m) = Dimension 1 (m) | Area (m2) = Top Surface Area (Net) (m2) | ArchiCADQuantities, Height (m) = AC_Equantity_Fire_Hose_Cabinet_27, Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Surface Area (m2) = Bottom Surface Area (Net) (m2) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Survey Coordinate X (m) | Survey Coordinate Y (m)
M203 | 103.57 | M203 | Distribuïdor; Nau Lateral | Metal - Stainless Steel; Paint - Vermilion; Plastic - Laminate; Glass - Clear Fast; Metal - Aluminium | 1 | M203_ | Nau Lateral | 0.919 | 0.25732 | 0.795 | 0.0590257 | 2.86425 | 12.2043 | 6.09724 | 3.65925 | 12.9993 | 426530 | 4579815
M008 | 197.021 | M008 | Espai d'atenció; Nau Santa Eulàlia | Metal - Stainless Steel; Paint - Vermilion; Plastic - Laminate; Glass - Clear Fast; Metal - Aluminium | 1 | M008_ | Nau Santa Eulalia | 0.919 | 0.25732 | 0.795 | 0.0590257 | 1.4922 | 10.8322 | 6.09724 | 2.2872 | 11.6272 | 426573 | 4579789
M011 | 197.021 | M011 | Espai d'atenció; Nau Santa Eulàlia | Metal - Stainless Steel; Paint - Vermilion; Plastic - Laminate; Glass - Clear Fast; Metal - Aluminium | 1 | M011_ | Nau Santa Eulalia | 0.919 | 0.25732 | 0.795 | 0.0590257 | 1.335 | 10.675 | 6.09724 | 2.13 | 11.47 | 426555 | 4579783
M009 | 197.021 | M009 | Espai d'atenció; Nau Santa Eulàlia | Metal - Stainless Steel; Paint - Vermilion; Glass - Clear Fast; Metal - Aluminium | 4 | M009_ | Nau Santa Eulalia | 0.38 | 0.1064 | 0.925 | 0.0380121 | 1.335 | 10.675 | 3.08247 | 2.26 | 11.6 | 426585 | 4579793
M007 | 102.767 | M007 | Espai d'espera; Nau Santa Eulàlia | Metal - Stainless Steel; Paint - Vermilion; Glass - Clear Fast; Metal - Aluminium | 4 | M007_ | Nau Santa Eulalia | 0.38 | 0.1064 | 0.795 | 0.0352821 | 1.4922 | 10.8322 | 2.74187 | 2.2872 | 11.6272 | 426569 | 4579788
M012 | 283.831 | M012 | Espai d'espera; Nau Santa Eulàlia | Metal - Stainless Steel; Paint - Vermilion; Glass - Clear Fast; Metal - Aluminium | 4 | M012_ | Nau Santa Eulalia | 0.38 | 0.1064 | 0.795 | 0.0352821 | 1.335 | 10.675 | 2.74187 | 2.13 | 11.47 | 426560 | 4579785
M010 | 17.0205 | M010 | Espai de treball; Nau Santa Eulàlia | Metal - Stainless Steel; Paint - Vermilion; Glass - Clear Fast; Metal - Aluminium | 4 | M010_ | Nau Santa Eulalia | 0.38 | 0.1064 | 0.795 | 0.0352821 | 1.335 | 10.675 | 2.74187 | 2.13 | 11.47 | 426546 | 4579786

# IfcBuildingElementProxy: Gypsum Plasterboard 30 (373)
In: planta baixa
Classification: 40.10.20.10 Revestiments discontinus (GuBIMclass CA); Material: Gypsum Plasterboard
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Layer: 00_PLAYWOOD; Building Material / Composite / Profile / Fill: Gypsum Plasterboard; Building Material: Gypsum Plasterboard; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Building Materials (All): Gypsum Plasterboard; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 40.10.20.10 Revestiments discontinus; 104.AMB.ClassificacioCodi: 40.10.20.10; 105.AMB.ClassificacioDescripcio: Revestiments discontinus; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; End Thickness of the Wall: 0.03 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.03 m; Top Offset: 0 m; Thickness: 0.03 m; Insulation Skin Thickness: 0 m
5 AMB.Geometria - 502.AMB.Amplada: 0.03 m; 504.AMB.Gruix: 0.03 m; 506.AMB.Profunditat: 0 m
Component Quantities - Gypsum Plasterboard, Component Thickness: 0.03 m; Gypsum Plasterboard, Rectangular Component Width: 0.03 m
Name | Reference Line Location | Inside Face Surface = Edge Surface | Outside Face Surface | Element ID = Hotlink and Element ID = Parent ID | Colliding Zones | Surfaces (All) | Number of Openings | 107.AMB.NomTipus | 109.AMB.CodiTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_107.NomTipus | Gypsum Plasterboard, Embodied Carbon | Gypsum Plasterboard, Embodied Energy (MJ) | Number of Windows | Maximum Height of the Wall (m) | Minimum Height of the Wall (m) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Surface Area of the Wall Inside Face (Conditional) (m2) | Length of the Wall Outside Face (Conditional) (m) | Surface Area of the Wall Outside Face (Conditional) (m2) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = Gypsum Plasterboard, Rectangular Component Height (m) | Volume (Net) (m3) = Gypsum Plasterboard, Component Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | 3D Length (m) | Volume (Conditional) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | 503.AMB.Altura (m) | Gypsum Plasterboard, Mass (kg) | Gypsum Plasterboard, Projected Component Area (Net) (m2) | Gypsum Plasterboard, Projected Component Area (Gross) (m2) | Gypsum Plasterboard, Component Cross Section Area (m2) | Gypsum Plasterboard, Component Volume (Gross) (m3)
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Lavabo; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 0.917891 (kgCO₂) | 15.8866 | 0 | 0.397 | 0.397 | 0 | 0 | 0.21957 | 0.0871691 | 0.0871691 | 0 | 0.21957 | 0.21957 | 0.0871691 | 0.21957 | 0.0871691 | 0.0871691 | 0.0871691 | 0.21957 | 0.21957 | 0.00658709 | 0.397 | 0.00261507 | 2.475 | 11.815 | 0.21957 | 0.00261507 | 0.00261507 | 0.499139 | 2.872 | 12.212 | 2.475 | 11.815 | 0.0369942 | 2.44 | 2.35357 | 0.0871691 | 0.0871691 | 0.01191 | 0.00261507
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 27.0732 (kgCO₂) | 468.574 | 0 | 1.80253 | 1.79383 | 0 | 0 | 1.43 | 2.57651 | 2.57762 | 0 | 1.43 | 1.43 | 2.57651 | 1.43 | 2.57762 | 2.57762 | 2.57762 | 1.43 | 1.43 | 0.0429 | 1.80253 | 0.0771316 | 2.475 | 11.815 | 1.43 | 0.0771316 | 0.0773286 | 2.92 | 4.27753 | 13.6175 | 2.475 | 11.815 | 0.150797 | 2.44 | 69.4184 | 2.57762 | 2.57762 | 0.0540759 | 0.0773286
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.6795 (kgCO₂) | 323.3 | 0 | 1.44693 | 1.44693 | 0 | 0 | 1.226 | 1.77393 | 1.77393 | 0 | 1.226 | 1.226 | 1.77393 | 1.226 | 1.77393 | 1.77393 | 1.77393 | 1.226 | 1.226 | 0.03678 | 1.44693 | 0.053218 | 2.872 | 12.212 | 1.226 | 0.053218 | 0.053218 | 2.512 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.160376 | 2.44 | 47.8962 | 1.77393 | 1.77393 | 0.0434079 | 0.053218
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 9.3529 (kgCO₂) | 161.877 | 0 | 0.890109 | 0.890109 | 0 | 0 | 0.997871 | 0.888214 | 0.888214 | 0 | 0.997871 | 0.997871 | 0.888214 | 0.997871 | 0.888214 | 0.888214 | 0.888214 | 0.997871 | 0.997871 | 0.0299361 | 0.890109 | 0.0266464 | 2.47 | 11.81 | 0.997871 | 0.0266464 | 0.0266464 | 2.05574 | 3.36011 | 12.7001 | 2.47 | 11.81 | 0.113279 | 2.44 | 23.9818 | 0.888214 | 0.888214 | 0.0267033 | 0.0266464
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 30.2655 (kgCO₂) | 523.826 | 0 | 2.01217 | 2.00375 | 0 | 0 | 1.43141 | 2.87969 | 2.86875 | 0 | 1.43141 | 1.43141 | 2.87969 | 1.43141 | 2.86875 | 2.87969 | 2.86875 | 1.43141 | 1.43141 | 0.0429424 | 2.6 | 0.0862265 | 2.872 | 12.212 | 1.43141 | 0.0862265 | 0.0862265 | 2.92283 | 4.88417 | 14.2242 | 2.872 | 12.212 | 0.207735 | 2.44 | 77.6039 | 2.87969 | 2.87969 | 0.078 | 0.0862265
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Enva_140 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 27.8843 (kgCO₂) | 482.614 | 0 | 2.6 | 0 | 0 | 0 | 1.03709 | 2.61949 | 2.67668 | 0 | 1.02949 | 1.0447 | 2.61949 | 1.02949 | 2.67668 | 2.71621 | 2.7734 | 1.0447 | 1.02949 | 0.0305548 | 2.6 | 0.0794426 | 0.27 | 9.61 | 1.02949 | 0.0794426 | 0.0823442 | 2.13782 | 2.87 | 12.21 | 0.27 | 9.61 | 0.13911 | 2.44 | 71.4983 | 2.67668 | 2.67668 | 0.078 | 0.0794426
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 12.3355 (kgCO₂) | 213.499 | 0 | 1.44693 | 0 | 0.308745 | 0.308745 | 1.023 | 1.17146 | 1.17146 | 0.00926235 | 1.023 | 0.570356 | 1.48021 | 0.570356 | 1.48021 | 1.48021 | 1.48021 | 1.023 | 1.023 | 0.010261 | 1.44693 | 0.0351439 | 2.872 | 12.212 | 1.023 | 0.0444062 | 0.0444062 | 2.106 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.100555 | 2.44 | 31.6295 | 1.17146 | 1.48021 | 0.0434079 | 0.0444062 | ArchiCADProperties - ID of Connected Openings: OP - 006; OP - 004
2 x T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.8928 (kgCO₂) | 326.991 | 0 | 1.44693 | 1.44693 | 0 | 0 | 1.24 | 1.79419 | 1.79419 | 0 | 1.24 | 1.24 | 1.79419 | 1.24 | 1.79419 | 1.79419 | 1.79419 | 1.24 | 1.24 | 0.0372 | 1.44693 | 0.0538257 | 2.872 | 12.212 | 1.24 | 0.0538257 | 0.0538257 | 2.54 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.161216 | 2.44 | 48.4432 | 1.79419 | 1.79419 | 0.0434079 | 0.0538257
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 23.7859 (kgCO₂) | 411.68 | 0 | 1.44693 | 0 | 0 | 0 | 1.56225 | 2.25729 | 2.26046 | 0 | 1.56225 | 1.56225 | 2.25729 | 1.56225 | 2.26046 | 2.25729 | 2.26046 | 1.56225 | 1.56225 | 0.0468345 | 1.44693 | 0.0677662 | 2.872 | 12.212 | 1.56225 | 0.0677662 | 0.0677662 | 3.18449 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.137077 | 2.44 | 60.9896 | 2.26046 | 2.26046 | 0.0434079 | 0.0677662
2 x T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.6555 (kgCO₂) | 288.268 | 0 | 1.44693 | 0 | 0.497518 | 0.497518 | 1.437 | 1.58172 | 1.58172 | 0.0149255 | 1.437 | 0.341001 | 2.07924 | 0.341001 | 2.07924 | 2.07924 | 2.07924 | 1.437 | 1.437 | 0.01023 | 1.44693 | 0.0474516 | 2.872 | 12.212 | 1.437 | 0.0623771 | 0.0623771 | 2.934 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.112919 | 2.44 | 42.7064 | 1.58172 | 2.07924 | 0.0434079 | 0.0623771 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 30.9974 (kgCO₂) | 536.494 | 0 | 2.01058 | 0 | 0 | 0 | 1.49046 | 2.99907 | 2.92454 | 0 | 1.49046 | 1.49046 | 2.99907 | 1.49046 | 2.92454 | 2.99907 | 2.98467 | 1.49046 | 1.49046 | 0.0440157 | 2.6 | 0.0883117 | 2.872 | 12.212 | 1.49195 | 0.0883117 | 0.0897561 | 3.04091 | 4.88258 | 14.2226 | 2.872 | 12.212 | 0.149641 | 2.44 | 79.4805 | 2.99907 | 2.99907 | 0.078 | 0.0883117
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 27.734 (kgCO₂) | 480.011 | 0 | 1.44693 | 0 | 0 | 0 | 1.81938 | 2.63511 | 2.63251 | 0 | 1.81938 | 1.81938 | 2.63511 | 1.81938 | 2.63251 | 2.63511 | 2.63251 | 1.81938 | 1.81938 | 0.0546082 | 1.44693 | 0.0790142 | 2.872 | 12.212 | 1.82117 | 0.0790142 | 0.0790142 | 3.69875 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.152624 | 2.44 | 71.1128 | 2.63511 | 2.63511 | 0.0434079 | 0.0790142
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.451 (kgCO₂) | 319.344 | 0 | 1.44693 | 0 | 0 | 0 | 1.241 | 1.75223 | 1.75223 | 0 | 1.241 | 1.241 | 1.75223 | 1.241 | 1.75223 | 1.79564 | 1.79564 | 1.241 | 1.241 | 0.03633 | 1.44693 | 0.0525669 | 2.872 | 12.212 | 1.21113 | 0.0525669 | 0.0538691 | 2.542 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.159476 | 2.44 | 47.3102 | 1.75241 | 1.75241 | 0.0434079 | 0.0525669
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.9081 (kgCO₂) | 327.255 | 0 | 1.44693 | 1.44693 | 0 | 0 | 1.241 | 1.79564 | 1.79564 | 0 | 1.241 | 1.241 | 1.79564 | 1.241 | 1.79564 | 1.79564 | 1.79564 | 1.241 | 1.241 | 0.03723 | 1.44693 | 0.0538691 | 2.872 | 12.212 | 1.241 | 0.0538691 | 0.0538691 | 2.542 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.161276 | 2.44 | 48.4822 | 1.79564 | 1.79564 | 0.0434079 | 0.0538691
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.6555 (kgCO₂) | 288.268 | 0 | 1.44693 | 0 | 0.497518 | 0.497518 | 1.437 | 1.58172 | 1.58172 | 0.0149255 | 1.437 | 0.341001 | 2.07924 | 0.341001 | 2.07924 | 2.07924 | 2.07924 | 1.437 | 1.437 | 0.01023 | 1.44693 | 0.0474516 | 2.872 | 12.212 | 1.437 | 0.0623771 | 0.0623771 | 2.934 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.126538 | 2.44 | 42.7064 | 1.58172 | 2.07924 | 0.0434079 | 0.0623771 | ArchiCADProperties - ID of Connected Openings: OP - 005; OP - 005
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 12.3458 (kgCO₂) | 213.678 | 0 | 1.44693 | 0 | 0.307764 | 0.307764 | 1.023 | 1.17244 | 1.17244 | 0.00923292 | 1.023 | 0.57007 | 1.48021 | 0.57007 | 1.48021 | 1.48021 | 1.48021 | 1.023 | 1.023 | 0.0104111 | 1.44693 | 0.0351733 | 2.872 | 12.212 | 1.023 | 0.0444062 | 0.0444062 | 2.106 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.10062 | 2.44 | 31.656 | 1.17244 | 1.48021 | 0.0434079 | 0.0444062 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 12.3445 (kgCO₂) | 213.656 | 0 | 1.44693 | 0 | 0.304993 | 0.304993 | 1.021 | 1.17232 | 1.17232 | 0.00914978 | 1.021 | 0.570155 | 1.47731 | 0.570155 | 1.47731 | 1.47731 | 1.47731 | 1.021 | 1.021 | 0.0104736 | 1.44693 | 0.0351696 | 2.872 | 12.212 | 1.021 | 0.0443194 | 0.0443194 | 2.102 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.100683 | 2.44 | 31.6527 | 1.17232 | 1.47731 | 0.0434079 | 0.0443194 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 32.7767 (kgCO₂) | 567.289 | 0 | 2.598 | 0 | 0 | 0 | 1.45901 | 3.1127 | 3.1127 | 0 | 1.45902 | 1.45901 | 3.1127 | 1.45901 | 3.1127 | 4.1802 | 4.1802 | 1.45901 | 1.45901 | 0.0428705 | 2.598 | 0.093381 | 1.71425 | 11.0543 | 1.42902 | 0.093381 | 0.125406 | 2.97802 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.163681 | 2.598 | 84.0429 | 3.1127 | 3.71258 | 0.07794 | 0.111378
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 37.4521 (kgCO₂) | 648.21 | 0 | 2.598 | 0 | 0 | 0 | 1.39902 | 3.55671 | 3.55671 | 0 | 1.39902 | 1.39902 | 3.55671 | 1.39902 | 3.55671 | 3.84249 | 3.84249 | 1.39902 | 1.39902 | 0.0410705 | 2.598 | 0.106701 | 1.71425 | 11.0543 | 1.36902 | 0.106701 | 0.115275 | 2.85803 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.160081 | 2.598 | 96.0311 | 3.55671 | 3.55671 | 0.07794 | 0.106701
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 46.982 (kgCO₂) | 813.151 | 0 | 2.60008 | 2.60008 | 0 | 0 | 1.716 | 4.46173 | 4.46173 | 0 | 1.716 | 1.716 | 4.46173 | 1.716 | 4.46173 | 4.46173 | 4.46173 | 1.716 | 1.716 | 0.05148 | 2.60008 | 0.133852 | 4.31425 | 13.6543 | 1.716 | 0.133852 | 0.133852 | 3.492 | 6.91433 | 16.2543 | 4.31425 | 13.6543 | 0.258965 | 2.60008 | 120.467 | 4.46173 | 4.46173 | 0.0780023 | 0.133852
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 29.8429 (kgCO₂) | 516.512 | 0 | 1.98413 | 1.97571 | 0 | 0 | 1.43141 | 2.82861 | 2.83956 | 0 | 1.43141 | 1.43141 | 2.82861 | 1.43141 | 2.83956 | 2.82861 | 2.83956 | 1.43141 | 1.43141 | 0.0429424 | 2.6 | 0.0850225 | 2.872 | 12.212 | 1.43141 | 0.0850225 | 0.0850225 | 2.92283 | 4.85613 | 14.1961 | 2.872 | 12.212 | 0.206053 | 2.44 | 76.5203 | 2.83956 | 2.83956 | 0.078 | 0.0850225
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.369 (kgCO₂) | 317.925 | 0 | 1.44693 | 1.44693 | 0 | 0 | 1.20562 | 1.74444 | 1.74444 | 0 | 1.20562 | 1.20562 | 1.74444 | 1.20562 | 1.74444 | 1.74444 | 1.74444 | 1.20562 | 1.20562 | 0.0361685 | 1.44693 | 0.0523333 | 2.872 | 12.212 | 1.20562 | 0.0523333 | 0.0523333 | 2.47124 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.159153 | 2.44 | 47.1 | 1.74444 | 1.74444 | 0.0434079 | 0.0523333
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 39.1248 (kgCO₂) | 677.159 | 0 | 2.60008 | 0 | 0 | 0 | 1.45901 | 3.71555 | 3.71555 | 0 | 1.45902 | 1.45901 | 3.71555 | 1.45901 | 3.71555 | 4.18355 | 4.18355 | 1.45901 | 1.45901 | 0.0428705 | 2.60008 | 0.111467 | 4.31425 | 13.6543 | 1.42902 | 0.111467 | 0.125506 | 2.97802 | 6.91433 | 16.2543 | 4.31425 | 13.6543 | 0.163743 | 2.60008 | 100.32 | 3.71555 | 3.71555 | 0.0780023 | 0.111467
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.6651 (kgCO₂) | 288.434 | 0 | 1.44693 | 0 | 0.49661 | 0.49661 | 1.437 | 1.58263 | 1.58263 | 0.0148983 | 1.437 | 0.343001 | 2.07924 | 0.343001 | 2.07924 | 2.07924 | 2.07924 | 1.437 | 1.437 | 0.01029 | 1.44693 | 0.0474788 | 2.872 | 12.212 | 1.437 | 0.0623771 | 0.0623771 | 2.934 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.112979 | 2.44 | 42.7309 | 1.58263 | 2.07924 | 0.0434079 | 0.0623771 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.2482 (kgCO₂) | 281.218 | 0 | 1.44693 | 1.44693 | 0 | 0 | 1.06642 | 1.54303 | 1.54303 | 0 | 1.06642 | 1.06642 | 1.54303 | 1.06642 | 1.54303 | 1.54303 | 1.54303 | 1.06642 | 1.06642 | 0.0319926 | 1.44693 | 0.046291 | 2.872 | 12.212 | 1.06642 | 0.046291 | 0.046291 | 2.19284 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.150801 | 2.44 | 41.6619 | 1.54303 | 1.54303 | 0.0434079 | 0.046291
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 5.42427 (kgCO₂) | 93.8816 | 0 | 0.75198 | 0.75198 | 0.456544 | 0.456544 | 0.797 | 0.515126 | 0.515126 | 0.0136963 | 0.797 | 0 | 0.97167 | 0 | 0.97167 | 0.97167 | 0.97167 | 0.797 | 0.797 | 0 | 1.21916 | 0.0154538 | 5.69517 | 15.0352 | 0.797 | 0.0291501 | 0.0291501 | 1.654 | 6.91433 | 16.2543 | 6.16235 | 15.5023 | 0.0643082 | 1.21916 | 13.9084 | 0.515126 | 0.97167 | 0.0365748 | 0.0291501 | ArchiCADProperties - ID of Connected Openings: OP - 003
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 12.2996 (kgCO₂) | 212.878 | 0 | 1.44693 | 0 | 0.309257 | 0.309257 | 1.021 | 1.16806 | 1.16806 | 0.0092777 | 1.021 | 0.568356 | 1.47731 | 0.568356 | 1.47731 | 1.47731 | 1.47731 | 1.021 | 1.021 | 0.0102524 | 1.44693 | 0.0350417 | 2.872 | 12.212 | 1.021 | 0.0443194 | 0.0443194 | 2.102 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.100401 | 2.44 | 31.5375 | 1.16806 | 1.47731 | 0.0434079 | 0.0443194 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 24.9776 (kgCO₂) | 432.305 | 0 | 2.59808 | 2.59808 | 0 | 0 | 0.913 | 2.37204 | 2.37204 | 0 | 0.913 | 0.913 | 2.37204 | 0.913 | 2.37204 | 2.37204 | 2.37204 | 0.913 | 0.913 | 0.02739 | 2.59808 | 0.0711613 | 4.31625 | 13.6563 | 0.913 | 0.0711613 | 0.0711613 | 1.886 | 6.91433 | 16.2543 | 4.31625 | 13.6563 | 0.210665 | 2.59808 | 64.0452 | 2.37204 | 2.37204 | 0.0779423 | 0.0711613
2 x T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 12.6586 (kgCO₂) | 219.092 | 0 | 1.50834 | 1.50834 | 0 | 0 | 0.797 | 1.20215 | 1.20215 | 0 | 0.797 | 0.797 | 1.20215 | 0.797 | 1.20215 | 1.20215 | 1.20215 | 0.797 | 0.797 | 0.02391 | 1.50834 | 0.0360645 | 1.71425 | 11.0543 | 0.797 | 0.0360645 | 0.0360645 | 1.654 | 3.2226 | 12.5626 | 1.71425 | 11.0543 | 0.138321 | 1.50834 | 32.4581 | 1.20215 | 1.20215 | 0.0452503 | 0.0360645
2 x T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 41.067 (kgCO₂) | 710.775 | 0 | 2.6 | 2.6 | 0 | 0 | 1.5 | 3.9 | 3.9 | 0 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.117 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.246 | 2.44 | 105.3 | 3.9 | 3.9 | 0.078 | 0.117
5 x Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 17.2349 (kgCO₂) | 298.296 | 0 | 2.598 | 2.598 | 0 | 0 | 0.63 | 1.63674 | 1.63674 | 0 | 0.63 | 0.63 | 1.63674 | 0.63 | 1.63674 | 1.63674 | 1.63674 | 0.63 | 0.63 | 0.0189 | 2.598 | 0.0491022 | 1.71425 | 11.0543 | 0.63 | 0.0491022 | 0.0491022 | 1.32 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.19368 | 2.598 | 44.192 | 1.63674 | 1.63674 | 0.07794 | 0.0491022
2 x T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 40.0106 (kgCO₂) | 692.491 | 0 | 2.6 | 2.6 | 0 | 0 | 1.46141 | 3.79967 | 3.79967 | 0 | 1.46141 | 1.46141 | 3.79967 | 1.46141 | 3.79967 | 3.79967 | 3.79967 | 1.46141 | 1.46141 | 0.0438424 | 2.6 | 0.11399 | 0.27 | 9.61 | 1.46141 | 0.11399 | 0.11399 | 2.98283 | 2.87 | 12.21 | 0.27 | 9.61 | 0.243685 | 2.44 | 102.591 | 3.79967 | 3.79967 | 0.078 | 0.11399
Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 17.8094 (kgCO₂) | 308.239 | 0 | 2.598 | 2.598 | 0 | 0 | 0.651 | 1.6913 | 1.6913 | 0 | 0.651 | 0.651 | 1.6913 | 0.651 | 1.6913 | 1.6913 | 1.6913 | 0.651 | 0.651 | 0.01953 | 2.598 | 0.0507389 | 1.71425 | 11.0543 | 0.651 | 0.0507389 | 0.0507389 | 1.362 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.19494 | 2.598 | 45.665 | 1.6913 | 1.6913 | 0.07794 | 0.0507389
F5 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F5 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 24.9961 (kgCO₂) | 432.625 | 0 | 2.6 | 2.6 | 0 | 0 | 0.913 | 2.3738 | 2.3738 | 0 | 0.913 | 0.913 | 2.3738 | 0.913 | 2.3738 | 2.3738 | 2.3738 | 0.913 | 0.913 | 0.02739 | 2.6 | 0.071214 | 1.71425 | 11.0543 | 0.913 | 0.071214 | 0.071214 | 1.886 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.21078 | 2.6 | 64.0926 | 2.3738 | 2.3738 | 0.078 | 0.071214
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 30.3092 (kgCO₂) | 524.582 | 0 | 1.98254 | 1.9741 | 0 | 0 | 1.45496 | 2.8728 | 2.88393 | 0 | 1.45496 | 1.45496 | 2.8728 | 1.45496 | 2.88393 | 2.8728 | 2.88393 | 1.45496 | 1.45496 | 0.0436487 | 2.6 | 0.086351 | 2.872 | 12.212 | 1.45496 | 0.086351 | 0.086351 | 2.96991 | 4.85454 | 14.1945 | 2.872 | 12.212 | 0.207392 | 2.44 | 77.7159 | 2.88393 | 2.88393 | 0.078 | 0.086351
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 40.8373 (kgCO₂) | 706.8 | 0 | 2.6 | 2.6 | 0 | 0 | 1.49161 | 3.87819 | 3.87819 | 0 | 1.49161 | 1.49161 | 3.87819 | 1.49161 | 3.87819 | 3.87819 | 3.87819 | 1.49161 | 1.49161 | 0.0447483 | 2.6 | 0.116346 | 0.27 | 9.61 | 1.49161 | 0.116346 | 0.116346 | 3.04322 | 2.87 | 12.21 | 0.27 | 9.61 | 0.245497 | 2.44 | 104.711 | 3.87819 | 3.87819 | 0.078 | 0.116346
2 x Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral; Sala de reunions | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 15.6055 (kgCO₂) | 270.094 | 0 | 2.6 | 2.6 | 0 | 0 | 0.57 | 1.482 | 1.482 | 0 | 0.57 | 0.57 | 1.482 | 0.57 | 1.482 | 1.482 | 1.482 | 0.57 | 0.57 | 0.0171 | 2.6 | 0.04446 | 1.71425 | 11.0543 | 0.57 | 0.04446 | 0.04446 | 1.2 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.1902 | 2.6 | 40.014 | 1.482 | 1.482 | 0.078 | 0.04446
3 x Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral; Sala de reunions | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 16.7553 (kgCO₂) | 289.996 | 0 | 2.6 | 2.6 | 0 | 0 | 0.612 | 1.5912 | 1.5912 | 0 | 0.612 | 0.612 | 1.5912 | 0.612 | 1.5912 | 1.5912 | 1.5912 | 0.612 | 0.612 | 0.01836 | 2.6 | 0.047736 | 1.71425 | 11.0543 | 0.612 | 0.047736 | 0.047736 | 1.284 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.19272 | 2.6 | 42.9624 | 1.5912 | 1.5912 | 0.078 | 0.047736
Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 4.3224 (kgCO₂) | 74.8107 | 0 | 2.598 | 2.598 | 0 | 0 | 0.158 | 0.410484 | 0.410484 | 0 | 0.158 | 0.158 | 0.410484 | 0.158 | 0.410484 | 0.410484 | 0.410484 | 0.158 | 0.158 | 0.00474 | 2.598 | 0.0123145 | 1.71425 | 11.0543 | 0.158 | 0.0123145 | 0.0123145 | 0.376 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.16536 | 2.598 | 11.0831 | 0.410484 | 0.410484 | 0.07794 | 0.0123145
Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral; Sala de reunions | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 17.2755 (kgCO₂) | 298.999 | 0 | 2.6 | 2.6 | 0 | 0 | 0.631 | 1.6406 | 1.6406 | 0 | 0.631 | 0.631 | 1.6406 | 0.631 | 1.6406 | 1.6406 | 1.6406 | 0.631 | 0.631 | 0.01893 | 2.6 | 0.049218 | 1.71425 | 11.0543 | 0.631 | 0.049218 | 0.049218 | 1.322 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.19386 | 2.6 | 44.2962 | 1.6406 | 1.6406 | 0.078 | 0.049218
2 x Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 16.7424 (kgCO₂) | 289.773 | 0 | 2.598 | 2.598 | 0 | 0 | 0.612 | 1.58998 | 1.58998 | 0 | 0.612 | 0.612 | 1.58998 | 0.612 | 1.58998 | 1.58998 | 1.58998 | 0.612 | 0.612 | 0.01836 | 2.598 | 0.0476993 | 1.71425 | 11.0543 | 0.612 | 0.0476993 | 0.0476993 | 1.284 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.1926 | 2.598 | 42.9294 | 1.58998 | 1.58998 | 0.07794 | 0.0476993
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 37.8394 (kgCO₂) | 654.913 | 0 | 2.6 | 2.6 | 0 | 0 | 1.38211 | 3.59349 | 3.59349 | 0 | 1.38211 | 1.38211 | 3.59349 | 1.38211 | 3.59349 | 3.59349 | 3.59349 | 1.38211 | 1.38211 | 0.0414633 | 2.6 | 0.107805 | 1.71425 | 11.0543 | 1.38211 | 0.107805 | 0.107805 | 2.82422 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.238927 | 2.6 | 97.0242 | 3.59349 | 3.59349 | 0.078 | 0.107805
Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral; Sala de reunions | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 16.153 (kgCO₂) | 279.571 | 0 | 2.6 | 2.6 | 0 | 0 | 0.59 | 1.534 | 1.534 | 0 | 0.59 | 0.59 | 1.534 | 0.59 | 1.534 | 1.534 | 1.534 | 0.59 | 0.59 | 0.0177 | 2.6 | 0.04602 | 1.71425 | 11.0543 | 0.59 | 0.04602 | 0.04602 | 1.24 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.1914 | 2.6 | 41.418 | 1.534 | 1.534 | 0.078 | 0.04602
F5 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F5 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 24.1804 (kgCO₂) | 418.508 | 0 | 2.6 | 0 | 0 | 0 | 0.913061 | 2.29634 | 2.37396 | 0 | 0.913 | 0.913123 | 2.29634 | 0.913 | 2.37396 | 2.58212 | 2.5818 | 0.913123 | 0.913 | 0.0297919 | 2.6 | 0.0688901 | 1.71425 | 11.0543 | 0.993123 | 0.0688901 | 0.0774588 | 1.88612 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.134286 | 2.6 | 62.0011 | 2.37396 | 2.37396 | 0.078 | 0.0688901
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 5.4186 (kgCO₂) | 93.7834 | 0 | 0.752025 | 0.752025 | 0.455864 | 0.455864 | 0.796 | 0.514587 | 0.514587 | 0.0136759 | 0.796 | 0 | 0.970451 | 0 | 0.970451 | 0.970451 | 0.970451 | 0.796 | 0.796 | 0 | 1.21916 | 0.0154376 | 5.69517 | 15.0352 | 0.796 | 0.0291135 | 0.0291135 | 1.652 | 6.91433 | 16.2543 | 6.1623 | 15.5023 | 0.0642812 | 1.21916 | 13.8938 | 0.514587 | 0.970451 | 0.0365748 | 0.0291135 | ArchiCADProperties - ID of Connected Openings: OP - 003
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 27.5578 (kgCO₂) | 476.961 | 0 | 1.98047 | 1.97281 | 0 | 0 | 1.324 | 2.61201 | 2.62213 | 0 | 1.324 | 1.324 | 2.61201 | 1.324 | 2.62213 | 2.61201 | 2.62213 | 1.324 | 1.324 | 0.03972 | 2.6 | 0.0785122 | 2.872 | 12.212 | 1.324 | 0.0785122 | 0.0785122 | 2.708 | 4.85247 | 14.1925 | 2.872 | 12.212 | 0.199309 | 2.44 | 70.661 | 2.62213 | 2.62213 | 0.078 | 0.0785122
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 31.2204 (kgCO₂) | 540.353 | 0 | 1.98043 | 1.97277 | 0 | 0 | 1.5 | 2.95916 | 2.97064 | 0 | 1.5 | 1.5 | 2.95916 | 1.5 | 2.97064 | 2.95916 | 2.97064 | 1.5 | 1.5 | 0.045 | 2.6 | 0.088947 | 2.872 | 12.212 | 1.5 | 0.088947 | 0.088947 | 3.06 | 4.85243 | 14.1924 | 2.872 | 12.212 | 0.210035 | 2.44 | 80.0523 | 2.97064 | 2.97064 | 0.078 | 0.088947
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 31.4934 (kgCO₂) | 545.078 | 0 | 2.59808 | 0 | 0 | 0 | 1.15124 | 2.99067 | 2.99099 | 0 | 1.15124 | 1.15124 | 2.99067 | 1.15124 | 2.99099 | 2.9907 | 2.99102 | 1.15124 | 1.15124 | 0.0345351 | 2.59808 | 0.0897248 | 4.31625 | 13.6563 | 1.15123 | 0.0897248 | 0.0897257 | 2.36249 | 6.91433 | 16.2543 | 4.31625 | 13.6563 | 0.147013 | 2.59808 | 80.7524 | 2.99099 | 2.99099 | 0.0779423 | 0.0897248
2 x F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 23.4702 (kgCO₂) | 406.214 | 0 | 2.6 | 1.2222 | 1.50732 | 1.50732 | 1.437 | 2.22888 | 2.22888 | 0.0452195 | 1.437 | 1.437 | 3.7362 | 1.437 | 3.7362 | 3.7362 | 3.7362 | 1.437 | 1.437 | 0.04311 | 2.6 | 0.0668665 | 0.27 | 9.61 | 1.437 | 0.112086 | 0.112086 | 2.934 | 2.87 | 12.21 | 0.27 | 9.61 | 0.126732 | 2.44 | 60.1799 | 2.22888 | 3.7362 | 0.078 | 0.112086 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.5243 (kgCO₂) | 355.228 | 0 | 2.6 | 1.22422 | 0.710676 | 0.710676 | 1.023 | 1.94912 | 1.94912 | 0.0213203 | 1.023 | 1.023 | 2.6598 | 1.023 | 2.6598 | 2.6598 | 2.6598 | 1.023 | 1.023 | 0.03069 | 2.6 | 0.0584737 | 0.27 | 9.61 | 1.023 | 0.079794 | 0.079794 | 2.106 | 2.87 | 12.21 | 0.27 | 9.61 | 0.143773 | 2.44 | 52.6264 | 1.94912 | 2.6598 | 0.078 | 0.079794 | ArchiCADProperties - ID of Connected Openings: OP - 003; OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.4288 (kgCO₂) | 353.575 | 0 | 2.6 | 1.22422 | 0.714544 | 0.714544 | 1.021 | 1.94006 | 1.94006 | 0.0214363 | 1.021 | 1.021 | 2.6546 | 1.021 | 2.6546 | 2.6546 | 2.6546 | 1.021 | 1.021 | 0.03063 | 2.6 | 0.0582017 | 0.27 | 9.61 | 1.021 | 0.079638 | 0.079638 | 2.102 | 2.87 | 12.21 | 0.27 | 9.61 | 0.143448 | 2.44 | 52.3815 | 1.94006 | 2.6546 | 0.078 | 0.079638 | ArchiCADProperties - ID of Connected Openings: OP - 003; OP - 003
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 33.9761 (kgCO₂) | 588.048 | 0 | 2.6 | 2.6 | 0 | 0 | 1.241 | 3.2266 | 3.2266 | 0 | 1.241 | 1.241 | 3.2266 | 1.241 | 3.2266 | 3.2266 | 3.2266 | 1.241 | 1.241 | 0.03723 | 2.6 | 0.096798 | 0.27 | 9.61 | 1.241 | 0.096798 | 0.096798 | 2.542 | 2.87 | 12.21 | 0.27 | 9.61 | 0.23046 | 2.44 | 87.1182 | 3.2266 | 3.2266 | 0.078 | 0.096798
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 33.5654 (kgCO₂) | 580.94 | 0 | 2.6 | 2.6 | 0 | 0 | 1.226 | 3.1876 | 3.1876 | 0 | 1.226 | 1.226 | 3.1876 | 1.226 | 3.1876 | 3.1876 | 3.1876 | 1.226 | 1.226 | 0.03678 | 2.6 | 0.095628 | 0.27 | 9.61 | 1.226 | 0.095628 | 0.095628 | 2.512 | 2.87 | 12.21 | 0.27 | 9.61 | 0.22956 | 2.44 | 86.0652 | 3.1876 | 3.1876 | 0.078 | 0.095628
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 31.3067 (kgCO₂) | 541.847 | 0 | 2.6 | 1.105 | 0 | 0 | 1.241 | 2.9731 | 2.9731 | 0 | 1.241 | 1.241 | 2.9731 | 1.241 | 2.9731 | 3.2266 | 3.2266 | 1.241 | 1.241 | 0.03723 | 2.6 | 0.089193 | 0.27 | 9.61 | 1.241 | 0.089193 | 0.096798 | 2.542 | 2.87 | 12.21 | 0.27 | 9.61 | 0.23046 | 2.44 | 80.2737 | 2.97313 | 3.2266 | 0.078 | 0.096798
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 23.4891 (kgCO₂) | 406.542 | 0 | 2.6 | 1.2222 | 1.50552 | 1.50552 | 1.437 | 2.23068 | 2.23068 | 0.0451655 | 1.437 | 1.437 | 3.7362 | 1.437 | 3.7362 | 3.7362 | 3.7362 | 1.437 | 1.437 | 0.04311 | 2.6 | 0.0669205 | 0.27 | 9.61 | 1.437 | 0.112086 | 0.112086 | 2.934 | 2.87 | 12.21 | 0.27 | 9.61 | 0.126808 | 2.44 | 60.2285 | 2.23068 | 3.7362 | 0.078 | 0.112086 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 23.4411 (kgCO₂) | 405.712 | 0 | 2.6 | 1.2222 | 1.51007 | 1.51007 | 1.437 | 2.22613 | 2.22613 | 0.0453021 | 1.437 | 1.437 | 3.7362 | 1.437 | 3.7362 | 3.7362 | 3.7362 | 1.437 | 1.437 | 0.04311 | 2.6 | 0.0667839 | 0.27 | 9.61 | 1.437 | 0.112086 | 0.112086 | 2.934 | 2.87 | 12.21 | 0.27 | 9.61 | 0.126672 | 2.44 | 60.1055 | 2.22613 | 3.7362 | 0.078 | 0.112086 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 33.0074 (kgCO₂) | 571.282 | 0 | 2.6 | 2.6 | 0 | 0 | 1.20562 | 3.13461 | 3.13461 | 0 | 1.20562 | 1.20562 | 3.13461 | 1.20562 | 3.13461 | 3.13461 | 3.13461 | 1.20562 | 1.20562 | 0.0361685 | 2.6 | 0.0940382 | 0.27 | 9.61 | 1.20562 | 0.0940382 | 0.0940382 | 2.47124 | 2.87 | 12.21 | 0.27 | 9.61 | 0.228337 | 2.44 | 84.6344 | 3.13461 | 3.13461 | 0.078 | 0.0940382
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 29.1965 (kgCO₂) | 505.323 | 0 | 2.6 | 2.6 | 0 | 0 | 1.06642 | 2.77269 | 2.77269 | 0 | 1.06642 | 1.06642 | 2.77269 | 1.06642 | 2.77269 | 2.77269 | 2.77269 | 1.06642 | 1.06642 | 0.0319926 | 2.6 | 0.0831808 | 0.27 | 9.61 | 1.06642 | 0.0831808 | 0.0831808 | 2.19284 | 2.87 | 12.21 | 0.27 | 9.61 | 0.219985 | 2.44 | 74.8627 | 2.77269 | 2.77269 | 0.078 | 0.0831808
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 30.7905 (kgCO₂) | 532.912 | 0 | 2.6 | 1.2622 | 0 | 0 | 1.24 | 2.92406 | 2.92409 | 0 | 1.24 | 1.24 | 2.92406 | 1.24 | 2.92409 | 3.224 | 3.224 | 1.24 | 1.24 | 0.0372 | 2.6 | 0.0877221 | 0.27 | 9.61 | 1.24 | 0.0877221 | 0.09672 | 2.54 | 2.87 | 12.21 | 0.27 | 9.61 | 0.20895 | 2.44 | 78.9499 | 2.92409 | 3.224 | 0.078 | 0.09672
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 30.8003 (kgCO₂) | 533.082 | 0 | 2.6 | 1.2622 | 0 | 0 | 1.24 | 2.92502 | 2.92499 | 0 | 1.24 | 1.24 | 2.92502 | 1.24 | 2.92499 | 3.224 | 3.224 | 1.24 | 1.24 | 0.0372 | 2.6 | 0.0877501 | 0.27 | 9.61 | 1.24 | 0.0877501 | 0.09672 | 2.54 | 2.87 | 12.21 | 0.27 | 9.61 | 0.20895 | 2.44 | 78.975 | 2.92502 | 3.224 | 0.078 | 0.09672
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.4678 (kgCO₂) | 354.251 | 0 | 2.6 | 1.2222 | 0.710836 | 0.710836 | 1.021 | 1.94376 | 1.94376 | 0.0213251 | 1.021 | 1.021 | 2.6546 | 1.021 | 2.6546 | 2.6546 | 2.6546 | 1.021 | 1.021 | 0.03063 | 2.6 | 0.0583129 | 0.27 | 9.61 | 1.021 | 0.079638 | 0.079638 | 2.102 | 2.87 | 12.21 | 0.27 | 9.61 | 0.1436 | 2.44 | 52.4816 | 1.94376 | 2.6546 | 0.078 | 0.079638 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.4598 (kgCO₂) | 354.111 | 0 | 2.6 | 1.22137 | 0.716803 | 0.716803 | 1.023 | 1.943 | 1.943 | 0.0215041 | 1.023 | 1.023 | 2.6598 | 1.023 | 2.6598 | 2.6598 | 2.6598 | 1.023 | 1.023 | 0.03069 | 2.6 | 0.0582899 | 0.27 | 9.61 | 1.023 | 0.079794 | 0.079794 | 2.106 | 2.87 | 12.21 | 0.27 | 9.61 | 0.14342 | 2.44 | 52.4609 | 1.943 | 2.6598 | 0.078 | 0.079794 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 42.7412 (kgCO₂) | 739.751 | 0 | 2.6 | 0 | 0 | 0 | 1.54611 | 4.05614 | 4.06184 | 0 | 1.56225 | 1.52998 | 4.05614 | 1.56225 | 4.06184 | 4.05614 | 4.06184 | 1.52998 | 1.56225 | 0.0468345 | 2.6 | 0.12177 | 0.27 | 9.61 | 1.56225 | 0.12177 | 0.12177 | 3.16628 | 2.87 | 12.21 | 0.27 | 9.61 | 0.171669 | 2.44 | 109.593 | 4.06184 | 4.06184 | 0.078 | 0.12177
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia; Office | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 41.067 (kgCO₂) | 710.775 | 0 | 2.6 | 2.6 | 0 | 0 | 1.5 | 3.9 | 3.9 | 0 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.117 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.246 | 2.44 | 105.3 | 3.9 | 3.9 | 0.078 | 0.117
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 49.8355 (kgCO₂) | 862.537 | 0 | 2.6 | 0 | 0 | 0 | 1.80525 | 4.73505 | 4.73038 | 0 | 1.81938 | 1.79112 | 4.73505 | 1.81938 | 4.73038 | 4.73505 | 4.73038 | 1.79112 | 1.81938 | 0.0546082 | 2.6 | 0.141981 | 0.27 | 9.61 | 1.82117 | 0.141981 | 0.141981 | 3.68171 | 2.87 | 12.21 | 0.27 | 9.61 | 0.187216 | 2.44 | 127.783 | 4.73505 | 4.73505 | 0.078 | 0.141981
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 33.1604 (kgCO₂) | 573.93 | 0 | 2.6 | 0 | 0 | 0 | 1.13121 | 3.14914 | 3.14914 | 0 | 1.13121 | 1.13121 | 3.14914 | 1.13121 | 3.14914 | 3.14914 | 3.14914 | 1.13121 | 1.13121 | 0.0363362 | 2.6 | 0.0944741 | 1.71425 | 11.0543 | 1.21121 | 0.0944741 | 0.0944741 | 2.32241 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.150672 | 2.6 | 85.0267 | 3.14914 | 3.14914 | 0.078 | 0.0944741
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Extradossat_170 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_170 | 13.1915 (kgCO₂) | 228.315 | 0 | 0.868161 | 0.868161 | 0 | 0 | 1.443 | 1.25276 | 1.25276 | 0 | 1.443 | 1.443 | 1.25276 | 1.443 | 1.25276 | 1.25276 | 1.25276 | 1.443 | 1.443 | 0.04329 | 0.868161 | 0.0375827 | 2.872 | 12.212 | 1.443 | 0.0375827 | 0.0375827 | 2.946 | 3.74016 | 13.0802 | 2.872 | 12.212 | 0.13867 | 2.44 | 33.8244 | 1.25276 | 1.25276 | 0.0260448 | 0.0375827
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia; Office | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 31.2207 (kgCO₂) | 540.359 | 0 | 1.98046 | 1.97279 | 0 | 0 | 1.5 | 2.9592 | 2.97067 | 0 | 1.5 | 1.5 | 2.9592 | 1.5 | 2.97067 | 2.9592 | 2.97067 | 1.5 | 1.5 | 0.045 | 2.6 | 0.0889479 | 2.872 | 12.212 | 1.5 | 0.0889479 | 0.0889479 | 3.06 | 4.85246 | 14.1925 | 2.872 | 12.212 | 0.210036 | 2.44 | 80.0532 | 2.97067 | 2.97067 | 0.078 | 0.0889479
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Extradossat_170 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_170 | 11.8706 (kgCO₂) | 205.452 | 0 | 2.6 | 0 | 0 | 0 | 1.16585 | 1.11999 | 1.1351 | 0 | 1.16585 | 1.16585 | 1.11999 | 1.16585 | 1.1351 | 3.05745 | 3.06873 | 1.16585 | 1.16585 | 0.0348337 | 2.6 | 0.0338193 | 2.872 | 12.212 | 1.16585 | 0.0338193 | 0.0918926 | 2.39171 | 5.472 | 14.812 | 2.872 | 12.212 | 0.0609954 | 2.44 | 30.4374 | 1.13555 | 3.03122 | 0.078 | 0.0907673
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Enva_140 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 33.8317 (kgCO₂) | 585.549 | 0 | 2.6 | 0 | 0 | 0 | 1.28867 | 3.20059 | 3.22519 | 0 | 1.27767 | 1.29967 | 3.20059 | 1.27767 | 3.22519 | 3.37914 | 3.40373 | 1.29967 | 1.27767 | 0.0370718 | 2.6 | 0.0963867 | 0.27 | 9.61 | 1.26248 | 0.0963867 | 0.101743 | 2.64454 | 2.87 | 12.21 | 0.27 | 9.61 | 0.152144 | 2.44 | 86.748 | 3.28245 | 3.28245 | 0.078 | 0.0963867
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Enva_140 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 36.4292 (kgCO₂) | 630.505 | 0 | 2.6 | 0 | 0 | 0 | 1.29627 | 3.41867 | 3.50045 | 0 | 1.27767 | 1.31487 | 3.41867 | 1.27767 | 3.50045 | 3.41867 | 3.50045 | 1.31487 | 1.27767 | 0.039918 | 2.6 | 0.103787 | 0.27 | 9.61 | 1.34633 | 0.103787 | 0.103787 | 2.66338 | 2.87 | 12.21 | 0.27 | 9.61 | 0.079836 | 2.44 | 93.4082 | 3.50045 | 3.50045 | 0.078 | 0.103787
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 40.7558 (kgCO₂) | 705.389 | 0 | 2.6 | 2.13347 | 0.0295541 | 0.0295541 | 1.5 | 3.87045 | 3.87045 | 0.000886624 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.116113 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.230104 | 2.44 | 104.502 | 3.87045 | 3.9 | 0.078 | 0.117 | ArchiCADProperties - ID of Connected Openings: OP - 006
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 27.9331 (kgCO₂) | 483.457 | 0 | 1.80253 | 0 | -6.04597e-10 | -6.66134e-15 | 1.49154 | 2.67606 | 2.63669 | 1.3993e-10 | 1.49831 | 1.48476 | 2.67606 | 1.49831 | 2.63669 | 2.74836 | 2.70075 | 1.48476 | 1.49831 | 0.0449493 | 1.80253 | 0.0795814 | 2.475 | 11.815 | 1.49831 | 0.0795814 | 0.0817367 | 3.04599 | 4.27753 | 13.6175 | 2.475 | 11.815 | 0.0981389 | 2.44 | 71.6232 | 2.68262 | 2.68291 | 0.0540759 | 0.0797686
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 34.4799 (kgCO₂) | 596.767 | 0 | 2.6 | 1.45847 | 0.62556 | 0.62556 | 1.5 | 3.27444 | 3.27444 | 0.0187668 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.0982332 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.22956 | 2.44 | 88.4099 | 3.27444 | 3.9 | 0.078 | 0.117 | ArchiCADProperties - ID of Connected Openings: OP - 004
