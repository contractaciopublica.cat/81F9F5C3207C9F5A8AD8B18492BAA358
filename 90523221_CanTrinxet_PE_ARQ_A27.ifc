Properties of the parts of a building model (IFC2X3), part 14 of 99

# IfcBuildingElementProxy: Insulation 80 (19)
Name | Classification | Reference Line Location | Inside Face Surface | Outside Face Surface | Element ID = Hotlink and Element ID = Parent ID | Colliding Zones | Surfaces (All) | Number of Openings | AUX_107.NomTipus | Insulation - Mineral Soft, Embodied Carbon | Insulation - Mineral Soft, Embodied Energy (MJ) | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 109.AMB.CodiTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | Insulation - Mineral Soft, Mass (kg) | Insulation - Mineral Soft, Projected Component Area (Net) (m2) | Insulation - Mineral Soft, Projected Component Area (Gross) (m2) | Insulation - Mineral Soft, Rectangular Component Height (m) = Height (m) = 503.AMB.Altura (m) | Insulation - Mineral Soft, Component Cross Section Area (m2) | Insulation - Mineral Soft, Component Volume (Net) (m3) = Wall Component Volume on the Inside Face (Net) (m3) = Wall Component Volume on the Outside Face (Net) (m3) | Insulation - Mineral Soft, Component Volume (Gross) (m3) | Number of Doors | Number of Windows | Number of Columns | Maximum Height of the Wall Skin on the Inside Face (m) = Maximum Height of the Wall (m) = Maximum Height of the Wall Skin on the Outside Face (m) | Minimum Height of the Wall Skin on the Inside Face (m) = Minimum Height of the Wall (m) = Minimum Height of the Wall Skin on the Outside Face (m) | Area of the Doors (m2) | Combined Width of Doors (m) | Area of the Windows (m2) | Combined Width of Windows (m) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Surface Area of the Wall Inside Face (Conditional) (m2) | Length of the Wall Outside Face (Conditional) (m) | Surface Area of the Wall Outside Face (Conditional) (m2) | Volume of the Wall Inside Face Component (Conditional) (m3) = Volume of the Wall Outside Face Component (Conditional) (m3) = Volume (Conditional) (m3) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2)
T4 | 40.10.10.30 Extradossats (GuBIMclass CA); Wall (ARCHICAD Classification) | Outside Face | Paint - Anthracite | Insulation - Cellulose | T4 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 0 | Extradossat_110 | 29.9162 (kgCO₂) | 396.113 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 27.7002 | 8.79455 | 9.39443 | 6.87257 | 0.549806 | 0.692506 | 0.740496 | 0 | 0 | 0 | 6.87257 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.41901 | 8.75778 | 8.31504 | 0 | 1.45901 | 1.45901 | 8.75778 | 1.37901 | 8.31504 | 0.692506 | 10.6913 | 10.728 | 1.45901 | 1.37901 | 0.116721 | 0.692506 | 1.71425 | 11.0543 | 1.45901 | 0.856772 | 3.03115 | 8.58682 | 17.9268 | 0.251796
T1 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Outside Face | Paint - Anthracite | Paint - Anthracite | T1 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 0 | Enva_140 | 41.6696 (kgCO₂) | 551.736 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | 38.5829 | 12.0572 | 16.5292 | 8.47043 | 0.677635 | 0.964573 | 1.32234 | 1 | 0 | 0 | 6.62116 | 2.598 | 4.47208 | 1.72003 | 0 | 0 | 4.47208 | 4.47208 | 2.66538 | 12.0572 | 12.0572 | 0.357766 | 2.66538 | 0.945352 | 12.0572 | 0.945352 | 12.0572 | 1.32234 | 16.5293 | 16.5293 | 2.66538 | 2.66538 | 0.0756282 | 0.964573 | 1.71425 | 11.0543 | 2.66538 | 1.32234 | 5.49077 | 8.33541 | 17.6754 | 1.29142
T4 | 40.10.10.30 Extradossats (GuBIMclass CA); Wall (ARCHICAD Classification) | Outside Face | Paint - Anthracite | Insulation - Cellulose | T4 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 0 | Extradossat_110 | 3.40073 (kgCO₂) | 45.0282 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 3.14882 | 0.984007 | 0.984007 | 3.784 | 0.30272 | 0.0787206 | 0.0787206 | 0 | 0 | 0 | 3.56 | 0 | 0 | 0 | 0 | 0 | -1.33227e-15 | -5.44009e-15 | 0.320002 | 0.984007 | 0.984007 | -4.64289e-09 | 0.360002 | 0.280002 | 0.984007 | 0.360002 | 0.984007 | 0.0787206 | 1.66497 | 1.66497 | 0.280002 | 0.360002 | 0.0224002 | 0.0787206 | 1.71425 | 11.0543 | 0.280002 | 0.133197 | 0.833141 | 5.27425 | 14.6143 | 0.0224002
T4 | 40.10.10.30 Extradossats (GuBIMclass CA); Wall (ARCHICAD Classification) | Outside Face | Paint - Anthracite | Insulation - Cellulose | T4 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 0 | Extradossat_110 | 4.43148 (kgCO₂) | 58.6761 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 4.10322 | 1.28226 | 1.28226 | 3.784 | 0.30272 | 0.102581 | 0.102581 | 0 | 0 | 0 | 3.784 | 0 | 0 | 0 | 0 | 0 | 2.66454e-15 | 3.10862e-15 | 0.320005 | 1.28226 | 1.28226 | 5.33014e-09 | 0.360005 | 0.280005 | 1.28226 | 0.360005 | 1.28226 | 0.102581 | 1.66498 | 1.66498 | 0.280005 | 0.360005 | 0.0288004 | 0.102581 | 1.71425 | 11.0543 | 0.360005 | 0.133198 | 0.833146 | 5.49825 | 14.8383 | 0.0336007
T4 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Outside Face | Paint - Anthracite | Insulation - Cellulose | T4 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 0 | Enva_220 | 52.7266 (kgCO₂) | 698.14 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | 48.8209 | 15.2565 | 15.2565 | 3.56 | 0.2848 | 1.22052 | 1.22052 | 0 | 0 | 0 | 3.56 | 3.56 | 0 | 0 | 0 | 0 | 0 | 0 | 4.28555 | 15.2565 | 15.2565 | 0 | 4.28555 | 4.28555 | 15.2565 | 4.28555 | 15.2565 | 1.22052 | 15.2565 | 15.2565 | 4.28555 | 4.28555 | 0.342844 | 1.22052 | 1.71425 | 11.0543 | 4.28555 | 1.22052 | 8.73109 | 5.27425 | 14.6143 | 1.25529
T4 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Outside Face | Paint - Anthracite | Paint - Anthracite | T4 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 0 | Enva_220 | 115.941 (kgCO₂) | 1535.15 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | 107.353 | 34.8801 | 34.8801 | 8.47043 | 0.677635 | 2.68382 | 2.68382 | 0 | 0 | 0 | 8.11223 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4.69483 | 34.8801 | 33.1036 | 0 | 4.73483 | 4.65483 | 34.8801 | 4.73483 | 33.1036 | 2.68382 | 34.8801 | 34.8801 | 4.65483 | 4.73483 | 0.378786 | 2.68382 | 1.71425 | 11.0543 | 4.73483 | 2.79041 | 9.5828 | 9.82648 | 19.1665 | 1.3056
T1 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Center | Insulation - Cellulose | Insulation - Cellulose | T1 | Nau Santa Eulàlia | Paint - Anthracite; Insulation - Cellulose | 0 | Enva_140 | 70.3552 (kgCO₂) | 931.555 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | 65.1437 | 20.4022 | 20.4022 | 5.3 | 0.424 | 1.62859 | 1.62859 | 0 | 0 | 0 | 4.62246 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4.42683 | 20.3126 | 20.4022 | 0 | 4.46683 | 4.42683 | 20.3126 | 4.42683 | 20.4022 | 1.62859 | 20.7407 | 20.8326 | 4.42683 | 4.42683 | 0.354146 | 1.62859 | 0.27 | 9.61 | 4.42683 | 1.66294 | 9.01365 | 4.89246 | 14.2325 | 1.08612
T1 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Center | Insulation - Cellulose | Insulation - Cellulose | T1 | Despatx; Nau Santa Eulàlia | Paint - Anthracite; Insulation - Cellulose | 0 | Enva_140 | 69.1682 (kgCO₂) | 915.838 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | 64.0446 | 20.0585 | 20.0585 | 5.3 | 0.424 | 1.60111 | 1.60111 | 0 | 0 | 0 | 4.60287 | 4.57304 | 0 | 0 | 0 | 0 | 0 | 0 | 4.36673 | 20.0585 | 19.9694 | 0 | 4.36673 | 4.36673 | 20.0585 | 4.36673 | 19.9694 | 1.60111 | 20.0585 | 19.9694 | 4.36673 | 4.36673 | 0.349338 | 1.60111 | 0.27 | 9.61 | 4.36673 | 1.60111 | 8.89346 | 4.87287 | 14.2129 | 1.44467
T1 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Center | Insulation - Cellulose | Insulation - Cellulose | T1 | Nau Santa Eulàlia | Paint - Anthracite; Insulation - Cellulose | 0 | Enva_140 | 66.9702 (kgCO₂) | 886.735 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | 62.0095 | 19.3781 | 23.5381 | 5.3 | 0.424 | 1.55024 | 1.88304 | 2 | 0 | 0 | 4.73 | 4.04514 | 4.16 | 1.6 | 0 | 0 | 4.16 | 4.16 | 5.36394 | 19.378 | 19.378 | 0.3328 | 5.36394 | 3.76394 | 19.378 | 3.76394 | 19.378 | 1.88304 | 23.538 | 23.538 | 5.36394 | 5.36394 | 0.301115 | 1.55024 | 0.27 | 9.61 | 5.36394 | 1.88304 | 10.8879 | 5 | 14.34 | 1.39137
T1 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Center | Insulation - Cellulose | Insulation - Cellulose | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal; Insulation - Cellulose | 0 | Enva_140 | 48.614 (kgCO₂) | 643.686 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | 45.013 | 14.0674 | 23.1792 | 5.3 | 0.424 | 1.12532 | 1.85427 | 1 | 3 | 0 | 4.72512 | 2.1586e-08 | 2.2865 | 0.879423 | 6.82536 | 2.62514 | 9.11185 | 9.11185 | 5.31159 | 14.0664 | 14.0667 | 0.728948 | 5.31159 | 1.80703 | 14.0664 | 1.80703 | 14.0667 | 1.85427 | 23.2997 | 23.2999 | 5.31159 | 5.31159 | 0.144562 | 1.12532 | 0.27 | 9.61 | 5.31159 | 1.86399 | 10.7832 | 4.99512 | 14.3351 | 1.22838 | ArchiCADProperties - Edge Surface: Wood - Pine Grained Horizontal
T1 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Center | Insulation - Cellulose | Insulation - Cellulose | T1 | Nau Santa Eulàlia | Paint - Anthracite; Insulation - Cellulose | 0 | Enva_140 | 65.3042 (kgCO₂) | 864.676 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | 60.4668 | 18.8969 | 23.0569 | 5.3 | 0.424 | 1.51167 | 1.84447 | 2 | 0 | 0 | 4.72512 | 2.1586e-08 | 4.16 | 1.6 | 0 | 0 | 4.16 | 4.16 | 5.28138 | 18.8958 | 18.896 | 0.3328 | 5.28138 | 3.68138 | 18.8958 | 3.68138 | 18.896 | 1.84447 | 23.1771 | 23.1773 | 5.28138 | 5.28138 | 0.29451 | 1.51167 | 0.27 | 9.61 | 5.28138 | 1.85418 | 10.7228 | 4.99512 | 14.3351 | 1.37465
Tr2 | 40.10.10.30 Extradossats (GuBIMclass CA); Wall (ARCHICAD Classification) | Outside Face | Paint - Anthracite | Insulation - Cellulose | Tr2 | Nau Lateral; Sala d'actes | Paint - Anthracite; Insulation - Cellulose | 0 | Extradossat_110 | 217.447 (kgCO₂) | 2879.16 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 201.34 | 62.9191 | 62.9191 | 8.07593 | 0.646074 | 5.0335 | 5.0335 | 0 | 0 | 0 | 8.07593 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 7.7909 | 62.9185 | 62.9191 | 0 | 7.87094 | 7.71087 | 62.9185 | 7.87094 | 62.9191 | 5.0335 | 63.5646 | 63.5651 | 7.71087 | 7.87094 | 0.623272 | 5.0335 | 1.71425 | 11.0543 | 7.79094 | 5.08519 | 15.8081 | 9.79018 | 19.1302 | 1.24654
T4 | 40.10.10.30 Extradossats (GuBIMclass CA); Wall (ARCHICAD Classification) | Outside Face | Paint - Anthracite | Insulation - Cellulose | T4 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 0 | Extradossat_110 | 53.7206 (kgCO₂) | 711.301 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 49.7413 | 15.5442 | 15.5442 | 3.56 | 0.2848 | 1.24353 | 1.24353 | 0 | 0 | 2 | 3.56 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4.32634 | 15.5442 | 15.5442 | 0 | 4.36633 | 4.28634 | 15.5442 | 4.36634 | 15.5442 | 1.24353 | 15.829 | 15.829 | 4.28634 | 4.36634 | 0.349307 | 1.24353 | 1.71425 | 11.0543 | 4.36634 | 1.26632 | 8.84581 | 5.27425 | 14.6143 | 0.698614
F5 | 40.10.10.30 Extradossats (GuBIMclass CA) | Outside Face | Paint - Anthracite | Insulation - Cellulose | F5 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 0 | Extradossat_110 | 185.152 (kgCO₂) | 2451.55 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 171.437 | 53.7318 | 71.6915 | 5.84695 | 0.467756 | 4.28592 | 5.7227 | 1 | 2 | 0 | 5.80676 | 3.55271e-15 | 5.95024 | 1.78948 | 12.3039 | 3.19838 | 17.9597 | 17.9597 | 12.403 | 53.7299 | 53.418 | 1.43678 | 12.4428 | 8.97451 | 53.7299 | 9.05412 | 53.418 | 5.7227 | 72.1561 | 71.8404 | 12.3632 | 12.4428 | 0.717931 | 4.28592 | 1.71425 | 11.0543 | 12.3632 | 5.75986 | 24.9988 | 7.52101 | 16.861 | 1.75484
F5 | 40.10.10.30 Extradossats (GuBIMclass CA) | Outside Face | Paint - Anthracite | Insulation - Cellulose | F5 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 0 | Extradossat_110 | 141.848 (kgCO₂) | 1878.17 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 131.341 | 41.0458 | 50.7681 | 8.47043 | 0.677635 | 3.28352 | 4.06129 | 0 | 4 | 0 | 8.11225 | 0 | 0 | 0 | 10.3243 | 5.39794 | 9.72227 | 9.72227 | 7.32078 | 41.0452 | 41.0433 | 0.777779 | 7.40062 | 7.24094 | 42.6151 | 7.40062 | 42.6132 | 4.06129 | 51.4136 | 51.4117 | 7.24094 | 7.40062 | 0.592065 | 3.28351 | 1.71425 | 11.0543 | 7.40101 | 4.11301 | 14.8676 | 9.8265 | 19.1665 | 1.20638
T4 | 40.10.10.30 Extradossats (GuBIMclass CA); Wall (ARCHICAD Classification) | Outside Face | Paint - Anthracite | Insulation - Cellulose | T4 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 0 | Extradossat_110 | 31.6149 (kgCO₂) | 418.605 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 29.2731 | 9.29836 | 9.29836 | 6.87257 | 0.549806 | 0.731827 | 0.731827 | 0 | 0 | 0 | 6.64635 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.35902 | 9.26312 | 8.76674 | 0 | 1.39902 | 1.39902 | 9.26312 | 1.31902 | 8.76674 | 0.731827 | 9.79281 | 9.83007 | 1.39902 | 1.31902 | 0.111921 | 0.731827 | 1.71425 | 11.0543 | 1.39902 | 0.784915 | 2.91117 | 8.36061 | 17.7006 | 0.229261
Tr2 | 40.10.10.30 Extradossats (GuBIMclass CA); Wall (ARCHICAD Classification) | Outside Face | Paint - Anthracite | Insulation - Cellulose | Tr2 | Nau Lateral; Sala de reunions | Paint - Anthracite; Insulation - Cellulose | 0 | Extradossat_110 | 53.4958 (kgCO₂) | 708.324 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 49.5331 | 15.4791 | 15.4791 | 3.56 | 0.2848 | 1.23833 | 1.23833 | 0 | 0 | 0 | 3.56 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4.38806 | 15.4791 | 15.4791 | 0 | 4.42806 | 4.34806 | 15.4791 | 4.42806 | 15.4791 | 1.23833 | 16.0487 | 16.0487 | 4.34806 | 4.42806 | 0.347845 | 1.23833 | 1.71425 | 11.0543 | 4.34806 | 1.2839 | 8.96927 | 5.27425 | 14.6143 | 0.69569
T4 | 40.10.10.30 Extradossats (GuBIMclass CA); Wall (ARCHICAD Classification) | Outside Face | Paint - Anthracite | Insulation - Cellulose | T4 | Nau Lateral | Paint - Anthracite; Insulation - Cellulose | 1 | Extradossat_110 | 35.4542 (kgCO₂) | 469.44 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 32.828 | 10.2588 | 14.7308 | 3.84 | 0.3072 | 0.8207 | 1.17847 | 0 | 0 | 0 | 3.56 | 0 | 0 | 0 | 0 | 0 | 4.47208 | 4.47208 | 4.26806 | 10.2588 | 10.2588 | 0.357766 | 4.42806 | 2.54803 | 10.2588 | 2.54803 | 10.2588 | 1.17847 | 17.311 | 17.311 | 4.26806 | 4.26806 | 0.341445 | 0.8207 | 1.71425 | 11.0543 | 4.26806 | 1.38488 | 8.69613 | 5.27425 | 14.6143 | 0.199043 | ArchiCADProperties - ID of Connected Openings: OP - 003
T1 | 40.10.10.30 Extradossats (GuBIMclass CA); Wall (ARCHICAD Classification) | Outside Face | Paint - Anthracite | Insulation - Cellulose | T1 |  | Paint - Anthracite; Insulation - Cellulose | 0 | Extradossat_110 | 19.0237 (kgCO₂) | 251.888 | 40.10.10.30 Extradossats | 40.10.10.30 | Extradossats | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | 17.6146 | 5.66699 | 5.66699 | 3.31378 | 0.265102 | 0.440364 | 0.440364 | 0 | 0 | 0 | 3.31378 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1.71013 | 5.66699 | 5.01714 | 0 | 1.71013 | 1.71013 | 5.66699 | 1.71013 | 5.01714 | 0.440364 | 5.75278 | 5.75278 | 1.71013 | 1.71013 | 0.13681 | 0.440364 | 5.02163 | 14.3616 | 1.71013 | 0.460222 | 3.58026 | 8.33541 | 17.6754 | 0.531124

# IfcBuildingElementProxy: LAMILUX CI System Glass Element F100 Round, L1
In: planta coberta
Classification: 30.20.20.10 Finestres de cobertes (GuBIMclass CA)
AC_Pset_LAMILUX_CI_System_Glass_Element_F100_Round - Show 2D Hotspots in 3D: no; Skylight Function: no; Add-On Type: skylight; Roof Angle: 0 deg; Lower Edge Type: 0; Lower Edge Angle: 90 deg; Upper Edge Type: 2; Upper Edge Angle: 90 deg; Story Sensitive Symbol: yes; Floor Plan Display: 0; Show Projection: 0; Contour Pen: 2D Elements - General; Fill Type: Background; IFC Operation (ifc_optypestr): Not Defined; IFC Operation (ifc_optype): 0; Fill Pen: Backgrounds - color 1; Fill Background Pen: Backgrounds - color 1; Shadows: yes; Resolution: 36; Cost: 0; Total Glazed Area: 0; Total Glass Perimeter: 0; Group Type (iFMType): 1; Object Weight: 0; Object Weight Unit: kg; Name of the object: LAMILUX CI System Glass Element F100 round; Product SKU: Lamilux_F100G_round; Brand:: LAMILUX; Brand url:: http://www.lamilux.com; Product family:: Daylight element; Product group:: Flat roof window; Manufacturer country:: Germany; Design country:: Germany; Edition number:: 1; Width (mm):: 0; Height (mm):: 0; Depth (mm):: 0; Weight Net (Kg):: 0; BIMobject QR code url:: http://bimobject.com/lamilux/product/Lamilux_F100G_round; Product data url:: bimobject.com/lamilux/product/Lamilux_F100G_round; Product url:: http://www.lamilux.com/daylight-systems/daylight-elements.html; Material main:: Glass; Material secondary:: Plastic; IFC Classification:: Window; UNSPC code:: 301516; Uniclass 1.4 Code: JL11; Uniclass 1.4 Description: Rooflights/Roof windows; Uniclass 2.0 Code: SS-20-30-74; Uniclass 2.0 Description: Roof Light Systems; Uniclass 2015 Code: Ss_30_30_34; Uniclass 2015 Description: Glass unit masonry roof light systems; NBS Reference: 20-30-74; NBS Reference Description: Roof Light Systems; OmniClass Code: 23-17 17 00; OmniClass Description: Skylights; Region Europe: All; Region North America: All; Region South America: All; Region Middle East: All; Region Asia: All; Region Oceania: All; Region Africa: All; Region Antarctica: All
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 17.0246 deg; Surface: Rhino - 011; Element ID: L1; Hotlink and Element ID: L1; Layer: 00_LUCERNARIO; Library Part Name: LAMILUX CI System Glass Element F100 Round; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Vestíbul; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Object; Parent ID: L1; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.20.10 Finestres de cobertes; 104.AMB.ClassificacioCodi: 30.20.20.10; 105.AMB.ClassificacioDescripcio: Finestres de cobertes; 107.AMB.NomTipus: L1_LucernariCircular; 109.AMB.CodiTipus: L1; 111.AMB.DescripcioTipus: Lucernari Lamilux F100 de 600 mm amb perfil plàstic i vidre d'alta eficiència energètica; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: LucernariCircular
ArchiCADQuantities - Length (A): 1 m; Area: 1 m2; Height: 0.37 m; Volume (Net): 0.0633207 m3; Width: 1 m; Elevation to Project Zero: 4.35 m; Elevation to 1st Reference Level: 4.35 m; Elevation to 2nd Reference Level: 4.35 m; Elevation to Sea Level: 13.69 m; Elevation to Linked/Home Story: -0.15 m; Home Offset: -0.15 m; Surface Area: 9.27664 m2; Top Elevation To First Reference Level: 4.72 m; Top Elevation To Home Story: 0.22 m; Top Elevation To Project Zero: 4.72 m; Top Elevation To Sea Level: 14.06 m; Top Elevation To Second Reference Level: 4.72 m; Bottom Elevation To First Reference Level: 4.35 m; Bottom Elevation To Home Story: -0.15 m; Bottom Elevation To Project Zero: 4.35 m; Bottom Elevation To Sea Level: 13.69 m; Bottom Elevation To Second Reference Level: 4.35 m; Survey Coordinate X: 426564 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.69 m; Top Surface Area (Net): 1 m2; Bottom Surface Area (Net): 9.27664 m2
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
AC_Equantity_LAMILUX_CI_System_Glass_Element_F100_Round - Dimension 1: 1 m; Dimension 2: 1 m; Height: 0.37 m; Bottom Level: 0 m; Top Level: 0.37 m; Roof Thickness: 0.3 m
5 AMB.Geometria - 502.AMB.Amplada: 1 m; 503.AMB.Altura: 0.37 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0633207 m3; Component, Component Volume (Gross): 0.0633207 m3
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0; Status: NEW

# IfcBuildingElementProxy: Pocket Door 27 (3)
In: planta baixa
Classification: 80.10.40.20 Portes d'accés (GuBIMclass CA)
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0; Status: NEW
ArchiCADProperties - Reveal Dimensions: 800,0×2.600,0; Wallhole Dimensions: 800,0×2.600,0; Unit Dimensions: 800,0×2.600,0; Egress Dimensions: 740,0×2.570,0; Leaf Dimensions: 740,0×2.570,0; Nominal W x H Size: 800,0×2.600,0; Marker Text: <Custom Text>; Opening Library Part Name: Pocket Door 27; Opening Side Fill Index: Background; Layer: 00_TABIQUE; Library Part Name: Pocket Door 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Door; Surfaces (All): Metal - Stainless Steel; Wood - Pine Grained Horizontal; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Pocket_Door_27 - Wall Contours (0-None,1-Full,2-Side,3-Length): 0; Hotspots 0-None,1-2D,2-3D,3-All: 3; Show 2D Hotspots in 3D: yes; Floor Plan Display Option: 3; Hole Position Angle: 0 deg; Hole has Wall's Side Surface: yes; Hole Surface's Split is Curved in Curved Walls: no; Wall Type: 1; Reveal Anchor Position: 1; Flip: no; Demolition / New construction: 1; New Wall Fill Type: Masonry Block; New Wall Fill Pen: General - General; New Wall Fill Background Pen: Backgrounds - color 1; Show new construction on Wall: no; Demolition line type: 1; Show Demolition/New parameter: no; Display as Transom: no; Sidelight (gs_SidelightTransomRelation): Under Transom; Sidelight (gs_SidelightTransomRelation_m): 1; Uniform Tolerances: yes; Nominal Size: 0; Set Wallhole Size as Nominal Size: yes; Set Reveal Size as Nominal Size: no; Set Unit Size as Nominal Size: no; Set Egress Size as Nominal Size: no; Set Leaf Size as Nominal Size: no; Transfer Current Nominal Size to Selection: no; Show Editable Hotspots: yes; 2D Detail Level: 1; Show Reveal on Symbol: 1; Symbolic Display of Opening: no; 3D Detail Level: 8; Opening Direction Sidelight (gs_opening_dir_sl): Opposite to Leaf; Opening Direction Sidelight (gs_opening_dir_sl_m): 2; Door Frame (gs_pocket_door_frame): yes; Frame Style (gs_frame_style): Block; Frame Style (gs_frame_style_m): 1; Uniform Frame Thickness: yes; Centered Leaf: yes; Uniform Frame Width: yes; Frame Style Changed Automatically: no; Pocket Frame: no; Number of Door Leaves: 4; Number of Door Leaves - Side 2: 3; Door Panel Style: 1; Leaves Configuration (gs_LeavesConfig): Uniform Leaves; Leaves Configuration (gs_iLeavesConfig): 1; Grid Position (gs_grill_pos): Throughout; Grid Position (gs_grill_pos_m): 3; Panes Number Vertically: 4; Panes Number Horizontally: 3; Panes Number Vertically Side 1: 4; Panes Number Horizontally Side 1: 3; Show as Glass Panel on Symbol: no; Show Chinese Spring Door Symbol: no; Show Symbol as Airtight Panel: no; Opening Handle (gs_handle_type): Fix Handle 4; Opening Handle (gs_handle_type_m): 36; Show Handle on Symbol: no; Kick Board Outside (bKickBoardOut): no; Kick Board Inside (bKickBoardIn): no; Uniform Sashes: no; Opening Type (gs_optype_m_05): 3; Opening Type (gs_optype_m_09): 3; Opening Type (gs_optype_m_02): 1; Opening Type (gs_optype_m_06): 1; Opening Type (gs_optype_m_10): 1; Sash Type (MullionStyle_00): No Grid; Sash Type (iMullionStyle_00): 1; Sash Type (iMullionStyle_05): 1; Sash Type (iMullionStyle_09): 1; Sash Type (iMullionStyle_02): 1; Sash Type (iMullionStyle_06): 1; Sash Type (iMullionStyle_10): 1; Hotspot Grill Editing: yes; Grid Position (MullionPosition): Throughout; Grid Position (iMullionPosition): 3; Panes Number Vertically Main Sash Side 1: 4; Panes Number Horizontally Main Sash Side 1: 2; Panes Number Vertically 2 Main Sash Side 1: 4; Panes Number Horizontally 2 Main Sash Side 1: 2; Panes Number Vertically Main Sash Side 2: 4; Panes Number Horizontally Main Sash Side 2: 2; Panes Number Vertically 2 Main Sash Side 2: 4; Panes Number Horizontally 2 Main Sash Side 2: 2; Panes Number Vertically Middle Transom: 2; Panes Number Horizontally Middle Transom: 2; Panes Number Vertically 2 Middle Transom: 2; Panes Number Horizontally 2 Middle Transom: 2; Panes Number Vertically Transom Side 1: 2; Panes Number Horizontally Transom Side 1: 2; Panes Number Vertically 2 Transom Side 1: 2; Panes Number Horizontally 2 Transom Side 1: 2; Panes Number Vertically Transom Side 2: 2; Panes Number Horizontally Transom Side 2: 2; Panes Number Vertically 2 Transom Side 2: 2; Panes Number Horizontally 2 Transom Side 2: 2; Right Sidelight: no; Left Sidelight: no; Transom: no; Casing (gs_trim_outside): no; Casing Type Outside (gs_trimtype_out): Simple; Casing Type Outside (gs_trimtype_out_int): 1; Outside Casing Head Type: 1; Architrave Capital: yes; Architrave Capital Type: 1; Cover Outer Wall Surface: yes; Uniform Casing Widths (gs_trim_outside_uniform): yes; Casing (gs_trim_inside): no; Casing Type Inside (gs_trimtype_in): Simple; Casing Type Inside (gs_trimtype_in_int): 1; Cover Inner Wall Surface: yes; Uniform Casing Widths (gs_trim_inside_uniform): yes; Threshold (bThreshold): no; Threshold Type: -1; Threshold Angle: 3.1996 deg; Threshold Changed Automatically: no; Sill - Door: no; Sill - Sidelight Side 1: no; Sill - Sidelight: no; Sill Oversize: no; Type of the Sill: 1; Sill Angle: 3 deg; Sill is Curved in Curved Walls: yes; Insulation below Sill: yes; Use Wall Insulation Skin: no; Brick Sill 3D Detail Level: 1; Sill Style Changed Automatically: no; Board - Sidelight Side 1: no; Board - Sidelight: no; Board - Door: no; Board Angle: 0 deg; Board is Curved in Curved Walls: yes; Board in Polygonal Walls: 1; Sunshade: no; Sunshade Type: 1; Enabled Sunshade Types: 126; Number of Panels: 2; Number of Panels 2: 1; Panel Position (gs_shutter_panelPos): Symmetric; Panel Position (gs_shutter_iPanelPos): 1; Automatic Shutter Height: yes; Extra Frame: no; Cover Type (gs_slidingShutter_cover): Z-Profile; Cover Type (gs_slidingShutter_iCover): 1; Stacking Direction (gs_foldingShutter_stacking): Inside; Stacking Direction (gs_foldingShutter_iStacking): 1; Open in 3D: yes; 3D Opening Angle: 180 deg; Show 2D Symbol: yes; Show Opening Lines on Symbol: no; Panel Type (gs_shutPanel_type): Style 1; Panel Type (gs_shutPanel_iType): 1; Different Bottom Frame Width: no; Automatic Shutter Width: yes; Louver Angle: 30 deg; Holes Number Horizontal: 5; Holes Number Vertical: 8; Rolling Shutter Placement (gs_shutRoll_placement): On Facade; Rolling Shutter Placement (gs_shutRoll_iPlacement): 1; Box Type (gs_shutRoll_boxType): Rectangular; Box Type (gs_shutRoll_iBoxType): 1; Rail Position (gs_shutRoll_railPos): On Casing; Rail Position (gs_shutRoll_iRailPos): 1; Show Casing behind Sunshade (gs_shutRoll_showCasingBehind): no; Insulation behind Box (gs_shutRoll_cutWallBehind): no; Include Height in Wallhole Height: no; Box Top Angle: 10 deg; Box Default Width (gs_shutRoll_boxDefaultSize): Reveal Width; Box Default Width (gs_shutRoll_iBoxDefaultSize): 1; Venetian Blinds Placement (gs_shutLam_placement): Fixed on Facade; Venetian Blinds Placement (gs_shutLam_iPlacement): 1; Insulation behind Box (gs_shutLam_cutWallBehind): no; Opened Box: yes; Rail (gs_shutLam_bRail): yes; Rail Position (gs_shutLam_railPos): On Casing; Rail Position (gs_shutLam_iRailPos): 1; Show Casing behind Sunshade (gs_shutLam_showCasingBehind): no; Rotation Angle of Slats (gs_shutLam_rotation): 45 deg; Rotation Angle of Slats (gs_shutLam2_rotation): 45 deg; Masonry Arch (bMasonryArch): no; Masonry Arch (gs_masonry_arch_int): 0; Masonry Arch Type (gs_masonry_arch_structure): Stucco Arch; Masonry Arch Type (gs_masonry_arch_structure_int): 0; Arch on Header: yes; Niche below Arch: yes; Skewback Angle: 75 deg; Custom Niche Surface: no; Set Jamb Depth on Side: 1; Uniform Jamb Depth: yes; Outer Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleOuterTypeInt): 0; Inner Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleInnerTypeInt): 0; Angle Side 2: 20 deg; Angle Side: 20 deg; Upper Side Angle: 20 deg; Bottom Side Angle: 20 deg; Outer Angle Side 2: 20 deg; Outer Angle Side: 20 deg; Outer Angle Upper Side: 20 deg; Outer Angle Bottom Side: 20 deg; Rail (gs_door_rail): no; Rail Position (gs_door_rail_ext): Rail at Bottom; Rail Position (gs_door_rail_ext_m): 2; Use Wall Finish Component: no; Auto Turn Inside Face Plaster: yes; Turn Inside Face Plaster: 0; Auto Turn Outside Face Plaster: yes; Turn Outside Face Plaster: 0; Dimensionable on 2D: no; Show in 3D: no; Closure Type (gs_closure_type): No Closure; Closure Type (gs_closure_type_int): 1; Turn Skin on Side (gs_cavity_side): Both; Turn Skin on Side (iCavityClosureSide): 1; Number of Skins to Turn: 1; Number from (gs_nTurnDir): Outside Face; Number from (iCavityClosureTurnDir): 1; Place Closer on Side 1: yes; Place Closer on Side 2: yes; Place Closer on Top: no; Place Closer on Bottom: no; Place Closer to Skin: 1; Place Closer from Side (gs_cc_dutch_ClosureToSide): 1; Gap at Outside Skin: yes; Turn Skin to Closer: no; Insert Insulation Strip: yes; Show Insulation Strip: yes; Contour Pen (gs_penJoint): Openings - Cut Non-Structural; Contour Line Type (gs_ltJoint): 1; Fill Type (gs_fillJoint): Rigid Insulation; Fill Pen (gs_penJointFg): General - General; Fill Background Pen (gs_penJointBg): 2D Elements - Drafting; Custom Surface: no; Surface: Wood - Pine Grained Horizontal; Contour Pen (gs_penPlug): Openings - Cut Non-Structural; Contour Line Type (gs_ltPlug): 1; Fill Type (gs_fillPlug): Rigid Insulation; Fill Pen (gs_penPlugFg): General - General; Fill Background Pen (gs_penPlugBg): 2D Elements - Drafting; Edited Jamb Side: 1; Edited Wall Side: 1; Edited Skin Number: 1; Turn-in Skin: no; Consider Skin as Plaster: no; Turn-in Thickness: 1; Hatch Orientation: 1; Separating Line at Turn-in: no; Separating Line Pen: General - General; Last Selected Side: no; Closure Method Changed Automatically: no; Connection on Side 1: no; Connection on Side 2: no; Connection on the Top: no; Opening Type (gs_leaf_optype): Pocket; Opening Type (gs_leaf_optype_m): 25; End Panel Opening Side 1: no; End Panel Opening Side 2: no; Opening Angle in 2D: 90 deg; Opening Angle in 2D on Side 2: 90 deg; Opening Angle in 3D: 0 deg; End Panel Opening Angle in 3D on Side 2: 0 deg; Opening Angle of Main Sash Side 1 (openingAngle_05): 0 deg; Opening Angle of Main Sash Side 1 (openingAngle2_05): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle_09): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle2_09): 0 deg; Opening Angle of Middle Transom (openingAngle_02): 0 deg; Opening Angle of Middle Transom (openingAngle2_02): 0 deg; Opening Angle of Transom Side 1 (openingAngle_06): 0 deg; Opening Angle of Transom Side 1 (openingAngle2_06): 0 deg; Opening Angle of Transom Side 2 (openingAngle_10): 0 deg; Opening Angle of Transom Side 2 (openingAngle2_10): 0 deg; Opening Line in 2D: no; Override MVO for 2D Symbolic Display: yes; Opening Line Type: 1; Opening Line Shape (or_SwingType): Curved; Opening Line Shape (or_iSwingType): 1; Opening Line Shape (or_SlidingType): Arrow; Opening Line Shape (or_iSlidingType): 1; Override MVO for 3D Projections: yes; Show Opening Line (or_bOplines3d): yes; Line Type Opening Side (or_opLineType3dIn): Dashed; Line Type Opening Side (or_iOpLineType3dIn): 1; Line Type Opposite Side (or_opLineType3dOut): Dashed; Line Type Opposite Side (or_iOpLineType3dOut): 1; Line Orientation (or_oplineStyle): Handle; Line Orientation (or_iOplineStyle): 1; Opening Line Pen in 2D/3D (or_opLinePen): Roofs/Shells - Outlines and Cover Fills; Opening Line Pen in 2D/3D (or_iOpLinePen): 92; Override MVO for Sidelight/Transom 3D Projections: no; Show Opening Line (or_bWinOplines3d): yes; Line Type Opening Side (or_winOpLineType3dIn): Dashed; Line Type Opening Side (or_iWinOpLineType3dIn): 1; Line Type Opposite Side (or_winOpLineType3dOut): Solid Line; Line Type Opposite Side (or_iWinOpLineType3dOut): 0; Line Orientation (or_winOplineStyle): Handle; Line Orientation (or_iWinOplineStyle): 1; Opening Line Pen in 2D/3D (or_winOpLinePen): Openings - General; Opening Line Pen in 2D/3D (or_iWinOpLinePen): 3; Symbol Pen: Openings - General; Frame Contour Pen: Openings - Cut Structural; Pocket Contour Pen: Openings - General; Casing Cut Line Pen on Both Sides: Openings - General; Leaf Contour Pen: Openings - General; Wall Contour Line (gs_wcont_line): Off; Wall Contour Line (iWallContourLine): 1; Wall Contour Line Type Inside: 1; Wall Contour Line Type Outside: 1; Hidden Wall Contour Line Type Inside: 4; Hidden Wall Contour Line Type Outside: 4; Sidelight Wall Contour Line: 4; Wall Contour Line Pen: Openings - General; Use Fills: yes; Frame Fill Type: Background; Frame Fill Pen: Openings - Cut Fills; Frame Fill Background Pen: Backgrounds - color 1; Leaf Fill Type: Air Space; Leaf Fill Pen: Backgrounds - color 1; Leaf Fill Background Pen: Backgrounds - color 1; Airtight Symbol Fill Type: Foreground; Airtight Symbol Fill Pen: General - General; Airtight Symbol Fill Background Pen: General - General; Plan Symbol Fill Type: Air Space; Plan Symbol Fill Pen: Transparent; Plan Symbol Fill Background Pen: Transparent; Sidelight Plan Symbol Fill Type: Background; Sidelight Plan Symbol Fill Pen: Backgrounds - color 1; Sidelight Plan Symbol Fill Background Pen: Backgrounds - color 1; Threshold and Sill Line Type: 1; Threshold Section Contour Pen: Openings - General; Threshold Section Fill Type: Background; Threshold Section Fill Pen: Backgrounds - color 1; Threshold Section Fill Background Pen: Backgrounds - color 1; Sill 3D and Uncut Pen: General - General; Sill Section Contour Pen: General - General; Sill Section Fill Type: Air Space; Sill Section Fill Pen: Backgrounds - color 1; Sill Section Fill Background Pen: Backgrounds - color 1; Section Insulation Contour Pen: General - General; Section Insulation Fill Type: Rigid Insulation; Section Insulation Fill Pen: General - General; Section Insulation Fill Background Pen: Backgrounds - color 1; Board 3D and Uncut Pen: General - General; Board Section Contour Pen: General - General; Board Section Fill Type: Air Space; Board Section Fill Pen: Backgrounds - color 1; Board Section Fill Bkg. Pen: Backgrounds - color 1; Casing Fill Type Inside: Air Space; Casing Fill Pen Inside: Backgrounds - color 1; Casing Fill Background Pen Inside: Backgrounds - color 1; Casing Fill Type Outside: Air Space; Casing Fill Pen Outside: Backgrounds - color 1; Casing Fill Background Pen Outside: Backgrounds - color 1; Arch Section Fill Type: Background; Arch Section Fill Pen: Backgrounds - color 1; Arch Section Fill Bkg. Pen: Backgrounds - color 1; Sunshade Symbol Line Type: 1; Sunshade Cut Line Pen: General - General; 3D/Section Uncut Line Pen: General - General; Sunshade Cut Fill Type: Background; Sunshade Cut Fill Pen: General - General; Sunshade Cut Fill Background Pen: Window Background; Sunshade Insulation Fill Type: Batt Insulation; Sunshade Insulation Fill Pen: General - General; Sunshade Insulation Background Pen: Window Background; Uncut Fill Type: Background; Uncut Fill Pen: Backgrounds - color 1; Uncut Fill Background Pen: Backgrounds - color 1; Opening Side Values (gs_opside_list): Custom; Opening Side Values (gs_opside_list_m): 0; Frame Element Joinery (gs_SashText_typ): Butt Joint; Frame Element Joinery (gs_SashText_typ_num): 2; Frame Pen: Openings - General; Leaf Pen: Openings - General; Sash Glass Pen: Openings - Cut Non-Structural; Leaf Glass Pen: Openings - Cut Non-Structural; Masonry Arch Pen: Walls/Curtain Walls - General; Curve Resolution: 24; Shadow: yes; Uniform Door Surfaces: no; Frame Outside: Wood - Pine Grained Horizontal; Frame Inside: Wood - Pine Grained Horizontal; Leaf Outside: Wood - Pine Grained Horizontal; Leaf Inside: Wood - Pine Grained Horizontal; Leaf 2: Wood - Pine Grained Horizontal; Leaf 3: Wood - Pine Grained Horizontal; Lock: Paint - Anthracite; Grid Outside (gs_grill_mat): Wood - Pine Grained Horizontal; Grid Inside (gs_grill_mat2): Wood - Pine Grained Horizontal; Grid Outside (gs_leaf_grill_mat): Wood - Pine Grained Horizontal; Grid Inside (gs_leaf_grill_mat2): Wood - Pine Grained Horizontal; Solid Panel Outside: Wood - Pine Grained Horizontal; Solid Panel Inside: Wood - Pine Grained Horizontal; Sash Glass: Glass - Clear Fast; Leaf Glass: Glass - Clear Fast; Rail (gs_rail_mat): Metal - Iron; Louver Outside: Wood - Pine Grained Horizontal; Louver Inside: Wood - Pine Grained Horizontal; Kick Plate: Metal - Aluminium; Uniform Casing Surfaces: yes; Interior Casing: Wood - Pine Grained Horizontal; Exterior Casing: Wood - Pine Grained Horizontal; Shutter Panel: Wood - Pine Grained Horizontal; Shutter Panel Frame: Wood - Pine Grained Horizontal; Rolling Shutter Box: Metal - Stainless Steel; Rolling Shutter Blades: Paint - Glossy White; Rolling Shutter Rail: Paint - Glossy White; Venetian Blinds Box: Metal - Stainless Steel; Venetian Blinds Segments: Paint - Glossy White; Sliding Shutter Rail: Metal - Stainless Steel; Threshold (gs_treshold_mat): Wood - Pine Grained Horizontal; Threshold Metal: Metal - Aluminium; Sill (gs_sill_mat): Brick - Running Bond; Brick Sill Mortar: Stucco - White Rough; Board (gs_board_mat): Wood - Pine Grained Horizontal; Handle: Metal - Stainless Steel; Handle Accessories: Metal - Iron; Kick Board Outside (matKickBoardOut): Metal - Stainless Steel; Kick Board Inside (matKickBoardIn): Metal - Stainless Steel; Masonry Arch Brick: Brick - Running Bond; Masonry Arch Mortar: Stucco - White Rough; Masonry Arch Keystone: Stone - Sandstone 01; Niche: Paint - Lead Oxide Yellow; Door belongs to the Zone into which it opens: yes; Cost: 0; Location as: Custom; Total Glazed Area (gs_list_glassarea_tmp): 0; Override Glazed Area: no; Total Glazed Area (gs_list_glassarea): 0; Total Glass Perimeter: 0; Group Type (FM_Type): Default Objects; Group Type (iFMType): 1; Object Weight: 0; Object Weight Unit: kg; Door Orientation Definition: 0; Door Closer: no; Vision Panel Type: No Vision Panel; Hold Open Device: no; Door Leaf Widths: 74; IFC Operation (ifc_optypestr): Other; IFC Operation (ifc_optype): 12
1 AMB.Identificacio - 103.AMB.Classificacio: 80.10.40.20 Portes d'accés; 104.AMB.ClassificacioCodi: 80.10.40.20; 105.AMB.ClassificacioDescripcio: Portes d'accés; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 80
AC_Equantity_Pocket_Door_27 - Z Dimension: 1 m; Bottom Level: 1 m; Top Level: 0 m; Sill Height to Current Story: 0.27 m; New Wall Fill Width Right: 0.15 m; New Wall Fill Width Left: 0.15 m; Shoulder Height: 2.2 m; Pivot Axis Offset: 0.275 m; Tolerance Right: 0 m; Tolerance Side 1 Lower: 0 m; Tolerance Sidelight 1 Bottom: 0 m; Tolerance Left: 0 m; Tolerance Side 2 Lower: 0 m; Tolerance Sidelight 2 Bottom: 0 m; Tolerance Upper: 0 m; Tolerance Lower: 0 m; Wallhole Width: 0.8 m; Wallhole Height: 2.6 m; Reveal Width: 0.8 m; Reveal Height: 2.6 m; Unit Width: 0.8 m; Unit Height: 2.6 m; Egress Width: 0.74 m; Egress Height: 2.57 m; Nominal Leaf Width: 0.74 m; Nominal Leaf Height: 2.57 m; Frame Thickness Inside: 0.115 m; Leaf Offset: 0.01 m; Frame Width: 0.03 m; Frame Width Side 1: 0.04 m; Middle Frame Width Side 1: 0.04 m; Bottom Frame Width Side 1: 0.04 m; Frame Width Side 2: 0.04 m; Middle Frame Width Side 2: 0.04 m; Bottom Frame Width Side 2: 0.04 m; Transom Frame Width (gs_frame_width_transom): 0.04 m; Upper Frame Width: 0.04 m; Door Stop Thickness: 0 m; Door Stop Width: 0 m; Rebate Width: 0 m; Leaf Rebate Depth in 3D: 0.04 m; Sidelight and Transom Rebate Width: 0.01 m; Sidelight and Transom Rebate Depth: 0.018 m; Pocket Frame Thickness: 0.023 m; Nominal Leaf Width Side 1: 0.37 m; Leaf Thickness: 0.04 m; Leaf Frame Width Side: 0.1 m; Leaf Frame Width Right: 0.1 m; Leaf Frame Width Left: 0.1 m; Leaf Frame Width Lower: 0.2 m; Leaf Frame Width Upper: 0.1 m; Leaf Frame Width Internal: 0.025 m; Leaf Undercut: 0 m; Grid Width: 0.012 m; Grid Thickness: 0.025 m; Glass Thickness: 0.012 m; Handle Height: 1 m; Handle Position: 0.05 m; Kick Board Height: 0.1 m; Horizontal Division Height Sidelight Side 1: 0.9 m; Horizontal Division Height Sidelight Side 2: 0.9 m; Horizontal Division Height Middle Transom: 0.9 m; Horizontal Division Height Transom Side 1: 0.9 m; Horizontal Division Height Transom Side 2: 0.9 m; Sidelight and Transom Frame Thickness: 0.044 m; Transom Frame Width (gs_sash_width): 0.067 m; Sidelight Frame Width: 0.067 m; Grill Width: 0.02 m; Grill Thickness: 0.025 m; Sidelight Division Width: 0.04 m; Sidelight Division Thickness: 0.05 m; Sidelight Width Right (gs_sidelight_width_right): 0 m; Sidelight Width Right (gs_sidelight_width_right_half): 0.15 m; Sidelight Width Right (gs_sidelight_width_right_orig): 0.3 m; Side 1 Sill Height: 0 m; Sidelight Width Left (gs_sidelight_width_left): 0 m; Sidelight Width Left (gs_sidelight_width_left_half): 0.15 m; Sidelight Width Left (gs_sidelight_width_left_orig): 0.3 m; Side Sill Height: 0 m; Transom Height: 0.3 m; Architrave Capital Width: 0.02 m; Width Side 1 (gs_tw_right_out): 0.05 m; Width Side 2 (gs_tw_left_out): 0.05 m; Width Top (gs_tw_top_out): 0.05 m; Thickness on Wall (gs_trim_thk_out): 0.019 m; Thickness in Wallhole (gs_trim_width_out): 0.025 m; Offset (gs_trim_offs_out): 0.012 m; Nosing (gs_trim_jambext_nosing_out): 0.05 m; Top Overhang (gs_trimov_top_left_out): 0.1 m; Top Overhang (gs_trimov_top_right_out): 0.1 m; Width Side 1 (gs_tw_right_in): 0.05 m; Width Side 2 (gs_tw_left_in): 0.05 m; Width Top (gs_tw_top_in): 0.05 m; Thickness on Wall (gs_trim_thk_in): 0.019 m; Thickness in Wallhole (gs_trim_width_in): 0.025 m; Offset (gs_trim_offs_in): 0.012 m; Nosing (gs_trim_jambext_nosing_in): 0.05 m; Top Overhang (gs_trimov_top_left_in): 0.1 m; Top Overhang (gs_trimov_top_right_in): 0.1 m; Threshold Thickness: 0.012 m; Threshold Width: 0 m; Threshold External Thickness: 0.00580738 m; Threshold Nosing Outside: 0.025 m; Threshold Nosing Inside: 0.025 m; Side Overhang Outside: 0 m; Side Overhang Inside: 0 m; Sill Thickness: 0.1 m; Sill Front Side Thickness: 0.015 m; Sill Elevation: 0.005 m; Sill Drip Overlap: 0.02 m; Sill Drip Width: 0.03 m; Sill Nosing: 0.03 m; Sill Overhang Side 1: 0 m; Sill Overhang Side 2: 0 m; Sill Slip-in Depth: 0.02 m; Sill Top Width: 0.01 m; Sill Top Height: 0.01 m; Sill Slip from Wall: 0 m; Rear Hole Depth (gs_sill_holeDepthBehind): 0 m; Width of Sill: 0 m; Brick Thickness (gs_brick_sill_br_thk): 0.065 m; Mortar Thickness (gs_brick_sill_mort_thk): 0.015 m; Board Width: 0.1 m; Board Thickness: 0.025 m; Board Nosing: 0.03 m; Board Overhang Side 1: 0 m; Board Overhang Side 2: 0 m; Board Slip-in Depth: 0 m; Panel Height: 1.5 m; Inner Offset: 0.02 m; Closing Depth: 0 m; Extra Frame Width: 0.04 m; Extra Frame Thickness: 0.03 m; Rail Width: 0.03 m; Hanging Stick Length: 0.02 m; Hanging Stick Radius: 0.005 m; Panel Distance: 0.006 m; Outside Overhang: 0 m; Inner Panel Width: 0.12 m; 3D Opening Length: 1.5 m; 3D Closed Length: 0 m; 3D Opening Length 1: 0.56 m; 3D Opening Length 2: 0.14 m; 3D Opening Height: 1.5 m; 3D Closed Height: 0 m; Panel Thickness: 0.05 m; Panel Frame Width: 0.05 m; Frame Width Bottom: 0.05 m; Panel Width: 0 m; Panel Fill Thickness: 0.01 m; Louver Thickness: 0.01 m; Louver Width: 0.04 m; Horizontal Frame Divider Width: 0.05 m; Vertical Frame Divider Width: 0.05 m; Hole Radius: 0.01 m; Vertical Board Width: 0.1 m; Z Frame Width: 0.05 m; Z Frame Thickness: 0.025 m; Vertical Boards Thickness: 0.025 m; Horizontal Boards Thickness: 0.025 m; Vertical Boards Approximate Width: 0.08 m; Horizontal Boards Approximate Width: 0.115 m; Box Height (gs_shutRoll_boxHeight): 0.2 m; Box Depth (gs_shutRoll_boxWidth): 0.15 m; Box Left Offset: 0 m; Box Right Offset: 0 m; Depth of Rails: 0.0725 m; Distance from Wall (gs_shutRoll_distFromWall): 0 m; Distance from Header (gs_shutRoll_distFromHead): 0 m; Slat Width: 0.05 m; Box Height (gs_shutLam_boxHeight): 0.2 m; Box Depth (gs_shutLam_boxWidth): 0.15 m; Cover Width: 0 m; Distance from Wall (gs_shutLam_distFromWall): 0 m; Distance from Header (gs_shutLam_distFromHead): 0 m; Segment Width (gs_shutLam_segmentWidth): 0.06 m; Box Height (gs_shutLam2_boxHeight): 0.06 m; Box Width: 0.06 m; Distance from Window: 0.06 m; Distance from Header (gs_shutLam2_distFromHead): 0.06 m; Box Axis Height from Header: 0 m; Segment Width (gs_shutLam2_segmentWidth): 0.06 m; Distance between Arch and Door: 0 m; Masonry Arch Overhang Side 1: 0 m; Masonry Arch Overhang Side 2: 0 m; Masonry Arch Rise: 0.03 m; Masonry Arch Projection: 0 m; Masonry Arch Height: 0.25 m; Masonry Arch Depth: 0.12 m; Rear Hole Depth (gs_masonry_arch_rearHoleDepth): 0 m; Brick Thickness (gs_masonry_arch_brick_thk): 0.065 m; Mortar Thickness (gs_masonry_arch_mort_thk): 0.01 m; Keystone Width: 0.1 m; Keystone Oversize: 0 m; Keystone Projection: 0.01 m; Jamb Depth: 0.06 m; Jamb Depth Side 2: 0.06 m; Lower Jamb Depth Side 1: 0.06 m; Lower Jamb Depth Side 2: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_splayed_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_splayed_innerRight): 0.06 m; Inner Jamb Depth (gs_reveal_double_innerRight): 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_double_innerLeft): 0.06 m; Inner Lower Jamb Depth Side 1: 0.06 m; Inner Lower Jamb Depth Side 2: 0.06 m; Head Depth: 0.06 m; Sill Depth: 0.06 m; Sill Depth Side 1: 0.06 m; Sill Depth Side 2: 0.06 m; Inner Head Depth (gs_reveal_splayed_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_splayed_innerBottom): 0.06 m; Inner Head Depth (gs_reveal_double_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_double_innerBottom): 0.06 m; Inner Sill Depth Side 1: 0 m; Inner Sill Depth Side 2: 0 m; Outer Jamb Depth: 0.08 m; Plaster Thickness Limit: 0.04 m; Distance of Skin from Closer: 0 m; Closer Width: 0.038 m; Closer Thickness: 0.1 m; Strip Thickness: 0.025 m; Profile Width: 0.15 m; Custom Thickness: 0.015 m; Skin Overhang to Frame Depth: 0 m; Left Opening Oversize: 0 m; Right Opening Oversize: 0 m; Upper Opening Oversize: 0 m; Lower Opening Oversize: 0 m; Opening Width in 3D on Side 2: 0 m; Opening Width in 2D on Side 2: 0 m; Opening Distance 1 Main Sash Side 1: 0 m; Opening Distance 2 Main Sash Side 1: 0 m; Opening Distance 1 Main Sash Side 2: 0 m; Opening Distance 2 Main Sash Side 2: 0 m; Opening Distance 1 Middle Transom: 0 m; Opening Distance 2 Middle Transom: 0 m; Opening Distance 1 Transom Side 1: 0 m; Opening Distance 2 Transom Side 1: 0 m; Opening Distance 1 Transom Side 2: 0 m; Opening Distance 2 Transom Side 2: 0 m; Opening Width in 3D (gs_open): 0.1 m; Width 1: 0.25 m; Width 2: 0.31 m; Opening Side Depth: 1.2 m; Opposite Side Width 2: 0.25 m; Opposite Side Width 1: 0.31 m; Opposite Side Depth: 1.2 m; Opposite Side Width: 1.3 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m; Real Frame Thickness: 0.14 m
ArchiCADQuantities - W/D Opening Surface Area: 6.01599 m2; W/D Opening Nominal Surface Area: 2.08 m2; W/D Opening Width on the Reveal Side: 0.8 m; W/D Opening Height on the Reveal Side: 2.6 m; W/D Opening Width on the Side Opposite to the Reveal Side: 0.8 m; W/D Opening Height on the Side Opposite to the Reveal Side: 2.6 m; W/D Opening Surface Area on the Reveal Side: 2.08 m2; W/D Opening Surface Area on the Side Opposite to the Reveal Side: 2.08 m2; Nominal W/D Opening Width on the Reveal Side: 0.8 m; Nominal W/D Opening Height on the Reveal Side: 2.6 m; Nominal W/D Opening Width on the Side Opposite to the Reveal Side: 0.8 m; Nominal W/D Opening Height on the Side Opposite to the Reveal Side: 2.6 m; Nominal W/D Opening Surface Area on the Reveal Side: 2.08 m2; Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side: 2.08 m2; Sill/Header Value: 0.27 m; W/D Nominal Sill Height: 0.27 m; W/D Sill Height on the Reveal Side: 0 m; W/D Sill Height on the Side Opposite to the Reveal Side: 0 m; W/D Nominal Head Height: 2.87 m; W/D Head Height on the Reveal Side: 2.5 m; W/D Head Height on the Side Opposite to the Reveal Side: 2.5 m; Frame Thickness: 0.14 m; Height: 2.6 m; Volume (Net): 0.0971757 m3; Width: 0.8 m; Elevation to Project Zero: 0.27 m; Elevation to 1st Reference Level: 0.27 m; Elevation to 2nd Reference Level: 0.27 m; Elevation to Sea Level: 9.61 m; Elevation to Linked/Home Story: 0.27 m; Home Offset: 0.27 m; Surface Area: 6.01599 m2; Top Elevation To First Reference Level: 2.87 m; Top Elevation To Home Story: 2.87 m; Top Elevation To Project Zero: 2.87 m; Top Elevation To Sea Level: 12.21 m; Top Elevation To Second Reference Level: 2.87 m; Bottom Elevation To First Reference Level: 0.27 m; Bottom Elevation To Home Story: 0.27 m; Bottom Elevation To Project Zero: 0.27 m; Bottom Elevation To Sea Level: 9.61 m; Bottom Elevation To Second Reference Level: 0.27 m; Bottom Surface Area (Net): 6.01599 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.8 m; 503.AMB.Altura: 2.6 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0971757 m3; Component, Component Volume (Gross): 0.0971757 m3
Name | Nominal W x H x T Size | Wall Structure | Orientation = Door Orientation | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Colliding Zones | Parent ID | Wall Direction Type | Opening Direction | Parapet Wall Inset Value | Frame Thickness=Wall Thickness | Reveal Type (gs_reveal_type_new) | Reveal Type (gs_reveal_type_int) | Bottom Reveal Type (gs_reveal_type_bottom) | Bottom Reveal Type (gs_reveal_type_bottom_int) | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | AUX_107.NomTipus | Reveal to Wall Core (m) = Reveal Depth (gs_wido_sill) (m) = Reveal Depth (AC_wido_sill) (m) | Frame Thickness (m) | Opening Width in 3D (gs_open3D) (m) | Opening Width in 2D (m) | W/D Opening Opening Volume (m3) | W/D Opening Nominal Volume (m3) | Wall Thickness (m)
PI013 | 800,0×2.600,0×140,0 | Concrete 18 (1) | R | PI013 | Lavabo; Nau Santa Eulàlia | T5 | 3 | 1 | 2 | yes | No Reveal - Edge | 1 | No Reveal | 2 | PI013_PortaIntTipusE | Porta de pi amb fulla corredissa de 72.5cm | PortaIntTipusE | 0 | 0.06 | 0.595349 | 0 | 0.383078 | 0.2912 | 0.14
PI003 | 800,0×2.600,0×140,0 | Concrete 18 (1) | R | PI003 | Nau Santa Eulàlia; Office | T3 | 3 | 0 | 3 | no | No Reveal - Edge | 1 | Uniform | 1 | PI003_PortaIntTipusD | Porta de pi amb doble fulla de 72.5cm | PortaIntTipusD | 0 | 0.14 | 0 | 0.1 | 0.383078 | 0.2912 | 0.14
PI007 | 800,0×2.600,0×110,0 | Concrete 18 (5) | L | PI007 | Nau Santa Eulàlia | T3 | 0 | 1 | 2 | no | No Reveal | 2 | Uniform | 1 | PI007_PortaIntTipusD | Porta de pi amb doble fulla de 72.5cm | PortaIntTipusD | -0.03 | 0.14 | 2.55351e-15 | 0.1 | 0.320677 | 0.2288 | 0.11

# IfcBuildingElementProxy: Pocket Double Door 27 (4)
In: planta baixa
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0; Status: NEW; LoadBearing: no
ArchiCADProperties - Marker Text: <Custom Text>; Opening Library Part Name: Pocket Double Door 27; Opening Side Fill Index: Background; Library Part Name: Pocket Double Door 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Door; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Non-Load-Bearing Element; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
