Properties of the parts of a building model (IFC2X3), part 39 of 99

# IfcBuildingElementProxy: Rhino_Object_1331, Object_1331
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1331; Hotlink and Element ID: Object_1331; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1331; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1331; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1331 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1331_; 109.AMB.CodiTipus: Object_1331; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23628 m; Elevation to 1st Reference Level: 1.23628 m; Elevation to 2nd Reference Level: 1.23628 m; Elevation to Sea Level: 10.5763 m; Elevation to Linked/Home Story: 1.23628 m; Home Offset: 1.23628 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35636 m; Top Elevation To Home Story: 1.35636 m; Top Elevation To Project Zero: 1.35636 m; Top Elevation To Sea Level: 10.6964 m; Top Elevation To Second Reference Level: 1.35636 m; Bottom Elevation To First Reference Level: 1.23628 m; Bottom Elevation To Home Story: 1.23628 m; Bottom Elevation To Project Zero: 1.23628 m; Bottom Elevation To Sea Level: 10.5763 m; Bottom Elevation To Second Reference Level: 1.23628 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5763 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1331 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1332, Object_1332
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1332 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1332; Hotlink and Element ID: Object_1332; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1332; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1332; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23636 m; Elevation to 1st Reference Level: 1.23636 m; Elevation to 2nd Reference Level: 1.23636 m; Elevation to Sea Level: 10.5764 m; Elevation to Linked/Home Story: 1.23636 m; Home Offset: 1.23636 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35644 m; Top Elevation To Home Story: 1.35644 m; Top Elevation To Project Zero: 1.35644 m; Top Elevation To Sea Level: 10.6964 m; Top Elevation To Second Reference Level: 1.35644 m; Bottom Elevation To First Reference Level: 1.23636 m; Bottom Elevation To Home Story: 1.23636 m; Bottom Elevation To Project Zero: 1.23636 m; Bottom Elevation To Sea Level: 10.5764 m; Bottom Elevation To Second Reference Level: 1.23636 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5764 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1332 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1332_; 109.AMB.CodiTipus: Object_1332; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1333, Object_1333
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1333; Hotlink and Element ID: Object_1333; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1333; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1333; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1333 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1333_; 109.AMB.CodiTipus: Object_1333; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23644 m; Elevation to 1st Reference Level: 1.23644 m; Elevation to 2nd Reference Level: 1.23644 m; Elevation to Sea Level: 10.5764 m; Elevation to Linked/Home Story: 1.23644 m; Home Offset: 1.23644 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35652 m; Top Elevation To Home Story: 1.35652 m; Top Elevation To Project Zero: 1.35652 m; Top Elevation To Sea Level: 10.6965 m; Top Elevation To Second Reference Level: 1.35652 m; Bottom Elevation To First Reference Level: 1.23644 m; Bottom Elevation To Home Story: 1.23644 m; Bottom Elevation To Project Zero: 1.23644 m; Bottom Elevation To Sea Level: 10.5764 m; Bottom Elevation To Second Reference Level: 1.23644 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5764 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1333 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1334, Object_1334
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1334 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23652 m; Elevation to 1st Reference Level: 1.23652 m; Elevation to 2nd Reference Level: 1.23652 m; Elevation to Sea Level: 10.5765 m; Elevation to Linked/Home Story: 1.23652 m; Home Offset: 1.23652 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.3566 m; Top Elevation To Home Story: 1.3566 m; Top Elevation To Project Zero: 1.3566 m; Top Elevation To Sea Level: 10.6966 m; Top Elevation To Second Reference Level: 1.3566 m; Bottom Elevation To First Reference Level: 1.23652 m; Bottom Elevation To Home Story: 1.23652 m; Bottom Elevation To Project Zero: 1.23652 m; Bottom Elevation To Sea Level: 10.5765 m; Bottom Elevation To Second Reference Level: 1.23652 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5765 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1334_; 109.AMB.CodiTipus: Object_1334; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1334 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1334; Hotlink and Element ID: Object_1334; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1334; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1334; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1335, Object_1335
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1335; Hotlink and Element ID: Object_1335; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1335; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1335; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1335 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1335_; 109.AMB.CodiTipus: Object_1335; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.2366 m; Elevation to 1st Reference Level: 1.2366 m; Elevation to 2nd Reference Level: 1.2366 m; Elevation to Sea Level: 10.5766 m; Elevation to Linked/Home Story: 1.2366 m; Home Offset: 1.2366 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35668 m; Top Elevation To Home Story: 1.35668 m; Top Elevation To Project Zero: 1.35668 m; Top Elevation To Sea Level: 10.6967 m; Top Elevation To Second Reference Level: 1.35668 m; Bottom Elevation To First Reference Level: 1.2366 m; Bottom Elevation To Home Story: 1.2366 m; Bottom Elevation To Project Zero: 1.2366 m; Bottom Elevation To Sea Level: 10.5766 m; Bottom Elevation To Second Reference Level: 1.2366 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5766 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1335 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1336, Object_1336
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1336; Hotlink and Element ID: Object_1336; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1336; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1336; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1336 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1336_; 109.AMB.CodiTipus: Object_1336; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23668 m; Elevation to 1st Reference Level: 1.23668 m; Elevation to 2nd Reference Level: 1.23668 m; Elevation to Sea Level: 10.5767 m; Elevation to Linked/Home Story: 1.23668 m; Home Offset: 1.23668 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35676 m; Top Elevation To Home Story: 1.35676 m; Top Elevation To Project Zero: 1.35676 m; Top Elevation To Sea Level: 10.6968 m; Top Elevation To Second Reference Level: 1.35676 m; Bottom Elevation To First Reference Level: 1.23668 m; Bottom Elevation To Home Story: 1.23668 m; Bottom Elevation To Project Zero: 1.23668 m; Bottom Elevation To Sea Level: 10.5767 m; Bottom Elevation To Second Reference Level: 1.23668 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5767 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1336 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1337, Object_1337
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1337; Hotlink and Element ID: Object_1337; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1337; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1337; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1337 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1337_; 109.AMB.CodiTipus: Object_1337; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23676 m; Elevation to 1st Reference Level: 1.23676 m; Elevation to 2nd Reference Level: 1.23676 m; Elevation to Sea Level: 10.5768 m; Elevation to Linked/Home Story: 1.23676 m; Home Offset: 1.23676 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35684 m; Top Elevation To Home Story: 1.35684 m; Top Elevation To Project Zero: 1.35684 m; Top Elevation To Sea Level: 10.6968 m; Top Elevation To Second Reference Level: 1.35684 m; Bottom Elevation To First Reference Level: 1.23676 m; Bottom Elevation To Home Story: 1.23676 m; Bottom Elevation To Project Zero: 1.23676 m; Bottom Elevation To Sea Level: 10.5768 m; Bottom Elevation To Second Reference Level: 1.23676 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5768 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1337 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1338, Object_1338
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1338; Hotlink and Element ID: Object_1338; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1338; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1338; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1338 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1338_; 109.AMB.CodiTipus: Object_1338; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23684 m; Elevation to 1st Reference Level: 1.23684 m; Elevation to 2nd Reference Level: 1.23684 m; Elevation to Sea Level: 10.5768 m; Elevation to Linked/Home Story: 1.23684 m; Home Offset: 1.23684 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35692 m; Top Elevation To Home Story: 1.35692 m; Top Elevation To Project Zero: 1.35692 m; Top Elevation To Sea Level: 10.6969 m; Top Elevation To Second Reference Level: 1.35692 m; Bottom Elevation To First Reference Level: 1.23684 m; Bottom Elevation To Home Story: 1.23684 m; Bottom Elevation To Project Zero: 1.23684 m; Bottom Elevation To Sea Level: 10.5768 m; Bottom Elevation To Second Reference Level: 1.23684 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5768 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1338 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1339, Object_1339
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1339; Hotlink and Element ID: Object_1339; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1339; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1339; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1339 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1339_; 109.AMB.CodiTipus: Object_1339; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23691 m; Elevation to 1st Reference Level: 1.23691 m; Elevation to 2nd Reference Level: 1.23691 m; Elevation to Sea Level: 10.5769 m; Elevation to Linked/Home Story: 1.23691 m; Home Offset: 1.23691 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.357 m; Top Elevation To Home Story: 1.357 m; Top Elevation To Project Zero: 1.357 m; Top Elevation To Sea Level: 10.697 m; Top Elevation To Second Reference Level: 1.357 m; Bottom Elevation To First Reference Level: 1.23691 m; Bottom Elevation To Home Story: 1.23691 m; Bottom Elevation To Project Zero: 1.23691 m; Bottom Elevation To Sea Level: 10.5769 m; Bottom Elevation To Second Reference Level: 1.23691 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5769 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1339 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_134, Object_134
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_134; Hotlink and Element ID: Object_134; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_134; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_134; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_134 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_134_; 109.AMB.CodiTipus: Object_134; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_134 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1340, Object_1340
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1340; Hotlink and Element ID: Object_1340; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1340; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1340; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1340 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1340_; 109.AMB.CodiTipus: Object_1340; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23699 m; Elevation to 1st Reference Level: 1.23699 m; Elevation to 2nd Reference Level: 1.23699 m; Elevation to Sea Level: 10.577 m; Elevation to Linked/Home Story: 1.23699 m; Home Offset: 1.23699 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35707 m; Top Elevation To Home Story: 1.35707 m; Top Elevation To Project Zero: 1.35707 m; Top Elevation To Sea Level: 10.6971 m; Top Elevation To Second Reference Level: 1.35707 m; Bottom Elevation To First Reference Level: 1.23699 m; Bottom Elevation To Home Story: 1.23699 m; Bottom Elevation To Project Zero: 1.23699 m; Bottom Elevation To Sea Level: 10.577 m; Bottom Elevation To Second Reference Level: 1.23699 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.577 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1340 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1341, Object_1341
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1341; Hotlink and Element ID: Object_1341; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1341; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1341; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1341 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1341_; 109.AMB.CodiTipus: Object_1341; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1341 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23707 m; Elevation to 1st Reference Level: 1.23707 m; Elevation to 2nd Reference Level: 1.23707 m; Elevation to Sea Level: 10.5771 m; Elevation to Linked/Home Story: 1.23707 m; Home Offset: 1.23707 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35715 m; Top Elevation To Home Story: 1.35715 m; Top Elevation To Project Zero: 1.35715 m; Top Elevation To Sea Level: 10.6972 m; Top Elevation To Second Reference Level: 1.35715 m; Bottom Elevation To First Reference Level: 1.23707 m; Bottom Elevation To Home Story: 1.23707 m; Bottom Elevation To Project Zero: 1.23707 m; Bottom Elevation To Sea Level: 10.5771 m; Bottom Elevation To Second Reference Level: 1.23707 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5771 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1342, Object_1342
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23715 m; Elevation to 1st Reference Level: 1.23715 m; Elevation to 2nd Reference Level: 1.23715 m; Elevation to Sea Level: 10.5772 m; Elevation to Linked/Home Story: 1.23715 m; Home Offset: 1.23715 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35723 m; Top Elevation To Home Story: 1.35723 m; Top Elevation To Project Zero: 1.35723 m; Top Elevation To Sea Level: 10.6972 m; Top Elevation To Second Reference Level: 1.35723 m; Bottom Elevation To First Reference Level: 1.23715 m; Bottom Elevation To Home Story: 1.23715 m; Bottom Elevation To Project Zero: 1.23715 m; Bottom Elevation To Sea Level: 10.5772 m; Bottom Elevation To Second Reference Level: 1.23715 m; Survey Coordinate X: 426539 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5772 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1342 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1342; Hotlink and Element ID: Object_1342; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1342; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1342; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1342_; 109.AMB.CodiTipus: Object_1342; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Equantity_Rhino_Object_1342 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1343, Object_1343
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1343 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1343; Hotlink and Element ID: Object_1343; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1343; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1343; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1343_; 109.AMB.CodiTipus: Object_1343; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23723 m; Elevation to 1st Reference Level: 1.23723 m; Elevation to 2nd Reference Level: 1.23723 m; Elevation to Sea Level: 10.5772 m; Elevation to Linked/Home Story: 1.23723 m; Home Offset: 1.23723 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35731 m; Top Elevation To Home Story: 1.35731 m; Top Elevation To Project Zero: 1.35731 m; Top Elevation To Sea Level: 10.6973 m; Top Elevation To Second Reference Level: 1.35731 m; Bottom Elevation To First Reference Level: 1.23723 m; Bottom Elevation To Home Story: 1.23723 m; Bottom Elevation To Project Zero: 1.23723 m; Bottom Elevation To Sea Level: 10.5772 m; Bottom Elevation To Second Reference Level: 1.23723 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.5772 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1343 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1345, Object_1345
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1345; Hotlink and Element ID: Object_1345; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1345; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1345; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1345 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23132 m; Elevation to 1st Reference Level: 1.23132 m; Elevation to 2nd Reference Level: 1.23132 m; Elevation to Sea Level: 10.5713 m; Elevation to Linked/Home Story: 1.23132 m; Home Offset: 1.23132 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.3514 m; Top Elevation To Home Story: 1.3514 m; Top Elevation To Project Zero: 1.3514 m; Top Elevation To Sea Level: 10.6914 m; Top Elevation To Second Reference Level: 1.3514 m; Bottom Elevation To First Reference Level: 1.23132 m; Bottom Elevation To Home Story: 1.23132 m; Bottom Elevation To Project Zero: 1.23132 m; Bottom Elevation To Sea Level: 10.5713 m; Bottom Elevation To Second Reference Level: 1.23132 m; Survey Coordinate X: 426553 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 10.5713 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1345_; 109.AMB.CodiTipus: Object_1345; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1345 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg

# IfcBuildingElementProxy: Rhino_Object_1346, Object_1346
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1346; Hotlink and Element ID: Object_1346; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1346; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1346; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
