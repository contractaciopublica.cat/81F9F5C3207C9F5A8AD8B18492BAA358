Properties of the parts of a building model (IFC2X3), part 67 of 99

# IfcBuildingElementProxy: Rhino_Object_1748, Object_1748
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426546 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1748 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1749, Object_1749
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1749; Hotlink and Element ID: Object_1749; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1749; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1749; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1749 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1749_; 109.AMB.CodiTipus: Object_1749; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1749 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426546 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1750, Object_1750
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1750; Hotlink and Element ID: Object_1750; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1750; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1750; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1750 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426546 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1750 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1750_; 109.AMB.CodiTipus: Object_1750; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1751, Object_1751
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1751; Hotlink and Element ID: Object_1751; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1751; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1751; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1751 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1751_; 109.AMB.CodiTipus: Object_1751; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1751 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426545 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1752, Object_1752
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1752; Hotlink and Element ID: Object_1752; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1752; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1752; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1752 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1752_; 109.AMB.CodiTipus: Object_1752; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426545 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1752 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3

# IfcBuildingElementProxy: Rhino_Object_1753, Object_1753
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1753; Hotlink and Element ID: Object_1753; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1753; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1753; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1753 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1753_; 109.AMB.CodiTipus: Object_1753; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1753 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426545 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2

# IfcBuildingElementProxy: Rhino_Object_1754, Object_1754
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1754; Hotlink and Element ID: Object_1754; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1754; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1754; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1754 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1754_; 109.AMB.CodiTipus: Object_1754; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1754 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426545 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2

# IfcBuildingElementProxy: Rhino_Object_1755, Object_1755
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1755; Hotlink and Element ID: Object_1755; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1755; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1755; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1755 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1755_; 109.AMB.CodiTipus: Object_1755; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426545 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1755 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1756, Object_1756
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1756; Hotlink and Element ID: Object_1756; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1756; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1756; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1756 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1756_; 109.AMB.CodiTipus: Object_1756; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3
AC_Equantity_Rhino_Object_1756 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m

# IfcBuildingElementProxy: Rhino_Object_1757, Object_1757
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1757; Hotlink and Element ID: Object_1757; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1757; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1757; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1757 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1757 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1757_; 109.AMB.CodiTipus: Object_1757; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1758, Object_1758
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1758 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1758_; 109.AMB.CodiTipus: Object_1758; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1758 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1758; Hotlink and Element ID: Object_1758; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1758; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1758; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1759, Object_1759
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1759; Hotlink and Element ID: Object_1759; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1759; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1759; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1759 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1759_; 109.AMB.CodiTipus: Object_1759; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1759 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3

# IfcBuildingElementProxy: Rhino_Object_1760, Object_1760
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1760; Hotlink and Element ID: Object_1760; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1760; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1760; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1760 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1760_; 109.AMB.CodiTipus: Object_1760; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1760 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1761, Object_1761
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1761; Hotlink and Element ID: Object_1761; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1761; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1761; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1761 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1761_; 109.AMB.CodiTipus: Object_1761; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1761 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1762, Object_1762
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1762; Hotlink and Element ID: Object_1762; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1762; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1762; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1762 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1762_; 109.AMB.CodiTipus: Object_1762; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426544 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1762 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3

# IfcBuildingElementProxy: Rhino_Object_1763, Object_1763
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1763; Hotlink and Element ID: Object_1763; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1763; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1763; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1763 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1763_; 109.AMB.CodiTipus: Object_1763; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1763 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
