Properties of the parts of a building model (IFC2X3), part 44 of 99

# IfcBuildingElementProxy: Rhino_Object_1418 (2)
AC_Pset_Rhino_Object_1418 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1418_; 109.AMB.CodiTipus: Object_1418; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.280422 m; Area: 0.116174 m2; Height: 0.757696 m; Volume (Net): 0.0695445 m3; Width: 0.414283 m; Surface Area: 1.12347 m2; Survey Coordinate X: 426591 m; Top Surface Area (Net): 0.116174 m2; Bottom Surface Area (Net): 1.12347 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.414283 m; 503.AMB.Altura: 0.757696 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0695445 m3; Component, Component Volume (Gross): 0.0695445 m3
AC_Equantity_Rhino_Object_1418 - Dimension 1: 0.280422 m; Dimension 2: 0.414283 m; Height: 0.757696 m; Bottom Level: -1.73177e-11 m; Top Level: 0.757696 m
Name | Rotation Angle (deg) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Survey Coordinate Y (m)
Object_1418 | 13.5006 | 5.82289 | 15.1629 | 6.58059 | 15.9206 | 4579794
Object_1418 | 283.516 | 5.82389 | 15.1639 | 6.58159 | 15.9216 | 4579793

# IfcBuildingElementProxy: Rhino_Object_1419, Object_1419
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1419; Hotlink and Element ID: Object_1419; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1419; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1419; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1419 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1419_; 109.AMB.CodiTipus: Object_1419; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.604168 m; Area: 0.365019 m2; Height: 0.129997 m; Volume (Net): 0.0422969 m3; Width: 0.604168 m; Elevation to Project Zero: 6.36397 m; Elevation to 1st Reference Level: 6.36397 m; Elevation to 2nd Reference Level: 6.36397 m; Elevation to Sea Level: 15.704 m; Elevation to Linked/Home Story: 6.36397 m; Home Offset: 6.36397 m; Surface Area: 0.947344 m2; Top Elevation To First Reference Level: 6.49397 m; Top Elevation To Home Story: 6.49397 m; Top Elevation To Project Zero: 6.49397 m; Top Elevation To Sea Level: 15.834 m; Top Elevation To Second Reference Level: 6.49397 m; Bottom Elevation To First Reference Level: 6.36397 m; Bottom Elevation To Home Story: 6.36397 m; Bottom Elevation To Project Zero: 6.36397 m; Bottom Elevation To Sea Level: 15.704 m; Bottom Elevation To Second Reference Level: 6.36397 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 15.704 m; Top Surface Area (Net): 0.365019 m2; Bottom Surface Area (Net): 0.947344 m2
AC_Equantity_Rhino_Object_1419 - Dimension 1: 0.604168 m; Dimension 2: 0.604168 m; Height: 0.129997 m; Bottom Level: 0 m; Top Level: 0.129997 m
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.604168 m; 503.AMB.Altura: 0.129997 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0422969 m3; Component, Component Volume (Gross): 0.0422969 m3

# IfcBuildingElementProxy: Rhino_Object_142, Object_142
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_142 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_142; Hotlink and Element ID: Object_142; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_142; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_142; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_142_; 109.AMB.CodiTipus: Object_142; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426572 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_142 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1420, Object_1420
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1420; Hotlink and Element ID: Object_1420; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1420; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1420; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1420 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1420_; 109.AMB.CodiTipus: Object_1420; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1420 - Dimension 1: 0.291848 m; Dimension 2: 0.297897 m; Height: 0.125946 m; Bottom Level: 0 m; Top Level: 0.125946 m
Component Quantities - Component, Component Volume (Net): 0.00921471 m3; Component, Component Volume (Gross): 0.00921471 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.297897 m; 503.AMB.Altura: 0.125946 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 0.291848 m; Area: 0.0869404 m2; Height: 0.125946 m; Volume (Net): 0.00921471 m3; Width: 0.297897 m; Elevation to Project Zero: 6.58159 m; Elevation to 1st Reference Level: 6.58159 m; Elevation to 2nd Reference Level: 6.58159 m; Elevation to Sea Level: 15.9216 m; Elevation to Linked/Home Story: 6.58159 m; Home Offset: 6.58159 m; Surface Area: 0.282693 m2; Top Elevation To First Reference Level: 6.70753 m; Top Elevation To Home Story: 6.70753 m; Top Elevation To Project Zero: 6.70753 m; Top Elevation To Sea Level: 16.0475 m; Top Elevation To Second Reference Level: 6.70753 m; Bottom Elevation To First Reference Level: 6.58159 m; Bottom Elevation To Home Story: 6.58159 m; Bottom Elevation To Project Zero: 6.58159 m; Bottom Elevation To Sea Level: 15.9216 m; Bottom Elevation To Second Reference Level: 6.58159 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 15.9216 m; Top Surface Area (Net): 0.0869404 m2; Bottom Surface Area (Net): 0.282693 m2

# IfcBuildingElementProxy: Rhino_Object_1421, Object_1421
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1421; Hotlink and Element ID: Object_1421; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1421; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1421; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1421 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1421_; 109.AMB.CodiTipus: Object_1421; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.504711 m; Area: 0.261721 m2; Height: 0.0876197 m; Volume (Net): 0.0204399 m3; Width: 0.518556 m; Elevation to Project Zero: 6.49397 m; Elevation to 1st Reference Level: 6.49397 m; Elevation to 2nd Reference Level: 6.49397 m; Elevation to Sea Level: 15.834 m; Elevation to Linked/Home Story: 6.49397 m; Home Offset: 6.49397 m; Surface Area: 0.635857 m2; Top Elevation To First Reference Level: 6.58159 m; Top Elevation To Home Story: 6.58159 m; Top Elevation To Project Zero: 6.58159 m; Top Elevation To Sea Level: 15.9216 m; Top Elevation To Second Reference Level: 6.58159 m; Bottom Elevation To First Reference Level: 6.49397 m; Bottom Elevation To Home Story: 6.49397 m; Bottom Elevation To Project Zero: 6.49397 m; Bottom Elevation To Sea Level: 15.834 m; Bottom Elevation To Second Reference Level: 6.49397 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 15.834 m; Top Surface Area (Net): 0.261721 m2; Bottom Surface Area (Net): 0.635857 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.518556 m; 503.AMB.Altura: 0.0876197 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1421 - Dimension 1: 0.504711 m; Dimension 2: 0.518556 m; Height: 0.0876197 m; Bottom Level: 0 m; Top Level: 0.0876197 m
Component Quantities - Component, Component Volume (Net): 0.0204399 m3; Component, Component Volume (Gross): 0.0204399 m3

# IfcBuildingElementProxy: Rhino_Object_1422, Object_1422
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1422_; 109.AMB.CodiTipus: Object_1422; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1422 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1422; Hotlink and Element ID: Object_1422; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1422; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1422; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
ArchiCADQuantities - Length (A): 0.153084 m; Area: 0.0237665 m2; Height: 0.125946 m; Volume (Net): 0.00242903 m3; Width: 0.155251 m; Elevation to Project Zero: 6.64102 m; Elevation to 1st Reference Level: 6.64102 m; Elevation to 2nd Reference Level: 6.64102 m; Elevation to Sea Level: 15.981 m; Elevation to Linked/Home Story: 6.64102 m; Home Offset: 6.64102 m; Surface Area: 0.108639 m2; Top Elevation To First Reference Level: 6.76696 m; Top Elevation To Home Story: 6.76696 m; Top Elevation To Project Zero: 6.76696 m; Top Elevation To Sea Level: 16.107 m; Top Elevation To Second Reference Level: 6.76696 m; Bottom Elevation To First Reference Level: 6.64102 m; Bottom Elevation To Home Story: 6.64102 m; Bottom Elevation To Project Zero: 6.64102 m; Bottom Elevation To Sea Level: 15.981 m; Bottom Elevation To Second Reference Level: 6.64102 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 15.981 m; Top Surface Area (Net): 0.0237665 m2; Bottom Surface Area (Net): 0.108639 m2
AC_Equantity_Rhino_Object_1422 - Dimension 1: 0.153084 m; Dimension 2: 0.155251 m; Height: 0.125946 m; Bottom Level: 0 m; Top Level: 0.125946 m
5 AMB.Geometria - 502.AMB.Amplada: 0.155251 m; 503.AMB.Altura: 0.125946 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00242903 m3; Component, Component Volume (Gross): 0.00242903 m3

# IfcBuildingElementProxy: Rhino_Object_1423 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1423 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 2; Overhead Lines: 1; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 5; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_1423; Hotlink and Element ID: Object_1423; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_1423; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1423; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1423_; 109.AMB.CodiTipus: Object_1423; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 1.75171 m; Area: 2.21145 m2; Height: 0.317008 m; Volume (Net): 0.177999 m3; Width: 1.26245 m; Elevation to Project Zero: 5.13867 m; Elevation to 1st Reference Level: 5.13867 m; Elevation to 2nd Reference Level: 5.13867 m; Elevation to Sea Level: 14.4787 m; Elevation to Linked/Home Story: 5.13867 m; Home Offset: 5.13867 m; Surface Area: 2.61515 m2; Top Elevation To First Reference Level: 5.45567 m; Top Elevation To Home Story: 5.45567 m; Top Elevation To Project Zero: 5.45567 m; Top Elevation To Sea Level: 14.7957 m; Top Elevation To Second Reference Level: 5.45567 m; Bottom Elevation To First Reference Level: 5.13867 m; Bottom Elevation To Home Story: 5.13867 m; Bottom Elevation To Project Zero: 5.13867 m; Bottom Elevation To Sea Level: 14.4787 m; Bottom Elevation To Second Reference Level: 5.13867 m; Survey Coordinate Z: 14.4787 m; Top Surface Area (Net): 2.21145 m2; Bottom Surface Area (Net): 2.61515 m2
AC_Equantity_Rhino_Object_1423 - Dimension 1: 1.75171 m; Dimension 2: 1.26245 m; Height: 0.317008 m; Bottom Level: -4.3114e-07 m; Top Level: 0.317008 m
5 AMB.Geometria - 502.AMB.Amplada: 1.26245 m; 503.AMB.Altura: 0.317008 m; 506.AMB.Profunditat: 0 m
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Component Quantities - Component, Component Volume (Net): 0.177999 m3; Component, Component Volume (Gross): 0.177999 m3
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_1423 | 4.73844 | 426558 | 4579790
Object_1423 | 35.6782 | 426569 | 4579794

# IfcBuildingElementProxy: Rhino_Object_1426 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.2792 deg; Surface: Brick - Aged Natural; Element ID: Object_1426; Hotlink and Element ID: Object_1426; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1426; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1426; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1426 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0533076 m; Area: 0.00752645 m2; Height: 0.352017 m; Volume (Net): 0.002464 m3; Width: 0.141189 m; Surface Area: 0.14776 m2; Top Surface Area (Net): 0.00752645 m2; Bottom Surface Area (Net): 0.14776 m2
AC_Equantity_Rhino_Object_1426 - Dimension 1: 0.0533076 m; Dimension 2: 0.141189 m; Height: 0.352017 m; Bottom Level: -1.77636e-15 m; Top Level: 0.352017 m
5 AMB.Geometria - 502.AMB.Amplada: 0.141189 m; 503.AMB.Altura: 0.352017 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.002464 m3; Component, Component Volume (Gross): 0.002464 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1426_; 109.AMB.CodiTipus: Object_1426; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Name | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_1426 | 5.3149 | 14.6549 | 5.66691 | 15.0069 | 426560 | 4579786
Object_1426 | 5.79896 | 15.139 | 6.15098 | 15.491 | 426561 | 4579785

# IfcBuildingElementProxy: Rhino_Object_1427, Object_1427
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.2792 deg; Surface: Brick - Aged Natural; Element ID: Object_1427; Hotlink and Element ID: Object_1427; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1427; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1427; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1427 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1427_; 109.AMB.CodiTipus: Object_1427; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.053451 m; Area: 0.00786971 m2; Height: 0.352018 m; Volume (Net): 0.00257039 m3; Width: 0.147232 m; Elevation to Project Zero: 4.88818 m; Elevation to 1st Reference Level: 4.88818 m; Elevation to 2nd Reference Level: 4.88818 m; Elevation to Sea Level: 14.2282 m; Elevation to Linked/Home Story: 4.88818 m; Home Offset: 4.88818 m; Surface Area: 0.15262 m2; Top Elevation To First Reference Level: 5.24019 m; Top Elevation To Home Story: 5.24019 m; Top Elevation To Project Zero: 5.24019 m; Top Elevation To Sea Level: 14.5802 m; Top Elevation To Second Reference Level: 5.24019 m; Bottom Elevation To First Reference Level: 4.88818 m; Bottom Elevation To Home Story: 4.88818 m; Bottom Elevation To Project Zero: 4.88818 m; Bottom Elevation To Sea Level: 14.2282 m; Bottom Elevation To Second Reference Level: 4.88818 m; Survey Coordinate X: 426560 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 14.2282 m; Top Surface Area (Net): 0.00786971 m2; Bottom Surface Area (Net): 0.15262 m2
AC_Equantity_Rhino_Object_1427 - Dimension 1: 0.053451 m; Dimension 2: 0.147232 m; Height: 0.352018 m; Bottom Level: -1.77636e-15 m; Top Level: 0.352018 m
5 AMB.Geometria - 502.AMB.Amplada: 0.147232 m; 503.AMB.Altura: 0.352018 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00257039 m3; Component, Component Volume (Gross): 0.00257039 m3

# IfcBuildingElementProxy: Rhino_Object_1428, Object_1428
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.2792 deg; Surface: Brick - Aged Natural; Element ID: Object_1428; Hotlink and Element ID: Object_1428; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_1428; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1428; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1428 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 2; Overhead Lines: 1; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 5; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1428_; 109.AMB.CodiTipus: Object_1428; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.656408 m; Area: 3.81433 m2; Height: 1.38302 m; Volume (Net): 1.03729 m3; Width: 5.81091 m; Elevation to Project Zero: 5.24018 m; Elevation to 1st Reference Level: 5.24018 m; Elevation to 2nd Reference Level: 5.24018 m; Elevation to Sea Level: 14.5802 m; Elevation to Linked/Home Story: 5.24018 m; Home Offset: 5.24018 m; Surface Area: 11.6941 m2; Top Elevation To First Reference Level: 6.6232 m; Top Elevation To Home Story: 6.6232 m; Top Elevation To Project Zero: 6.6232 m; Top Elevation To Sea Level: 15.9632 m; Top Elevation To Second Reference Level: 6.6232 m; Bottom Elevation To First Reference Level: 5.24018 m; Bottom Elevation To Home Story: 5.24018 m; Bottom Elevation To Project Zero: 5.24018 m; Bottom Elevation To Sea Level: 14.5802 m; Bottom Elevation To Second Reference Level: 5.24018 m; Survey Coordinate X: 426560 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 14.5802 m; Top Surface Area (Net): 3.81433 m2; Bottom Surface Area (Net): 11.6941 m2
AC_Equantity_Rhino_Object_1428 - Dimension 1: 0.656408 m; Dimension 2: 5.81091 m; Height: 1.38302 m; Bottom Level: -7.10543e-15 m; Top Level: 1.38302 m
5 AMB.Geometria - 502.AMB.Amplada: 5.81091 m; 503.AMB.Altura: 1.38302 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 1.03729 m3; Component, Component Volume (Gross): 1.03729 m3

# IfcBuildingElementProxy: Rhino_Object_1429, Object_1429
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7227 deg; Surface: Brick - Aged Natural; Element ID: Object_1429; Hotlink and Element ID: Object_1429; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_1429; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1429; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1429_; 109.AMB.CodiTipus: Object_1429; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_1429 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 2; Overhead Lines: 1; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 5; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.607649 m; Area: 3.52859 m2; Height: 1.38302 m; Volume (Net): 1.03729 m3; Width: 5.80695 m; Elevation to Project Zero: 5.25847 m; Elevation to 1st Reference Level: 5.25847 m; Elevation to 2nd Reference Level: 5.25847 m; Elevation to Sea Level: 14.5985 m; Elevation to Linked/Home Story: 5.25847 m; Home Offset: 5.25847 m; Surface Area: 11.6942 m2; Top Elevation To First Reference Level: 6.64149 m; Top Elevation To Home Story: 6.64149 m; Top Elevation To Project Zero: 6.64149 m; Top Elevation To Sea Level: 15.9815 m; Top Elevation To Second Reference Level: 6.64149 m; Bottom Elevation To First Reference Level: 5.25847 m; Bottom Elevation To Home Story: 5.25847 m; Bottom Elevation To Project Zero: 5.25847 m; Bottom Elevation To Sea Level: 14.5985 m; Bottom Elevation To Second Reference Level: 5.25847 m; Survey Coordinate X: 426568 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 14.5985 m; Top Surface Area (Net): 3.52859 m2; Bottom Surface Area (Net): 11.6942 m2
5 AMB.Geometria - 502.AMB.Amplada: 5.80695 m; 503.AMB.Altura: 1.38302 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 1.03729 m3; Component, Component Volume (Gross): 1.03729 m3
AC_Equantity_Rhino_Object_1429 - Dimension 1: 0.607649 m; Dimension 2: 5.80695 m; Height: 1.38302 m; Bottom Level: -2.85488e-07 m; Top Level: 1.38302 m

# IfcBuildingElementProxy: Rhino_Object_143, Object_143
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426572 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_143 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_143_; 109.AMB.CodiTipus: Object_143; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_143 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_143; Hotlink and Element ID: Object_143; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_143; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_143; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1431, Object_1431
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.2792 deg; Surface: Brick - Aged Natural; Element ID: Object_1431; Hotlink and Element ID: Object_1431; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1431; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1431; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1431 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1431_; 109.AMB.CodiTipus: Object_1431; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.75127 m; Area: 20.5479 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3508 m; Elevation to Project Zero: 5.88768 m; Elevation to 1st Reference Level: 5.88768 m; Elevation to 2nd Reference Level: 5.88768 m; Elevation to Sea Level: 15.2277 m; Elevation to Linked/Home Story: 5.88768 m; Home Offset: 5.88768 m; Surface Area: 0.443443 m2; Top Elevation To First Reference Level: 5.99422 m; Top Elevation To Home Story: 5.99422 m; Top Elevation To Project Zero: 5.99422 m; Top Elevation To Sea Level: 15.3342 m; Top Elevation To Second Reference Level: 5.99422 m; Bottom Elevation To First Reference Level: 5.88768 m; Bottom Elevation To Home Story: 5.88768 m; Bottom Elevation To Project Zero: 5.88768 m; Bottom Elevation To Sea Level: 15.2277 m; Bottom Elevation To Second Reference Level: 5.88768 m; Survey Coordinate X: 426561 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 15.2277 m; Top Surface Area (Net): 20.5479 m2; Bottom Surface Area (Net): 0.443443 m2
AC_Equantity_Rhino_Object_1431 - Dimension 1: 0.75127 m; Dimension 2: 27.3508 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3508 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1432, Object_1432
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.2792 deg; Surface: Brick - Aged Natural; Element ID: Object_1432; Hotlink and Element ID: Object_1432; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1432; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1432; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1432 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1432_; 109.AMB.CodiTipus: Object_1432; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.75127 m; Area: 20.5479 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3508 m; Elevation to Project Zero: 5.40437 m; Elevation to 1st Reference Level: 5.40437 m; Elevation to 2nd Reference Level: 5.40437 m; Elevation to Sea Level: 14.7444 m; Elevation to Linked/Home Story: 5.40437 m; Home Offset: 5.40437 m; Surface Area: 0.454836 m2; Top Elevation To First Reference Level: 5.51091 m; Top Elevation To Home Story: 5.51091 m; Top Elevation To Project Zero: 5.51091 m; Top Elevation To Sea Level: 14.8509 m; Top Elevation To Second Reference Level: 5.51091 m; Bottom Elevation To First Reference Level: 5.40437 m; Bottom Elevation To Home Story: 5.40437 m; Bottom Elevation To Project Zero: 5.40437 m; Bottom Elevation To Sea Level: 14.7444 m; Bottom Elevation To Second Reference Level: 5.40437 m; Survey Coordinate X: 426560 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 14.7444 m; Top Surface Area (Net): 20.5479 m2; Bottom Surface Area (Net): 0.454836 m2
AC_Equantity_Rhino_Object_1432 - Dimension 1: 0.75127 m; Dimension 2: 27.3508 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3508 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1433, Object_1433
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.2792 deg; Surface: Brick - Aged Natural; Element ID: Object_1433; Hotlink and Element ID: Object_1433; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1433; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1433; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1433 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1433_; 109.AMB.CodiTipus: Object_1433; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.75127 m; Area: 20.5479 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3508 m; Elevation to Project Zero: 4.97765 m; Elevation to 1st Reference Level: 4.97765 m; Elevation to 2nd Reference Level: 4.97765 m; Elevation to Sea Level: 14.3177 m; Elevation to Linked/Home Story: 4.97765 m; Home Offset: 4.97765 m; Surface Area: 0.426456 m2; Top Elevation To First Reference Level: 5.08419 m; Top Elevation To Home Story: 5.08419 m; Top Elevation To Project Zero: 5.08419 m; Top Elevation To Sea Level: 14.4242 m; Top Elevation To Second Reference Level: 5.08419 m; Bottom Elevation To First Reference Level: 4.97765 m; Bottom Elevation To Home Story: 4.97765 m; Bottom Elevation To Project Zero: 4.97765 m; Bottom Elevation To Sea Level: 14.3177 m; Bottom Elevation To Second Reference Level: 4.97765 m; Survey Coordinate X: 426560 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 14.3177 m; Top Surface Area (Net): 20.5479 m2; Bottom Surface Area (Net): 0.426456 m2
AC_Equantity_Rhino_Object_1433 - Dimension 1: 0.75127 m; Dimension 2: 27.3508 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3508 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Rhino_Object_1434, Object_1434
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Component Quantities - Component, Component Volume (Net): 0.011856 m3; Component, Component Volume (Gross): 0.011856 m3
5 AMB.Geometria - 502.AMB.Amplada: 1.5208 m; 503.AMB.Altura: 0.156183 m; 506.AMB.Profunditat: 0 m
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1434 - Dimension 1: 0.0883971 m; Dimension 2: 1.5208 m; Height: 0.156183 m; Bottom Level: -1.06581e-14 m; Top Level: 0.156183 m
ArchiCADQuantities - Length (A): 0.0883971 m; Area: 0.134434 m2; Height: 0.156183 m; Volume (Net): 0.011856 m3; Width: 1.5208 m; Elevation to Project Zero: 5.99422 m; Elevation to 1st Reference Level: 5.99422 m; Elevation to 2nd Reference Level: 5.99422 m; Elevation to Sea Level: 15.3342 m; Elevation to Linked/Home Story: 5.99422 m; Home Offset: 5.99422 m; Surface Area: 0.64184 m2; Top Elevation To First Reference Level: 6.1504 m; Top Elevation To Home Story: 6.1504 m; Top Elevation To Project Zero: 6.1504 m; Top Elevation To Sea Level: 15.4904 m; Top Elevation To Second Reference Level: 6.1504 m; Bottom Elevation To First Reference Level: 5.99422 m; Bottom Elevation To Home Story: 5.99422 m; Bottom Elevation To Project Zero: 5.99422 m; Bottom Elevation To Sea Level: 15.3342 m; Bottom Elevation To Second Reference Level: 5.99422 m; Survey Coordinate X: 426561 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 15.3342 m; Top Surface Area (Net): 0.134434 m2; Bottom Surface Area (Net): 0.64184 m2
AC_Pset_Rhino_Object_1434 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
