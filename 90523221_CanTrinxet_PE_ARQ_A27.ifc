Properties of the parts of a building model (IFC2X3), part 97 of 99

# IfcOpeningElement (289)
Name | Depth (m) | BaseQuantities, Height (m) | BaseQuantities, Width (m) | BaseQuantities, Area (m2) | Volume (m3) | Classification | Shape | Orientation | Limits | Cut Symbol Name | Uncut Symbol Name | IDs of Cut Elements | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Layer | Colliding Zones | Locked | Home Story Name = 115.AMB.Nivell | Home Story Number = Slant Angle (deg) = 506.AMB.Profunditat (m) = Opening End Surface Area (Net, total) (m2) | Element Type | Parent ID | Surfaces (All) | Design Option Name = Design Option Set Name = Design Option Status = Design Option Set | Position | Renovation Status | Show On Renovation Filter | 001.AMB.ExpedientNumero | 003.AMB.NomProjecte | 004.AMB.FaseProjecte | 007.AMB.ModelDisciplina | 008.AMB.Adreca | 009.AMB.Municipi | 010.AMB.AutorProjecte | 011.AMB.AutorProjecte2 | 012.AMB.AutorProjecte3 | 107.AMB.NomTipus | 117.AMB.Localitzacio | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | Status | 502.AMB.Amplada (m) = ArchiCADQuantities, Width (m) | 503.AMB.Altura (m) = ArchiCADQuantities, Height (m) | Sill Height to Home Story (m) = Sill Height to Project Zero (m) | Header Height to Home Story (m) = Header Height to Project Zero (m) | Total Thickness (m) | Number of Cut Elements | Center Height to Home Story (m) = Center Height to Project Zero (m) | Sill Height to Wall Bottom (m) | Sill Height to Wall Top (m) | Center Height to Wall Bottom (m) | Center Height to Wall Top (m) | Header Height to Wall Bottom (m) | Header Height to Wall Top (m) | Opening Extrusion Surface Area (Net) (m2) = Surface Area (m2) = Edge Surface Area (Net) (m2) = Bottom Surface Area (Net) (m2) | ArchiCADQuantities, Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) | Elevation to Sea Level (m) | Home Offset (m) | 3D Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m)
OP - 003 | 0.4 | 2.60747 | 2.4 | 6.25792 | 2.50317 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 2.4 | 2.60747 | 0.27 | 2.87747 | 0.4 | 1 | 1.57373 | 1.22808 | -4.03892 | 2.53182 | -2.73518 | 3.83555 | -1.43145 | 4.00597 | 6.25792 | 2.50317 | 2.87747 | 12.2175 | 0.27 | 10.0149 | 2.87747 | 12.2175 | 0.27 | 9.61 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 | 0.874 | 0.301704 | 0.263689 | 0.105476 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.301704 | 0.874 | 2.40347 | 3.27747 | 0.4 | 1 | 2.84047 | 3.36155 | -1.90545 | 3.79855 | -1.46845 | 4.23555 | -1.03145 | 0.940563 | 0.263689 | 0.105476 | 3.27747 | 12.6175 | 2.40347 | 2.35141 | 3.27747 | 12.6175 | 2.40347 | 11.7435 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 | 0.874 | 0.29998 | 0.262182 | 0.104873 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.29998 | 0.874 | 2.40347 | 3.27747 | 0.4 | 1 | 2.84047 | 3.36155 | -1.90545 | 3.79855 | -1.46845 | 4.23555 | -1.03145 | 0.939184 | 0.262182 | 0.104873 | 3.27747 | 12.6175 | 2.40347 | 2.34796 | 3.27747 | 12.6175 | 2.40347 | 11.7435 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
PI003 | 0.14 | 2.6 | 0.8 | 2.08 | 0.0971757
2 x OP - 003 | 0.4 |  |  | 0.859539 | 0.343816 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.452644 | 2.03962 | 1.49422 | 3.53384 | 0.4 | 1 | 2.51403 | 2.4523 | -3.0457 | 3.47211 | -2.0259 | 4.49192 | -1.00609 | 1.98702 | 0.859539 | 0.343816 | 3.53384 | 12.8738 | 1.49422 | 4.96754 | 3.53384 | 12.8738 | 1.49422 | 10.8342 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
3 x OP - 003 | 0.4 |  |  | 0.423538 | 0.169415 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.457933 | 1.04239 |  |  | 0.4 | 1 |  |  |  |  |  |  |  | 1.20026 | 0.423538 | 0.169415 | 3.50675 | 12.8467 | 3.50675 | 3.00064 | 3.50675 | 12.8467 | 2.46436 | 11.8044 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
2 x OP - 003 | 0.4 |  |  | 0.859364 | 0.343746 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.452644 | 2.03962 | 1.49422 | 3.53384 | 0.4 | 1 | 2.51403 | 2.4523 | -3.0457 | 3.47211 | -2.0259 | 4.49192 | -1.00609 | 1.98702 | 0.859364 | 0.343746 | 3.53384 | 12.8738 | 1.49422 | 4.96754 | 3.53384 | 12.8738 | 1.49422 | 10.8342 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
4 x OP - 003 | 0.4 |  |  | 1.04194 | 0.416774 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.55 | 2.02004 |  |  | 0.4 | 1 |  |  |  |  |  |  |  | 2.05604 | 1.04194 | 0.416774 | 3.51142 | 12.8514 | 3.51142 | 5.14009 | 3.51142 | 12.8514 | 1.49138 | 10.8314 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
3 x OP - 003 | 0.4 |  |  | 0.859364 | 0.343746 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.452644 | 2.03962 |  |  | 0.4 | 1 |  |  |  |  |  |  |  | 1.98702 | 0.859364 | 0.343746 | 3.53384 | 12.8738 | 3.53384 | 4.96754 | 3.53384 | 12.8738 | 1.49422 | 10.8342 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 |  |  | 1.04194 | 0.416774 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.55 | 2.02004 |  |  | 0.4 | 1 |  |  |  |  |  |  |  | 2.05604 | 1.04194 | 0.416774 | 3.51427 | 12.8543 | 3.51427 | 5.14009 | 3.51427 | 12.8543 | 1.49422 | 10.8342 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 |  |  | 1.04194 | 0.416774 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.55 | 2.02004 |  |  | 0.4 | 1 |  |  |  |  |  |  |  | 2.05603 | 1.04194 | 0.416774 | 3.51427 | 12.8543 | 3.51427 | 5.14009 | 3.51427 | 12.8543 | 1.49422 | 10.8342 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
3 x OP - 003 | 0.4 |  |  | 1.04194 | 0.416774 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.55 | 2.02004 |  |  | 0.4 | 1 |  |  |  |  |  |  |  | 2.05604 | 1.04194 | 0.416774 | 3.51332 | 12.8533 | 3.51332 | 5.14009 | 3.51332 | 12.8533 | 1.49327 | 10.8333 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 x OP - 003 | 0.4 |  |  | 1.04194 | 0.416774 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.55 | 2.02004 |  |  | 0.4 | 1 |  |  |  |  |  |  |  | 2.05603 | 1.04194 | 0.416774 | 3.51332 | 12.8533 | 3.51332 | 5.14009 | 3.51332 | 12.8533 | 1.49327 | 10.8333 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
PE002 | 0.16 | 3.23889 | 1.3901 | 4.42746 | 0.0831429
28 x OP - 003 | 0.3 | 0.747969 | 0.460187 | 0.344206 | 0.103262 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | SW - 052 | OP - 003 | 00_MURS PREEXISTENT |  | no | planta baixa | 0 | Opening | SW - 052 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.460187 | 0.747969 | 4.62175 | 5.36972 | 0.3 | 1 | 4.99573 | 0.0818211 | -1.54684 | 0.455806 | -1.17285 | 0.829791 | -0.798868 | 0.724894 | 0.344206 | 0.103262 | 5.36972 | 14.7097 | 4.62175 | 2.41631 | 5.36972 | 14.7097 | 4.62175 | 13.9617 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 006 | 0.03 | 0.861579 | 0.452644 | 0.389989 | 0.00310934 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 006 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 006_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | -0.40764 | -1.85457 | 0.0231503 | -1.42378 | 0.45394 | -0.992988 | 0.0204679 | 0.389989 | 0.00310934 | 3.32594 | 12.6659 | 2.46436 | 2.62845 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 004 | 0.03 | 1.83374 | 0.452644 | 0.830033 | 0.00615301 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 1.83374 | 1.49137 | 3.32512 | 0.03 | 1 | 2.40824 | -1.38063 | -2.82756 | -0.463756 | -1.91068 | 0.453116 | -0.993812 | 0.0271728 | 0.830033 | 0.00615301 | 3.32512 | 12.6651 | 1.49137 | 4.57278 | 3.32512 | 12.6651 | 2.872 | 12.212
V013 | 0.16 | 1.708 | 0.929675 | 1.58789 | 0.0126656
5 x OP - 004 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00746276 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | -1.3798 | -2.82673 | -0.462932 | -1.90986 | 0.45394 | -0.992988 | 0.0300582 | 1.00489 | 0.00746276 | 3.32594 | 12.6659 | 1.4922 | 4.76349 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 003 | 0 | 1.549 | 0.543 | 0.841106 | 0 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F5 | OP - 003 | 00_MURS PREEXISTENT |  | no | planta baixa | 0 | Opening | F5 |  | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ |  | Preexistències | EXISTING | 0.543 | 1.549 | 8.22716 | 9.77616 | 0 | 1 | 9.00166 | 8.50291 | -2.17984 | 9.27741 | -1.40534 | 10.0519 | -0.630839 | 0 | 0.841106 | 0 | 9.77616 | 19.1162 | 8.22716 | 4.184 | 0 | 9.34 | 0 | 9.34
OP - 004 | 0.4 |  |  | 11.381 | 4.1688 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F5 | OP - 004 | 00_MURS PREEXISTENT |  | no | planta baixa | 0 | Opening | F5 | Concrete - Bush hammered | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Lateral | Preexistències | EXISTING | 7.72563 | 2.9254 | 7.58335 | 10.5088 | 0.4 | 1 | 9.04605 | 7.8591 | -2.82365 | 9.3218 | -1.36095 | 10.7845 | 0.101758 | 4.19851 | 11.381 | 4.1688 | 10.5088 | 19.8488 | 7.58335 | 21.3103 | 10.407 | 19.747 | 7.58335 | 16.9234 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 |  |  | 1.13097 | 0.453036 | 00.20 Preexistències (GuBIMclass CA) | Circle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F5 | OP - 003 | 00_MURS PREEXISTENT |  | no | planta baixa | 0 | Opening | F5 | Concrete - Bush hammered | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Preexistències | EXISTING | 1.2 | 1.2 | 7.14686 | 8.34686 | 0.4 | 1 | 7.74686 | 7.42261 | -3.26014 | 8.02261 | -2.66014 | 8.62261 | -2.06014 | 1.51012 | 1.13097 | 0.453036 | 8.34686 | 17.6869 | 7.14686 | 3.76991 | 8.34686 | 17.6869 | 7.14686 | 16.4869 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
2 x OP - 003 | 0.4 |  |  | 4.08163 | 1.6329 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F5 | OP - 003 | 00_MURS PREEXISTENT | Espai públic; Nau Lateral | no | planta baixa | 0 | Opening | F5 | Concrete - Bush hammered | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Preexistències | EXISTING | 1.72397 | 2.41375 | 2.66699 | 5.08182 | 0.4 | 1 | 3.87441 | 2.94274 | -7.74001 | 4.15015 | -6.53259 | 5.35757 | -5.32518 | 3.21045 | 4.08163 | 1.6329 | 5.08075 | 14.4207 | 2.66699 | 8.02562 | 5.08182 | 14.4218 | 2.66699 | 12.007 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 |  |  | 0.441786 | 0.177055 | 00.20 Preexistències (GuBIMclass CA) | Circle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F5 | OP - 003 | 00_MURS PREEXISTENT |  | no | planta baixa | 0 | Opening | F5 | Concrete - Bush hammered | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Preexistències | EXISTING | 0.75 | 0.75 | 7.40004 | 8.15004 | 0.4 | 1 | 7.77504 | 7.67579 | -3.00696 | 8.05079 | -2.63196 | 8.42579 | -2.25696 | 0.944482 | 0.441786 | 0.177055 | 8.15004 | 17.49 | 7.40004 | 2.35619 | 8.15004 | 17.49 | 7.40004 | 16.74 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 | 1.708 | 0.929675 | 1.58789 | 0.635154 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.929675 | 1.708 | 1.63947 | 3.34747 | 0.4 | 1 | 2.49347 | 2.59755 | -3.61756 | 3.45155 | -2.76356 | 4.30555 | -1.90956 | 2.11014 | 1.58789 | 0.635154 | 3.34747 | 12.6875 | 1.63947 | 5.27535 | 3.34747 | 12.6875 | 1.63947 | 10.9795 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 |  |  | 4.88296 | 1.95342 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Infinite |  | Projection 1 Fill Opening 27 | SW - 052 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | SW - 052 | Brick - Aged Natural | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 1.41 | 3.51371 | 0.0788369 | 3.59379 | 0.4 | 1 | 1.83631 | 1.03692 | -5.60664 | 2.79439 | -3.84916 | 4.55187 | -2.09168 | 3.83336 | 4.88296 | 1.95342 | 3.59255 | 12.9325 | 0.0788369 | 9.58268 | 3.59379 | 12.9338 | 0.0788369 | 9.41884 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00; ArchiCADProperties - Opening Extrusion Surface: Brick - Aged Natural; Edge Surface: Brick - Aged Natural
OP - 003 | 0.4 | 1.708 | 0.929675 | 1.58789 | 0.635154 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.929675 | 1.708 | 1.63947 | 3.34747 | 0.4 | 1 | 2.49347 | 2.59755 | -3.51053 | 3.45155 | -2.65653 | 4.30555 | -1.80253 | 2.11014 | 1.58789 | 0.635154 | 3.34747 | 12.6875 | 1.63947 | 5.27535 | 3.34747 | 12.6875 | 1.63947 | 10.9795 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
PI201 | 0.08 | 2.6 | 1.72003 | 4.47208 | 0.100595
OP - 003 | 0.4 |  |  | 4.6905 | 1.87644 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Infinite |  | Projection 1 Fill Opening 27 | SW - 052 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | SW - 052 | Brick - Aged Natural | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 1.3505 | 3.5282 | 0.07 | 3.59878 | 0.4 | 1 | 1.83439 | 1.02808 | -5.49691 | 2.79247 | -3.73252 | 4.55687 | -1.96812 | 3.79021 | 4.6905 | 1.87644 | 3.5982 | 12.9382 | 0.07 | 9.47468 | 3.59878 | 12.9388 | 0.07 | 9.41 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00; ArchiCADProperties - Opening Extrusion Surface: Brick - Aged Natural; Edge Surface: Brick - Aged Natural
OP - 003 | 0.4 |  |  | 4.86708 | 1.94381 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Limited on one side |  | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 1.39291 | 3.54635 | 0.0988536 | 3.64632 | 0.4 | 1 | 1.87258 | 1.05694 | -5.58662 | 2.83067 | -3.81289 | 4.6044 | -2.03916 | 2.48657 | 4.86708 | 1.94381 | 3.6452 | 12.9852 | 0.0988536 | 9.60722 | 3.64632 | 12.9863 | 0.0988536 | 9.43885 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 005 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00746276 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 005 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | -1.3798 | -2.82673 | -0.462932 | -1.90986 | 0.45394 | -0.992988 | 0.0300582 | 1.00489 | 0.00746276 | 3.32594 | 12.6659 | 1.4922 | 4.76349 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 005 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00746276 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 005 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 005_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | -1.3798 | -2.82673 | -0.462932 | -1.90986 | 0.45394 | -0.992988 | 0.0436764 | 1.00489 | 0.00746276 | 3.32594 | 12.6659 | 1.4922 | 4.76349 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 004 | 0.03 | 0.859554 | 0.45293 | 0.389317 | 0.00303731 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.45293 | 0.859554 | 2.46639 | 3.32594 | 0.03 | 1 | 2.89616 | -0.405614 | -1.85254 | 0.0241631 | -1.42277 | 0.45394 | -0.992988 | 0.0203092 | 0.389317 | 0.00303731 | 3.32594 | 12.6659 | 2.46639 | 2.62497 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 004 | 0.03 | 1.83374 | 0.45293 | 0.830557 | 0.00619561 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.45293 | 1.83374 | 1.49422 | 3.32797 | 0.03 | 1 | 2.41109 | -1.37778 | -2.82471 | -0.460906 | -1.90783 | 0.455966 | -0.990963 | 0.0272669 | 0.830557 | 0.00619561 | 3.32797 | 12.668 | 1.49422 | 4.57335 | 3.32797 | 12.668 | 2.872 | 12.212
OP - 004 | 0.03 | 1.83374 | 0.452644 | 0.830033 | 0.0061397 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | -1.3798 | -2.82673 | -0.462932 | -1.90986 | 0.45394 | -0.992988 | 0.0271435 | 0.830033 | 0.0061397 | 3.32594 | 12.6659 | 1.4922 | 4.57278 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 004 | 0.03 | 0.861579 | 0.221034 | 0.190439 | 0.00301009 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.221034 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | -0.40764 | -1.85457 | 0.0231503 | -1.42378 | 0.45394 | -0.992988 | 0.0202492 | 0.190439 | 0.00301009 | 3.32594 | 12.6659 | 2.46436 | 2.16523 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 003 | 0.55 |  |  | 7.49345 | 4.12178 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F5 | OP - 003 | 00_MURS PREEXISTENT | Nau Lateral | no | planta baixa | 0 | Opening | F5 | Brick - Aged Natural | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Preexistències | EXISTING | 1.59919 | 4.73522 | 1.57675 | 6.31323 | 0.55 | 1 | 3.94499 | 1.8525 | -5.5643 | 4.22074 | -3.19606 | 6.58898 | -0.827817 | 6.82332 | 7.49345 | 4.12178 | 6.31198 | 15.652 | 1.57675 | 12.4054 | 6.31323 | 15.6532 | 1.57675 | 10.9168 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00; ArchiCADProperties - Opening Extrusion Surface: Brick - Aged Natural; Edge Surface: Brick - Aged Natural
OP - 003 | 0.55 |  |  | 6.07235 | 3.34022 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F5 | OP - 003 | 00_MURS PREEXISTENT | Nau Lateral | no | planta baixa | 0 | Opening | F5 | Brick - Aged Natural | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Preexistències | EXISTING | 1.78948 | 3.46262 | 1.57675 | 5.04064 | 0.55 | 1 | 3.30869 | 1.8525 | -5.5643 | 3.58444 | -3.83236 | 5.31638 | -2.10041 | 5.58055 | 6.07235 | 3.34022 | 5.03937 | 14.3794 | 1.57675 | 10.1457 | 5.04064 | 14.3806 | 1.57675 | 10.9168 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00; ArchiCADProperties - Opening Extrusion Surface: Brick - Aged Natural; Edge Surface: Brick - Aged Natural
OP - 003 | 0.55 |  |  | 4.86824 | 2.6779 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F5 | OP - 003 | 00_MURS PREEXISTENT | Nau Lateral | no | planta baixa | 0 | Opening | F5 | Paint - Stucco Yellow | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Preexistències | EXISTING | 1.59919 | 3.09563 | 3.2226 | 6.31943 | 0.55 | 1 | 4.77101 | 3.49834 | -3.91845 | 5.04676 | -2.37004 | 6.59518 | -0.82162 | 5.01463 | 4.86824 | 2.6779 | 6.31822 | 15.6582 | 3.2226 | 9.11687 | 6.31943 | 15.6594 | 3.2226 | 12.5626 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 | 0.58 | 0.45 | 0.261 | 0.1044 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F6; F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F6 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.45 | 0.58 | 2.24347 | 2.82347 | 0.4 | 2 | 2.53347 | 3.20155 | -2.0655 | 3.49155 | -1.7755 | 3.78155 | -1.4855 | 0.824 | 0.261 | 0.1044 | 2.82347 | 12.1635 | 2.24347 | 2.06 | 2.82347 | 12.1635 | 2.24347 | 11.5835 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 | 1.708 | 0.929675 | 1.58789 | 0.635154 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | SW - 052 | OP - 003 | 00_MURS PREEXISTENT | Espai públic; Nau Santa Eulàlia | no | planta baixa | 0 | Opening | SW - 052 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.929675 | 1.708 | 1.63947 | 3.34747 | 0.4 | 1 | 2.49347 | 2.59755 | -3.61737 | 3.45155 | -2.76337 | 4.30555 | -1.90937 | 2.11014 | 1.58789 | 0.635154 | 3.34747 | 12.6875 | 1.63947 | 5.27535 | 3.34747 | 12.6875 | 1.63947 | 10.9795 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 004 | 0.03 | 1.83374 | 0.45293 | 0.830557 | 0.00619171 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.45293 | 1.83374 | 1.49422 | 3.32797 | 0.03 | 1 | 2.41109 | -1.37778 | -2.82471 | -0.460906 | -1.90783 | 0.455966 | -0.990963 | 0.0272583 | 0.830557 | 0.00619171 | 3.32797 | 12.668 | 1.49422 | 4.57335 | 3.32797 | 12.668 | 2.872 | 12.212
OP - 004 | 0.03 | 0.859554 | 0.45293 | 0.389317 | 0.003086 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.45293 | 0.859554 | 2.46639 | 3.32594 | 0.03 | 1 | 2.89616 | -0.405614 | -1.85254 | 0.0241631 | -1.42277 | 0.45394 | -0.992988 | 0.0204164 | 0.389317 | 0.003086 | 3.32594 | 12.6659 | 2.46639 | 2.62497 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 004 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.00743553 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T6 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | T6 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | -1.3798 | -2.82673 | -0.462932 | -1.90986 | 0.45394 | -0.992988 | 0.0299982 | 1.00489 | 0.00743553 | 3.32594 | 12.6659 | 1.4922 | 4.76349 | 3.32594 | 12.6659 | 2.872 | 12.212
OP - 003 | 0.4 | 1.708 | 0.929675 | 1.58789 | 0.635154 | 00.20 Preexistències (GuBIMclass CA) | Rectangle | Aligned | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | SW - 052 | OP - 003 | 00_MURS PREEXISTENT | Espai públic; Nau Santa Eulàlia | no | planta baixa | 0 | Opening | SW - 052 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.929675 | 1.708 | 1.63947 | 3.34747 | 0.4 | 1 | 2.49347 | 2.59755 | -3.49901 | 3.45155 | -2.64501 | 4.30555 | -1.79101 | 2.11014 | 1.58789 | 0.635154 | 3.34747 | 12.6875 | 1.63947 | 5.27535 | 3.34747 | 12.6875 | 1.63947 | 10.9795 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
PE001 | 0.4 | 2.6 | 2 | 5.2 | 0.021
PE004 | 0.4 | 2.6 | 2.4 | 6.24 | 0.0222
PE007 | 0.31 | 3.5 | 3.56138 | 11.8101 | 0
2 x OP - 003 | 0.400003 |  |  | 1.04194 | 0.416777 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Custom | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.55 | 2.02004 |  |  | 0.400003 | 1 |  |  |  |  |  |  |  | 2.05605 | 1.04194 | 0.416777 | 3.51427 | 12.8543 | 3.51427 | 5.14009 | 3.51427 | 12.8543 | 1.49422 | 10.8342 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.399998 |  |  | 0.859364 | 0.343744 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Custom | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.452644 | 2.03962 |  |  | 0.399998 | 1 |  |  |  |  |  |  |  | 1.98701 | 0.859364 | 0.343744 | 3.53384 | 12.8738 | 3.53384 | 4.96754 | 3.53384 | 12.8738 | 1.49422 | 10.8342 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.4 |  |  | 0.423538 | 0.169415 | 00.20 Preexistències (GuBIMclass CA) | Polygonal | Custom | Limited on both sides | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_MURS PREEXISTENT | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Stone - Wall | Main Model | Undefined | Existing | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Preexistències | EXISTING | 0.457933 | 1.04239 |  |  | 0.4 | 1 |  |  |  |  |  |  |  | 1.20026 | 0.423538 | 0.169415 | 3.50675 | 12.8467 | 3.50675 | 3.00064 | 3.50675 | 12.8467 | 2.46436 | 11.8044 | 1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
OP - 003 | 0.03 |  |  | 0.914987 | 0.0273723 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Infinite | Bowtie Opening 27 | Projection 1 Fill Opening 27 | T2; T2 | OP - 003 | 00_PLAYWOOD |  | no | planta baixa | 0 | Opening | T2 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Lateral | Obra | NEW | 1.59919 | 0.623843 | 5.69517 | 6.32018 | 0.03 | 2 | 6.00768 | -5.21381e-09 | -1.21916 | 0.312505 | -0.906654 | 0.625011 | -0.594148 | 0.049031 | 0.914987 | 0.0273723 | 6.31901 | 15.659 | 5.69517 | 4.17213 | 6.32018 | 15.6602 | 6.1623 | 15.5023
PI007 | 0.11 | 2.6 | 0.8 | 2.08 | 0.0971757
PI010 | 0.14 | 2.6 | 0.8 | 2.08 | 0.10096
2 x OP - 004 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0225684 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | 1.2222 | -1.3778 | 2.13907 | -0.460932 | 3.05594 | 0.45594 | 0.0577141 | 1.00489 | 0.0225684 | 3.32594 | 12.6659 | 1.4922 | 4.76349 | 2.87 | 12.21 | 1.4922 | 10.8322
V018 | 0.16 | 1.708 | 0.929675 | 1.58789 | 0.0126656
4 x OP - 004 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0226511 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | 1.2222 | -1.3778 | 2.13907 | -0.460932 | 3.05594 | 0.45594 | 0.0577741 | 1.00489 | 0.0226511 | 3.32594 | 12.6659 | 1.4922 | 4.76349 | 2.87 | 12.21 | 1.4922 | 10.8322
OP - 003 | 0.03 | 0.861579 | 0.229611 | 0.197828 | 0.00275417 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 0.229611 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | 2.19436 | -0.40564 | 2.62515 | 0.0251503 | 3.05594 | 0.45594 | 0.0189589 | 0.197828 | 0.00275417 | 3.32594 | 12.6659 | 2.46436 | 2.18238 | 2.87 | 12.21 | 2.46436 | 11.8044
OP - 003 | 0.03 | 1.83172 | 0.452644 | 0.829117 | 0.0186821 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 1.83172 | 1.49422 | 3.32594 | 0.03 | 1 | 2.41008 | 1.22422 | -1.37578 | 2.14008 | -0.459919 | 3.05594 | 0.45594 | 0.0548527 | 0.829117 | 0.0186821 | 3.32594 | 12.6659 | 1.49422 | 4.56872 | 2.87 | 12.21 | 1.49422 | 10.8342
OP - 003 | 0.03 | 0.861579 | 0.229611 | 0.197828 | 0.00270058 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 003 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 003_ | Nau Santa Eulalia | Obra | NEW | 0.229611 | 0.861579 | 2.46639 | 3.32797 | 0.03 | 1 | 2.89718 | 2.19639 | -0.403614 | 2.62718 | 0.0271759 | 3.05797 | 0.457966 | 0.0187994 | 0.197828 | 0.00270058 | 3.32797 | 12.668 | 2.46639 | 2.18238 | 2.87 | 12.21 | 2.46639 | 11.8064
OP - 004 | 0.03 | 1.83374 | 0.45293 | 0.830557 | 0.0186197 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.45293 | 1.83374 | 1.49422 | 3.32797 | 0.03 | 1 | 2.41109 | 1.22422 | -1.37578 | 2.14109 | -0.458906 | 3.05797 | 0.457966 | 0.0548073 | 0.830557 | 0.0186197 | 3.32797 | 12.668 | 1.49422 | 4.57335 | 2.87 | 12.21 | 1.49422 | 10.8342
OP - 004 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0226178 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.49422 | 3.32797 | 0.03 | 1 | 2.41109 | 1.22422 | -1.37578 | 2.14109 | -0.458906 | 3.05797 | 0.457966 | 0.0577133 | 1.00489 | 0.0226178 | 3.32797 | 12.668 | 1.49422 | 4.76349 | 2.87 | 12.21 | 1.49422 | 10.8342
OP - 004 | 0.03 | 1.83374 | 0.547999 | 1.00489 | 0.0225477 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.547999 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | 1.2222 | -1.3778 | 2.13907 | -0.460932 | 3.05594 | 0.45594 | 0.0576991 | 1.00489 | 0.0225477 | 3.32594 | 12.6659 | 1.4922 | 4.76349 | 2.87 | 12.21 | 1.4922 | 10.8322
OP - 004 | 0.03 | 1.83374 | 0.452644 | 0.830033 | 0.0186353 | Empty Opening (ARCHICAD Classification) | Rectangle | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 1.83374 | 1.4922 | 3.32594 | 0.03 | 1 | 2.40907 | 1.2222 | -1.3778 | 2.13907 | -0.460932 | 3.05594 | 0.45594 | 0.0548595 | 0.830033 | 0.0186353 | 3.32594 | 12.6659 | 1.4922 | 4.57278 | 2.87 | 12.21 | 1.4922 | 10.8322
OP - 004 | 0.03 |  |  | 0.29163 | 0.00268981 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | 2.19436 | -0.40564 | 2.62515 | 0.0251503 | 3.05594 | 0.45594 | 0.0188002 | 0.29163 | 0.00268981 | 3.32594 | 12.6659 | 2.46436 | 2.42987 | 2.87 | 12.21 | 2.46436 | 11.8044
OP - 004 | 0.03 |  |  | 0.29477 | 0.00277849 | Empty Opening (ARCHICAD Classification) | Polygonal | Aligned | Limited on one side | Bowtie Opening 27 | Projection 1 Fill Opening 27 | F1 | OP - 004 | 00_PLAYWOOD | Nau Santa Eulàlia | no | planta baixa | 0 | Opening | F1 | Wood - Pine Grained Horizontal blank | Main Model | Undefined | New | All Relevant Filters | 905232/21 | CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT | PE | ARQ | Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll. | L’Hospitalet de Llobregat | GFA2 arquitectos | L.Solsona | E.Fernàndez | OP - 004_ | Nau Santa Eulalia | Obra | NEW | 0.452644 | 0.861579 | 2.46436 | 3.32594 | 0.03 | 1 | 2.89515 | 2.19436 | -0.40564 | 2.62515 | 0.0251503 | 3.05594 | 0.45594 | 0.0190188 | 0.29477 | 0.00277849 | 3.32594 | 12.6659 | 2.46436 | 2.43531 | 2.87 | 12.21 | 2.46436 | 11.8044
PI009 | 0.08 | 2.6 | 0.8 | 2.08 | 0.0606751
PI008 | 0.08 | 2.6 | 0.8 | 2.08 | 0.0606751
