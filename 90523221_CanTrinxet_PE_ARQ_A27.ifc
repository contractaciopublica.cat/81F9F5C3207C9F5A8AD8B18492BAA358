Properties of the parts of a building model (IFC2X3), part 69 of 99

# IfcBuildingElementProxy: Rhino_Object_1778, Object_1778
AC_Equantity_Rhino_Object_1778 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1779, Object_1779
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1779; Hotlink and Element ID: Object_1779; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1779; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1779; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1779 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1779_; 109.AMB.CodiTipus: Object_1779; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1779 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3

# IfcBuildingElementProxy: Rhino_Object_1780, Object_1780
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1780; Hotlink and Element ID: Object_1780; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1780; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1780; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1780 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1780_; 109.AMB.CodiTipus: Object_1780; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1780 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1781, Object_1781
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1781; Hotlink and Element ID: Object_1781; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1781; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1781; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1781 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1781_; 109.AMB.CodiTipus: Object_1781; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1781 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1782, Object_1782
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1782; Hotlink and Element ID: Object_1782; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1782; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1782; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1782 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1782_; 109.AMB.CodiTipus: Object_1782; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1782 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1783, Object_1783
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1783 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1783_; 109.AMB.CodiTipus: Object_1783; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1783; Hotlink and Element ID: Object_1783; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1783; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1783; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1783 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1784, Object_1784
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1784; Hotlink and Element ID: Object_1784; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1784; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1784; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1784_; 109.AMB.CodiTipus: Object_1784; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1784 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1784 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1785, Object_1785
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1785 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1785; Hotlink and Element ID: Object_1785; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1785; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1785; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1785_; 109.AMB.CodiTipus: Object_1785; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1785 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1786, Object_1786
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1786; Hotlink and Element ID: Object_1786; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1786; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1786; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1786 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1786_; 109.AMB.CodiTipus: Object_1786; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1786 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1787, Object_1787
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1787 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1787_; 109.AMB.CodiTipus: Object_1787; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1787 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1787; Hotlink and Element ID: Object_1787; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1787; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1787; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1788, Object_1788
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1788; Hotlink and Element ID: Object_1788; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1788; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1788; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1788 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1788_; 109.AMB.CodiTipus: Object_1788; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1788 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1789, Object_1789
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1789 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1789_; 109.AMB.CodiTipus: Object_1789; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1789; Hotlink and Element ID: Object_1789; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1789; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1789; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1789 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1790, Object_1790
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1790; Hotlink and Element ID: Object_1790; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1790; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1790; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1790 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1790_; 109.AMB.CodiTipus: Object_1790; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1790 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1791, Object_1791
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1791; Hotlink and Element ID: Object_1791; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1791; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1791; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1791 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1791_; 109.AMB.CodiTipus: Object_1791; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1791 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1792, Object_1792
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1792; Hotlink and Element ID: Object_1792; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1792; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1792; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1792 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1792_; 109.AMB.CodiTipus: Object_1792; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1792 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3

# IfcBuildingElementProxy: Rhino_Object_1793, Object_1793
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1793; Hotlink and Element ID: Object_1793; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1793; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1793; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1793 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1793_; 109.AMB.CodiTipus: Object_1793; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426540 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1793 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1794, Object_1794
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
