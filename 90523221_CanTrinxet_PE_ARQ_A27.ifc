Properties of the parts of a building model (IFC2X3), part 74 of 99

# IfcBuildingElementProxy: Rhino_Object_1855, Object_1855
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Equantity_Rhino_Object_1855 - Dimension 1: 0.0737153 m; Dimension 2: 1.59754 m; Height: 0.156192 m; Bottom Level: -1.15463e-14 m; Top Level: 0.156192 m
5 AMB.Geometria - 502.AMB.Amplada: 1.59754 m; 503.AMB.Altura: 0.156192 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0124562 m3; Component, Component Volume (Gross): 0.0124562 m3

# IfcBuildingElementProxy: Rhino_Object_1856, Object_1856
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1856 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.7227 deg; Surface: Brick - Aged Natural; Element ID: Object_1856; Hotlink and Element ID: Object_1856; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1856; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1856; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1856_; 109.AMB.CodiTipus: Object_1856; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1856 - Dimension 1: 0.0759633 m; Dimension 2: 1.74887 m; Height: 0.15621 m; Bottom Level: -1.24345e-14 m; Top Level: 0.15621 m
ArchiCADQuantities - Length (A): 0.0759633 m; Area: 0.13285 m2; Height: 0.15621 m; Volume (Net): 0.0132518 m3; Width: 1.74887 m; Elevation to Project Zero: 5.10249 m; Elevation to 1st Reference Level: 5.10249 m; Elevation to 2nd Reference Level: 5.10249 m; Elevation to Sea Level: 14.4425 m; Elevation to Linked/Home Story: 5.10249 m; Home Offset: 5.10249 m; Surface Area: 0.720502 m2; Top Elevation To First Reference Level: 5.2587 m; Top Elevation To Home Story: 5.2587 m; Top Elevation To Project Zero: 5.2587 m; Top Elevation To Sea Level: 14.5987 m; Top Elevation To Second Reference Level: 5.2587 m; Bottom Elevation To First Reference Level: 5.10249 m; Bottom Elevation To Home Story: 5.10249 m; Bottom Elevation To Project Zero: 5.10249 m; Bottom Elevation To Sea Level: 14.4425 m; Bottom Elevation To Second Reference Level: 5.10249 m; Survey Coordinate X: 426568 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 14.4425 m; Top Surface Area (Net): 0.13285 m2; Bottom Surface Area (Net): 0.720502 m2
5 AMB.Geometria - 502.AMB.Amplada: 1.74887 m; 503.AMB.Altura: 0.15621 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0132518 m3; Component, Component Volume (Gross): 0.0132518 m3

# IfcBuildingElementProxy: Rhino_Object_1857, Object_1857
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.7902 deg; Surface: Brick - Aged Natural; Element ID: Object_1857; Hotlink and Element ID: Object_1857; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_1857; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1857; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1857 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 1; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 5; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1857_; 109.AMB.CodiTipus: Object_1857; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.635839 m; Area: 3.6945 m2; Height: 1.38302 m; Volume (Net): 1.03729 m3; Width: 5.81042 m; Elevation to Project Zero: 5.25489 m; Elevation to 1st Reference Level: 5.25489 m; Elevation to 2nd Reference Level: 5.25489 m; Elevation to Sea Level: 14.5949 m; Elevation to Linked/Home Story: 5.25489 m; Home Offset: 5.25489 m; Surface Area: 11.6942 m2; Top Elevation To First Reference Level: 6.63791 m; Top Elevation To Home Story: 6.63791 m; Top Elevation To Project Zero: 6.63791 m; Top Elevation To Sea Level: 15.9779 m; Top Elevation To Second Reference Level: 6.63791 m; Bottom Elevation To First Reference Level: 5.25489 m; Bottom Elevation To Home Story: 5.25489 m; Bottom Elevation To Project Zero: 5.25489 m; Bottom Elevation To Sea Level: 14.5949 m; Bottom Elevation To Second Reference Level: 5.25489 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 14.5949 m; Top Surface Area (Net): 3.6945 m2; Bottom Surface Area (Net): 11.6942 m2
AC_Equantity_Rhino_Object_1857 - Dimension 1: 0.635839 m; Dimension 2: 5.81042 m; Height: 1.38302 m; Bottom Level: -2.85488e-07 m; Top Level: 1.38302 m
5 AMB.Geometria - 502.AMB.Amplada: 5.81042 m; 503.AMB.Altura: 1.38302 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 1.03729 m3; Component, Component Volume (Gross): 1.03729 m3

# IfcBuildingElementProxy: Rhino_Object_1858, Object_1858
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.7902 deg; Surface: Brick - Aged Natural; Element ID: Object_1858; Hotlink and Element ID: Object_1858; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1858; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1858; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1858 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1858_; 109.AMB.CodiTipus: Object_1858; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0533913 m; Area: 0.00785989 m2; Height: 0.352018 m; Volume (Net): 0.00257039 m3; Width: 0.147213 m; Elevation to Project Zero: 5.32969 m; Elevation to 1st Reference Level: 5.32969 m; Elevation to 2nd Reference Level: 5.32969 m; Elevation to Sea Level: 14.6697 m; Elevation to Linked/Home Story: 5.32969 m; Home Offset: 5.32969 m; Surface Area: 0.15262 m2; Top Elevation To First Reference Level: 5.68171 m; Top Elevation To Home Story: 5.68171 m; Top Elevation To Project Zero: 5.68171 m; Top Elevation To Sea Level: 15.0217 m; Top Elevation To Second Reference Level: 5.68171 m; Bottom Elevation To First Reference Level: 5.32969 m; Bottom Elevation To Home Story: 5.32969 m; Bottom Elevation To Project Zero: 5.32969 m; Bottom Elevation To Sea Level: 14.6697 m; Bottom Elevation To Second Reference Level: 5.32969 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 14.6697 m; Top Surface Area (Net): 0.00785989 m2; Bottom Surface Area (Net): 0.15262 m2
AC_Equantity_Rhino_Object_1858 - Dimension 1: 0.0533913 m; Dimension 2: 0.147213 m; Height: 0.352018 m; Bottom Level: 0 m; Top Level: 0.352018 m
Component Quantities - Component, Component Volume (Net): 0.00257039 m3; Component, Component Volume (Gross): 0.00257039 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.147213 m; 503.AMB.Altura: 0.352018 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1859, Object_1859
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.7902 deg; Surface: Brick - Aged Natural; Element ID: Object_1859; Hotlink and Element ID: Object_1859; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1859; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1859; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1859 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0533913 m; Area: 0.00785989 m2; Height: 0.352018 m; Volume (Net): 0.00257039 m3; Width: 0.147213 m; Elevation to Project Zero: 4.90292 m; Elevation to 1st Reference Level: 4.90292 m; Elevation to 2nd Reference Level: 4.90292 m; Elevation to Sea Level: 14.2429 m; Elevation to Linked/Home Story: 4.90292 m; Home Offset: 4.90292 m; Surface Area: 0.15262 m2; Top Elevation To First Reference Level: 5.25493 m; Top Elevation To Home Story: 5.25493 m; Top Elevation To Project Zero: 5.25493 m; Top Elevation To Sea Level: 14.5949 m; Top Elevation To Second Reference Level: 5.25493 m; Bottom Elevation To First Reference Level: 4.90292 m; Bottom Elevation To Home Story: 4.90292 m; Bottom Elevation To Project Zero: 4.90292 m; Bottom Elevation To Sea Level: 14.2429 m; Bottom Elevation To Second Reference Level: 4.90292 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 14.2429 m; Top Surface Area (Net): 0.00785989 m2; Bottom Surface Area (Net): 0.15262 m2
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1859_; 109.AMB.CodiTipus: Object_1859; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Equantity_Rhino_Object_1859 - Dimension 1: 0.0533913 m; Dimension 2: 0.147213 m; Height: 0.352018 m; Bottom Level: -1.77636e-15 m; Top Level: 0.352018 m
Component Quantities - Component, Component Volume (Net): 0.00257039 m3; Component, Component Volume (Gross): 0.00257039 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.147213 m; 503.AMB.Altura: 0.352018 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1860, Object_1860
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1860_; 109.AMB.CodiTipus: Object_1860; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1860 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 12.7902 deg; Surface: Brick - Aged Natural; Element ID: Object_1860; Hotlink and Element ID: Object_1860; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1860; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1860; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.70445 m; Area: 19.268 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3519 m; Elevation to Project Zero: 5.90239 m; Elevation to 1st Reference Level: 5.90239 m; Elevation to 2nd Reference Level: 5.90239 m; Elevation to Sea Level: 15.2424 m; Elevation to Linked/Home Story: 5.90239 m; Home Offset: 5.90239 m; Surface Area: 0.443443 m2; Top Elevation To First Reference Level: 6.00893 m; Top Elevation To Home Story: 6.00893 m; Top Elevation To Project Zero: 6.00893 m; Top Elevation To Sea Level: 15.3489 m; Top Elevation To Second Reference Level: 6.00893 m; Bottom Elevation To First Reference Level: 5.90239 m; Bottom Elevation To Home Story: 5.90239 m; Bottom Elevation To Project Zero: 5.90239 m; Bottom Elevation To Sea Level: 15.2424 m; Bottom Elevation To Second Reference Level: 5.90239 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 15.2424 m; Top Surface Area (Net): 19.268 m2; Bottom Surface Area (Net): 0.443443 m2
AC_Equantity_Rhino_Object_1860 - Dimension 1: 0.70445 m; Dimension 2: 27.3519 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3519 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1861, Object_1861
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.7902 deg; Surface: Brick - Aged Natural; Element ID: Object_1861; Hotlink and Element ID: Object_1861; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1861; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1861; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1861 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1861_; 109.AMB.CodiTipus: Object_1861; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.70445 m; Area: 19.268 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3519 m; Elevation to Project Zero: 5.41908 m; Elevation to 1st Reference Level: 5.41908 m; Elevation to 2nd Reference Level: 5.41908 m; Elevation to Sea Level: 14.7591 m; Elevation to Linked/Home Story: 5.41908 m; Home Offset: 5.41908 m; Surface Area: 0.454836 m2; Top Elevation To First Reference Level: 5.52563 m; Top Elevation To Home Story: 5.52563 m; Top Elevation To Project Zero: 5.52563 m; Top Elevation To Sea Level: 14.8656 m; Top Elevation To Second Reference Level: 5.52563 m; Bottom Elevation To First Reference Level: 5.41908 m; Bottom Elevation To Home Story: 5.41908 m; Bottom Elevation To Project Zero: 5.41908 m; Bottom Elevation To Sea Level: 14.7591 m; Bottom Elevation To Second Reference Level: 5.41908 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 14.7591 m; Top Surface Area (Net): 19.268 m2; Bottom Surface Area (Net): 0.454836 m2
AC_Equantity_Rhino_Object_1861 - Dimension 1: 0.70445 m; Dimension 2: 27.3519 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3519 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1862, Object_1862
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.7902 deg; Surface: Brick - Aged Natural; Element ID: Object_1862; Hotlink and Element ID: Object_1862; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1862; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1862; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1862 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1862_; 109.AMB.CodiTipus: Object_1862; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.70445 m; Area: 19.268 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3519 m; Elevation to Project Zero: 4.99236 m; Elevation to 1st Reference Level: 4.99236 m; Elevation to 2nd Reference Level: 4.99236 m; Elevation to Sea Level: 14.3324 m; Elevation to Linked/Home Story: 4.99236 m; Home Offset: 4.99236 m; Surface Area: 0.426456 m2; Top Elevation To First Reference Level: 5.09891 m; Top Elevation To Home Story: 5.09891 m; Top Elevation To Project Zero: 5.09891 m; Top Elevation To Sea Level: 14.4389 m; Top Elevation To Second Reference Level: 5.09891 m; Bottom Elevation To First Reference Level: 4.99236 m; Bottom Elevation To Home Story: 4.99236 m; Bottom Elevation To Project Zero: 4.99236 m; Bottom Elevation To Sea Level: 14.3324 m; Bottom Elevation To Second Reference Level: 4.99236 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 14.3324 m; Top Surface Area (Net): 19.268 m2; Bottom Surface Area (Net): 0.426456 m2
AC_Equantity_Rhino_Object_1862 - Dimension 1: 0.70445 m; Dimension 2: 27.3519 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3519 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1863, Object_1863
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Component Quantities - Component, Component Volume (Net): 0.011856 m3; Component, Component Volume (Gross): 0.011856 m3
5 AMB.Geometria - 502.AMB.Amplada: 1.52077 m; 503.AMB.Altura: 0.156183 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1863 - Dimension 1: 0.0857879 m; Dimension 2: 1.52077 m; Height: 0.156183 m; Bottom Level: -1.06581e-14 m; Top Level: 0.156183 m
ArchiCADQuantities - Length (A): 0.0857879 m; Area: 0.130464 m2; Height: 0.156183 m; Volume (Net): 0.011856 m3; Width: 1.52077 m; Elevation to Project Zero: 6.00893 m; Elevation to 1st Reference Level: 6.00893 m; Elevation to 2nd Reference Level: 6.00893 m; Elevation to Sea Level: 15.3489 m; Elevation to Linked/Home Story: 6.00893 m; Home Offset: 6.00893 m; Surface Area: 0.64184 m2; Top Elevation To First Reference Level: 6.16511 m; Top Elevation To Home Story: 6.16511 m; Top Elevation To Project Zero: 6.16511 m; Top Elevation To Sea Level: 15.5051 m; Top Elevation To Second Reference Level: 6.16511 m; Bottom Elevation To First Reference Level: 6.00893 m; Bottom Elevation To Home Story: 6.00893 m; Bottom Elevation To Project Zero: 6.00893 m; Bottom Elevation To Sea Level: 15.3489 m; Bottom Elevation To Second Reference Level: 6.00893 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 15.3489 m; Top Surface Area (Net): 0.130464 m2; Bottom Surface Area (Net): 0.64184 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1863_; 109.AMB.CodiTipus: Object_1863; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1863 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 12.7902 deg; Surface: Brick - Aged Natural; Element ID: Object_1863; Hotlink and Element ID: Object_1863; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1863; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1863; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1864, Object_1864
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.7902 deg; Surface: Brick - Aged Natural; Element ID: Object_1864; Hotlink and Element ID: Object_1864; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1864; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1864; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1864 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1864_; 109.AMB.CodiTipus: Object_1864; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0876005 m; Area: 0.13996 m2; Height: 0.156192 m; Volume (Net): 0.0124562 m3; Width: 1.59771 m; Elevation to Project Zero: 5.52563 m; Elevation to 1st Reference Level: 5.52563 m; Elevation to 2nd Reference Level: 5.52563 m; Elevation to Sea Level: 14.8656 m; Elevation to Linked/Home Story: 5.52563 m; Home Offset: 5.52563 m; Surface Area: 0.673545 m2; Top Elevation To First Reference Level: 5.68182 m; Top Elevation To Home Story: 5.68182 m; Top Elevation To Project Zero: 5.68182 m; Top Elevation To Sea Level: 15.0218 m; Top Elevation To Second Reference Level: 5.68182 m; Bottom Elevation To First Reference Level: 5.52563 m; Bottom Elevation To Home Story: 5.52563 m; Bottom Elevation To Project Zero: 5.52563 m; Bottom Elevation To Sea Level: 14.8656 m; Bottom Elevation To Second Reference Level: 5.52563 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 14.8656 m; Top Surface Area (Net): 0.13996 m2; Bottom Surface Area (Net): 0.673545 m2
AC_Equantity_Rhino_Object_1864 - Dimension 1: 0.0876005 m; Dimension 2: 1.59771 m; Height: 0.156192 m; Bottom Level: -1.15463e-14 m; Top Level: 0.156192 m
5 AMB.Geometria - 502.AMB.Amplada: 1.59771 m; 503.AMB.Altura: 0.156192 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0124562 m3; Component, Component Volume (Gross): 0.0124562 m3

# IfcBuildingElementProxy: Rhino_Object_1865, Object_1865
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.7902 deg; Surface: Brick - Aged Natural; Element ID: Object_1865; Hotlink and Element ID: Object_1865; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1865; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1865; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1865 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1865_; 109.AMB.CodiTipus: Object_1865; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0911652 m; Area: 0.159449 m2; Height: 0.15621 m; Volume (Net): 0.0132518 m3; Width: 1.74901 m; Elevation to Project Zero: 5.09891 m; Elevation to 1st Reference Level: 5.09891 m; Elevation to 2nd Reference Level: 5.09891 m; Elevation to Sea Level: 14.4389 m; Elevation to Linked/Home Story: 5.09891 m; Home Offset: 5.09891 m; Surface Area: 0.720502 m2; Top Elevation To First Reference Level: 5.25512 m; Top Elevation To Home Story: 5.25512 m; Top Elevation To Project Zero: 5.25512 m; Top Elevation To Sea Level: 14.5951 m; Top Elevation To Second Reference Level: 5.25512 m; Bottom Elevation To First Reference Level: 5.09891 m; Bottom Elevation To Home Story: 5.09891 m; Bottom Elevation To Project Zero: 5.09891 m; Bottom Elevation To Sea Level: 14.4389 m; Bottom Elevation To Second Reference Level: 5.09891 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 14.4389 m; Top Surface Area (Net): 0.159449 m2; Bottom Surface Area (Net): 0.720502 m2
AC_Equantity_Rhino_Object_1865 - Dimension 1: 0.0911652 m; Dimension 2: 1.74901 m; Height: 0.15621 m; Bottom Level: -1.24345e-14 m; Top Level: 0.15621 m
5 AMB.Geometria - 502.AMB.Amplada: 1.74901 m; 503.AMB.Altura: 0.15621 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0132518 m3; Component, Component Volume (Gross): 0.0132518 m3

# IfcBuildingElementProxy: Rhino_Object_1866, Object_1866
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.8038 deg; Surface: Brick - Aged Natural; Element ID: Object_1866; Hotlink and Element ID: Object_1866; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1866; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1866; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1866 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1866_; 109.AMB.CodiTipus: Object_1866; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104362 m; Area: 0.0212381 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.203503 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0212381 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1866 - Dimension 1: 0.104362 m; Dimension 2: 0.203503 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.203503 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1867, Object_1867
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.8038 deg; Surface: Brick - Aged Natural; Element ID: Object_1867; Hotlink and Element ID: Object_1867; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1867; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1867; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1867 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1867_; 109.AMB.CodiTipus: Object_1867; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.104362 m; Area: 0.0212381 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.203503 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579780 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0212381 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1867 - Dimension 1: 0.104362 m; Dimension 2: 0.203503 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.203503 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1868, Object_1868
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.8038 deg; Surface: Brick - Aged Natural; Element ID: Object_1868; Hotlink and Element ID: Object_1868; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1868; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1868; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1868 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1868_; 109.AMB.CodiTipus: Object_1868; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.104362 m; Area: 0.0212381 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.203503 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0212381 m2; Bottom Surface Area (Net): 0.0491345 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.203503 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1868 - Dimension 1: 0.104362 m; Dimension 2: 0.203503 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1869, Object_1869
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1869 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1869_; 109.AMB.CodiTipus: Object_1869; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104362 m; Area: 0.0212381 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.203503 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426537 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0212381 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1869 - Dimension 1: 0.104362 m; Dimension 2: 0.203503 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.203503 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
ArchiCADProperties - Rotation Angle: 12.8038 deg; Surface: Brick - Aged Natural; Element ID: Object_1869; Hotlink and Element ID: Object_1869; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1869; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1869; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_187, Object_187
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_187 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_187; Hotlink and Element ID: Object_187; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_187; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_187; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_187_; 109.AMB.CodiTipus: Object_187; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.015273 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.693152 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426570 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693152 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.015273 m3; Component, Component Volume (Gross): 0.015273 m3
AC_Equantity_Rhino_Object_187 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -6.13198e-12 m; Top Level: 1.11675 m

# IfcBuildingElementProxy: Rhino_Object_1870, Object_1870
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
