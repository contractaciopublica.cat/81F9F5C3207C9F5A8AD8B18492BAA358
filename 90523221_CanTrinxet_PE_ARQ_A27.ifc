Properties of the parts of a building model (IFC2X3), part 2 of 99

# IfcBuildingElementProxy: Arch Door 27 (2)
AC_Equantity_Arch_Door_27 - Width: 1.39052 m; Height: 3.23889 m; Z Dimension: 1 m; Bottom Level: 1 m; Top Level: 0 m; Sill Height to Current Story: 0.406317 m; Reveal to Wall Core: 0 m; New Wall Fill Width Right: 0.15 m; New Wall Fill Width Left: 0.15 m; Shoulder Height: 3.07902 m; Sidelight 1 Width (gs_sidelight_width_right): 0 m; Sidelight 1 Width (gs_sidelight_width_right_half): 0.15 m; Sidelight 1 Width (gs_sidelight_width_right_orig): 0.3 m; Sidelight 1 Sill Height: 0 m; Sidelight 2 Width (gs_sidelight_width_left): 0 m; Sidelight 2 Width (gs_sidelight_width_left_half): 0.15 m; Sidelight 2 Width (gs_sidelight_width_left_orig): 0.3 m; Sidelight 2 Sill Height: 0 m; Transom Height: 0.3 m; Pivot Axis Offset: 0.275 m; Tolerance Side / Upper: 0 m; Tolerance Side 1 Lower: 0 m; Tolerance Sidelight 1 Bottom: 0 m; Tolerance Side 2: 0 m; Tolerance Side 2 Lower: 0 m; Tolerance Sidelight 2 Bottom: 0 m; Tolerance Upper: 0 m; Tolerance Lower: 0 m; Wallhole Width: 1.39052 m; Wallhole Height: 3.23889 m; Reveal Width: 1.39052 m; Reveal Height: 3.23889 m; Unit Width: 1.39052 m; Unit Height: 3.23889 m; Egress Width: 1.31052 m; Egress Height: 3.19889 m; Nominal Leaf Width: 1.33452 m; Nominal Leaf Height: 3.21089 m; Frame Thickness: 0.16 m; Frame Thickness Inside: 0.115 m; Leaf Offset: 0 m; Frame Width: 0.04 m; Frame Oversize: 0.01 m; Frame Outer Thickness: 0.01 m; Frame Width Side 1: 0.04 m; Middle Frame Width Side 1: 0.04 m; Bottom Frame Width Side 1: 0.04 m; Frame Width Side 2: 0.04 m; Middle Frame Width Side 2: 0.04 m; Bottom Frame Width Side 2: 0.04 m; Transom Frame Width (gs_frame_width_transom): 0.04 m; Upper Frame Width: 0.04 m; Door Stop Thickness: 0.032 m; Door Stop Width: 0.016 m; Rebate Width: 0.012 m; Leaf Rebate Depth in 3D: 0.04 m; Sidelight and Transom Rebate Width: 0.01 m; Sidelight and Transom Rebate Depth: 0.018 m; Nominal Leaf Width Side 1: 0.422 m; Leaf Thickness: 0.04 m; Leaf Frame Width Side: 0.1 m; Leaf Frame Width Right: 0.1 m; Leaf Frame Width Left: 0.1 m; Leaf Frame Width Upper: 0.1 m; Leaf Frame Width Internal: 0.025 m; Leaf Undercut: 0 m; Grid Width: 0.012 m; Grid Thickness: 0.025 m; Glass Thickness: 0.012 m; Handle Height: 1 m; Handle Position: 0.05 m; Kick Board Height: 0.1 m; Horizontal Division Height Sidelight Side 1: 0.9 m; Horizontal Division Height Sidelight Side 2: 0.9 m; Horizontal Division Height Middle Transom: 0.9 m; Horizontal Division Height Transom Side 1: 0.9 m; Horizontal Division Height Transom Side 2: 0.9 m; Sidelight and Transom Frame Thickness: 0.044 m; Transom Frame Width (gs_sash_width): 0.067 m; Sidelight Frame Width: 0.067 m; Grill Width: 0.02 m; Grill Thickness: 0.025 m; Sidelight Division Width: 0.04 m; Sidelight Division Thickness: 0.1 m; Width Side (gs_tw_right_out): 0.05 m; Width Side (gs_tw_left_out): 0.05 m; Width Top (gs_tw_top_out): 0.05 m; Thickness on Wall (gs_trim_thk_out): 0.019 m; Thickness in Wallhole (gs_trim_width_out): 0.025 m; Offset (gs_trim_offs_out): 0.012 m; Nosing (gs_trim_jambext_nosing_out): 0.05 m; Top Overhang (gs_trimov_top_left_out): 0 m; Top Overhang (gs_trimov_top_right_out): 0 m; Width Side (gs_tw_right_in): 0.05 m; Width Side (gs_tw_left_in): 0.05 m; Width Top (gs_tw_top_in): 0.05 m; Thickness on Wall (gs_trim_thk_in): 0.019 m; Thickness in Wallhole (gs_trim_width_in): 0.025 m; Offset (gs_trim_offs_in): 0.012 m; Nosing (gs_trim_jambext_nosing_in): 0.05 m; Top Overhang (gs_trimov_top_left_in): 0 m; Top Overhang (gs_trimov_top_right_in): 0 m; Threshold Thickness: 0.012 m; Threshold Width: 0.01 m; Threshold External Thickness: 0.00580738 m; Threshold Nosing Outside: 0.025 m; Threshold Nosing Inside: 0.025 m; Side Overhang Outside: 0 m; Side Overhang Inside: 0 m; Sill Thickness: 0.025 m; Sill Front Side Thickness: 0.015 m; Sill Elevation: 0.005 m; Sill Drip Overlap: 0.02 m; Sill Drip Width: 0.03 m; Sill Nosing: 0.03 m; Sill Overhang Side 1: 0 m; Sill Overhang Side 2: 0 m; Sill Slip-in Depth: 0.02 m; Sill Top Width: 0.01 m; Sill Top Height: 0.01 m; Sill Slip from Wall: 0 m; Rear Hole Depth (gs_sill_holeDepthBehind): 0 m; Width of Sill: 0 m; Brick Thickness (gs_brick_sill_br_thk): 0.065 m; Mortar Thickness (gs_brick_sill_mort_thk): 0.015 m; Board Width: 0.1 m; Board Thickness: 0.025 m; Board Nosing: 0.03 m; Board Overhang Side 1: 0 m; Board Overhang Side 2: 0 m; Board Slip-in Depth: 0 m; Panel Height: 1.5 m; Inner Offset: 0.02 m; Closing Depth: 0 m; Extra Frame Width: 0.04 m; Extra Frame Thickness: 0.03 m; Rail Width: 0.03 m; Hanging Stick Length: 0.02 m; Hanging Stick Radius: 0.005 m; Panel Distance: 0.006 m; Outside Overhang: 0 m; Inner Panel Width: 0.12 m; 3D Opening Length: 1.5 m; 3D Closed Length: 0 m; 3D Opening Length 1: 0.56 m; 3D Opening Length 2: 0.14 m; 3D Opening Height: 1.5 m; 3D Closed Height: 0 m; Panel Thickness: 0.05 m; Panel Frame Width: 0.05 m; Frame Width Bottom: 0.05 m; Panel Width: 0 m; Panel Fill Thickness: 0.01 m; Louver Thickness: 0.01 m; Louver Width: 0.04 m; Horizontal Frame Divider Width: 0.05 m; Vertical Frame Divider Width: 0.05 m; Hole Radius: 0.01 m; Vertical Board Width: 0.1 m; Z Frame Width: 0.05 m; Z Frame Thickness: 0.025 m; Vertical Boards Thickness: 0.025 m; Horizontal Boards Thickness: 0.025 m; Vertical Boards Approximate Width: 0.08 m; Horizontal Boards Approximate Width: 0.115 m; Box Height (gs_shutRoll_boxHeight): 0.2 m; Box Depth (gs_shutRoll_boxWidth): 0.15 m; Box Left Offset: 0 m; Box Right Offset: 0 m; Depth of Rails: 0.0725 m; Distance from Wall (gs_shutRoll_distFromWall): 0 m; Distance from Header (gs_shutRoll_distFromHead): 0 m; Slat Width: 0.05 m; Box Height (gs_shutLam_boxHeight): 0.2 m; Box Depth (gs_shutLam_boxWidth): 0.15 m; Cover Width: 0 m; Distance from Wall (gs_shutLam_distFromWall): 0 m; Distance from Header (gs_shutLam_distFromHead): 0 m; Segment Width (gs_shutLam_segmentWidth): 0.06 m; Box Height (gs_shutLam2_boxHeight): 0.06 m; Box Width: 0.06 m; Distance from Window: 0.06 m; Distance from Header (gs_shutLam2_distFromHead): 0.06 m; Box Axis Height from Header: 0 m; Segment Width (gs_shutLam2_segmentWidth): 0.06 m; Distance between Arch and Door: 0 m; Masonry Arch Overhang Side 1: 0 m; Masonry Arch Overhang Side 2: 0 m; Masonry Arch Rise: 0.03 m; Masonry Arch Projection: 0 m; Masonry Arch Height: 0.25 m; Masonry Arch Depth: 0.12 m; Rear Hole Depth (gs_masonry_arch_rearHoleDepth): 0 m; Brick Thickness (gs_masonry_arch_brick_thk): 0.065 m; Mortar Thickness (gs_masonry_arch_mort_thk): 0.01 m; Keystone Width: 0.1 m; Keystone Oversize: 0 m; Keystone Projection: 0.01 m; Reveal Depth (gs_wido_sill): 0 m; Reveal Depth (AC_wido_sill): 0 m; Jamb Depth Side 1: 0.06 m; Jamb Depth Side 2: 0.06 m; Lower Jamb Depth Side 1: 0.06 m; Lower Jamb Depth Side 2: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_splayed_innerLeft): 0.06 m; Inner Jamb Depth: 0.06 m; Inner Jamb Depth Side 1: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_double_innerLeft): 0.06 m; Inner Lower Jamb Depth Side 1: 0.06 m; Inner Lower Jamb Depth Side 2: 0.06 m; Head Depth: 0.06 m; Sill Depth: 0.06 m; Sill Depth Side 1: 0.06 m; Sill Depth Side 2: 0.06 m; Inner Head Depth (gs_reveal_splayed_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_splayed_innerBottom): 0.06 m; Inner Head Depth (gs_reveal_double_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_double_innerBottom): 0.06 m; Inner Sill Depth Side 1: 0 m; Inner Sill Depth Side 2: 0 m; Outer Jamb Depth: 0.08 m; Plaster Thickness Limit: 0.04 m; Distance of Skin from Closer: 0 m; Closer Width: 0.038 m; Closer Thickness: 0.1 m; Strip Thickness: 0.025 m; Profile Width: 0.15 m; Custom Thickness: 0.015 m; Skin Overhang to Frame Depth: 0 m; Left Opening Oversize: 0 m; Right Opening Oversize: 0 m; Upper Opening Oversize: 0 m; Lower Opening Oversize: 0 m; Opening Width in 3D: 0 m; Opening Width in 3D on Side 2: 0 m; Opening Width in 2D: 0 m; Opening Width in 2D on Side 2: 0 m; Opening Distance 1 Main Sash Side 1: 0 m; Opening Distance 2 Main Sash Side 1: 0 m; Opening Distance 1 Main Sash Side 2: 0 m; Opening Distance 2 Main Sash Side 2: 0 m; Opening Distance 1 Middle Transom: 0 m; Opening Distance 2 Middle Transom: 0 m; Opening Distance 1 Transom Side 1: 0 m; Opening Distance 2 Transom Side 1: 0 m; Opening Distance 1 Transom Side 2: 0 m; Opening Distance 2 Transom Side 2: 0 m; Opening Side Width 2: 0.3 m; Opening Side Width 1: 0.1 m; Opening Side Depth: 1.8 m; Opposite Side Width 2: 0.25 m; Opposite Side Width 1: 0.1 m; Opposite Side Depth: 1.2 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m; Real Frame Thickness: 0.16 m; ID Offset X: 0 m; ID Offset Y: 0 m; Custom Text Offset X: 0 m; Custom Text Offset Y: 0 m; Leaf Width Offset X: 0 m; Leaf Width Offset Y: 0 m
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
5 AMB.Geometria - 502.AMB.Amplada: 1.39052 m; 503.AMB.Altura: 3.23889 m; 506.AMB.Profunditat: 0 m
Name | Orientation = Door Orientation | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | 107.AMB.NomTipus | Wall Direction Type | Total Glazed Area (gs_list_glassarea) | W/D Opening Opening Volume (m3) | W/D Opening Surface Area (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | W/D Opening Width on the Reveal Side (m) = W/D Opening Width on the Side Opposite to the Reveal Side (m) | W/D Opening Surface Area on the Reveal Side (m2) = W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Leaf Frame Width Lower (m)
PE002 | R | PE002 | PE002_PortaExtTipusY | 1 | 3.25989 | 0.708393 | 12.2702 | 1.3901 | 4.42746 | 0.0831429 | 0.2
PE006 | L | PE006 | PE006_PortaExtTipusY | 0 | 3.37334 | 0.708599 | 12.2806 | 1.39052 | 4.42874 | 0.0786049 | 0.1

# IfcBuildingElementProxy: Arch Double Door 27, PE201
In: planta baixa
Classification: 30.10.20.20 Portes de façanes (GuBIMclass CA)
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0; Status: NEW
ArchiCADProperties - Reveal Dimensions: 1.789,5×3.325,1; Wallhole Dimensions: 1.789,5×3.325,1; Unit Dimensions: 1.789,5×3.325,1; Egress Dimensions: 1.709,5×3.285,1; Leaf Dimensions: 1.733,5×3.297,1; Nominal W x H Size: 1.789,5×3.325,1; Nominal W x H x T Size: 1.789,5×3.325,1×80,0; Wall Structure: Insulation; Marker Text: <Custom Text>; Orientation: L; Opening Library Part Name: Arch Double Door 27; Opening Side Fill Index: Background; Element ID: PE201; Hotlink and Element ID: PE201; Layer: 00_TABIQUE; Library Part Name: Arch Double Door 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Lateral; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Door; Parent ID: F5; Surfaces (All): Wood - Pine Grained Horizontal; Glass - Clear Fast; Metal - Aluminium; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Arch_Double_Door_27 - Wall Contours (0-None,1-Full,2-Side,3-Length): 0; Hotspots 0-None,1-2D,2-3D,3-All: 3; Show 2D Hotspots in 3D: yes; Floor Plan Display Option: 3; Hole Position Angle: 0 deg; Hole has Wall's Side Surface: yes; Hole Surface's Split is Curved in Curved Walls: no; Wall Type: 1; Wall Direction Type: 0; Reveal Anchor Position: 1; Opening Direction: 0; Flip: no; Parapet Wall Inset Value: 3; Demolition / New construction: 1; New Wall Fill Type: Masonry Block; New Wall Fill Pen: General - General; New Wall Fill Background Pen: Backgrounds - color 1; Show new construction on Wall: no; Demolition line type: 1; Show Demolition/New parameter: no; Display as Transom: no; Sidelight (gs_SidelightTransomRelation): Under Transom; Sidelight (gs_SidelightTransomRelation_m): 1; Sidelight 1: no; Sidelight 2: yes; Transom: yes; Uniform Tolerances: yes; Nominal Size: 0; Set Wallhole Size as Nominal Size: yes; Set Reveal Size as Nominal Size: no; Set Unit Size as Nominal Size: no; Set Egress Size as Nominal Size: no; Set Leaf Size as Nominal Size: no; Transfer Current Nominal Size to Selection: no; Show Editable Hotspots: yes; 2D Detail Level: 2; Show Reveal on Symbol: 1; Symbolic Display of Opening: no; 3D Detail Level: 8; Opening Direction Sidelight (gs_opening_dir_sl): Opposite to Leaf; Opening Direction Sidelight (gs_opening_dir_sl_m): 2; Door Frame (gs_pocket_door_frame): yes; Frame Style (gs_frame_style): Simple Rebate; Frame Style (gs_frame_style_m): 3; Frame Thickness=Wall Thickness: no; Uniform Frame Thickness: yes; Centered Leaf: yes; Uniform Frame Width: yes; Frame Style Changed Automatically: no; Number of Door Leaves: 4; Number of Door Leaves - Side 2: 3; Door Panel Style: 46; Leaves Configuration (gs_LeavesConfig): Uniform Leaves; Leaves Configuration (gs_iLeavesConfig): 1; Grid Position (gs_grill_pos): Throughout; Grid Position (gs_grill_pos_m): 3; Panes Number Vertically Side 2: 4; Panes Number Horizontally Side 2: 3; Panes Number Vertically Side 1: 4; Panes Number Horizontally Side 1: 3; Show as Glass Panel on Symbol: no; Show Chinese Spring Door Symbol: no; Show Symbol as Airtight Panel: no; Edit Handle: 1; Uniform Handles: no; Opening Handle (gs_handle_type_m): 0; Show Handle on Symbol: no; Opening Handle (gs_handle_type2_m): 0; Kick Board Outside (bKickBoardOut): no; Kick Board Inside (bKickBoardIn): no; Uniform Sashes: no; Opening Type (gs_optype_m_05): 3; Opening Type (gs_optype_m_09): 3; Opening Type (gs_optype_m_02): 1; Opening Type (gs_optype_m_06): 1; Opening Type (gs_optype_m_10): 1; Sash Type (MullionStyle_00): No Grid; Sash Type (iMullionStyle_00): 1; Sash Type (iMullionStyle_05): 1; Sash Type (iMullionStyle_09): 1; Sash Type (iMullionStyle_02): 1; Sash Type (iMullionStyle_06): 1; Sash Type (iMullionStyle_10): 1; Hotspot Grill Editing: yes; Grid Position (MullionPosition): Throughout; Grid Position (iMullionPosition): 3; Panes Number Vertically Main Sash Side 1: 4; Panes Number Horizontally Main Sash Side 1: 2; Panes Number Vertically 2 Main Sash Side 1: 4; Panes Number Horizontally 2 Main Sash Side 1: 2; Panes Number Vertically Main Sash Side 2: 4; Panes Number Horizontally Main Sash Side 2: 2; Panes Number Vertically 2 Main Sash Side 2: 4; Panes Number Horizontally 2 Main Sash Side 2: 2; Panes Number Vertically Middle Transom: 2; Panes Number Horizontally Middle Transom: 2; Panes Number Vertically 2 Middle Transom: 2; Panes Number Horizontally 2 Middle Transom: 2; Panes Number Vertically Transom Side 1: 2; Panes Number Horizontally Transom Side 1: 2; Panes Number Vertically 2 Transom Side 1: 2; Panes Number Horizontally 2 Transom Side 1: 2; Panes Number Vertically Transom Side 2: 2; Panes Number Horizontally Transom Side 2: 2; Panes Number Vertically 2 Transom Side 2: 2; Panes Number Horizontally 2 Transom Side 2: 2; Casing Outside: no; Casing Type Outside (gs_trimtype_out): Simple; Casing Type Outside (gs_trimtype_out_int): 1; Cover Outer Wall Surface: yes; Uniform Casing Widths (gs_trim_outside_uniform): yes; Casing Inside: yes; Casing Type Inside (gs_trimtype_in): Simple; Casing Type Inside (gs_trimtype_in_int): 1; Cover Inner Wall Surface: no; Uniform Casing Widths (gs_trim_inside_uniform): yes; Threshold (bThreshold): no; Threshold Type: 2; Threshold Angle: 3.1996 deg; Threshold Changed Automatically: no; Sill - Door: no; Sill - Sidelight Side 1: no; Sill - Sidelight Side 2: no; Sill Oversize: no; Type of the Sill: 1; Sill Angle: 3 deg; Sill is Curved in Curved Walls: yes; Insulation below Sill: yes; Use Wall Insulation Skin: no; Brick Sill 3D Detail Level: 1; Sill Style Changed Automatically: no; Board - Sidelight Side 1: no; Board - Sidelight Side 2: no; Board - Door: no; Board Angle: 0 deg; Board is Curved in Curved Walls: yes; Board in Polygonal Walls: 1; Sunshade: no; Sunshade Type: 1; Enabled Sunshade Types: 38; Number of Panels: 2; Number of Panels 2: 1; Panel Position (gs_shutter_panelPos): Symmetric; Panel Position (gs_shutter_iPanelPos): 1; Automatic Shutter Height: yes; Extra Frame: no; Cover Type (gs_slidingShutter_cover): Z-Profile; Cover Type (gs_slidingShutter_iCover): 1; Stacking Direction (gs_foldingShutter_stacking): Inside; Stacking Direction (gs_foldingShutter_iStacking): 1; Open in 3D: yes; 3D Opening Angle: 180 deg; Show 2D Symbol: yes; Show Opening Lines on Symbol: no; Panel Type (gs_shutPanel_type): Style 1; Panel Type (gs_shutPanel_iType): 1; Different Bottom Frame Width: no; Automatic Shutter Width: yes; Louver Angle: 30 deg; Holes Number Horizontal: 5; Holes Number Vertical: 8; Rolling Shutter Placement (gs_shutRoll_placement): On Facade; Rolling Shutter Placement (gs_shutRoll_iPlacement): 1; Box Type (gs_shutRoll_boxType): Rectangular; Box Type (gs_shutRoll_iBoxType): 1; Rail Position (gs_shutRoll_railPos): On Casing; Rail Position (gs_shutRoll_iRailPos): 1; Show Casing behind Sunshade (gs_shutRoll_showCasingBehind): no; Insulation behind Box (gs_shutRoll_cutWallBehind): no; Include Height in Wallhole Height: no; Box Top Angle: 10 deg; Box Default Width (gs_shutRoll_boxDefaultSize): Reveal Width; Box Default Width (gs_shutRoll_iBoxDefaultSize): 1; Venetian Blinds Placement (gs_shutLam_placement): Fixed on Facade; Venetian Blinds Placement (gs_shutLam_iPlacement): 1; Insulation behind Box (gs_shutLam_cutWallBehind): no; Opened Box: yes; Rail (gs_shutLam_bRail): yes; Rail Position (gs_shutLam_railPos): On Casing; Rail Position (gs_shutLam_iRailPos): 1; Show Casing behind Sunshade (gs_shutLam_showCasingBehind): no; Rotation Angle of Slats (gs_shutLam_rotation): 45 deg; Rotation Angle of Slats (gs_shutLam2_rotation): 45 deg; Masonry Arch (bMasonryArch): no; Masonry Arch (gs_masonry_arch_int): 5; Masonry Arch Type (gs_masonry_arch_structure): Stucco Arch; Masonry Arch Type (gs_masonry_arch_structure_int): 1; Arch on Header: yes; Niche below Arch: yes; Skewback Angle: 75 deg; Custom Niche Surface: no; Reveal Type (gs_reveal_type_new): No Reveal; Reveal Type (gs_reveal_type_int): 2; Bottom Reveal Type (gs_reveal_type_bottom): Uniform; Bottom Reveal Type (gs_reveal_type_bottom_int): 1; Set Jamb Depth on Side: 1; Uniform Jamb Depth: yes; Outer Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleOuterTypeInt): 0; Inner Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleInnerTypeInt): 0; Angle Side 2: 20 deg; Angle Side: 20 deg; Upper Side Angle: 20 deg; Bottom Side Angle: 20 deg; Outer Angle Side 2: 20 deg; Outer Angle Side: 20 deg; Outer Angle Upper Side: 20 deg; Outer Angle Bottom Side: 20 deg; Rail under Leaves: no; Rail (gs_door_rail_ext): Off; Rail (gs_door_rail_ext_m): 1; Use Wall Finish Component: no; Auto Turn Inside Face Plaster: yes; Turn Inside Face Plaster: 0; Auto Turn Outside Face Plaster: yes; Turn Outside Face Plaster: 0; Dimensionable on 2D: no; Show in 3D: no; Closure Type (gs_closure_type): No Closure; Closure Type (gs_closure_type_int): 1; Turn Skin on Side (gs_cavity_side): Both; Turn Skin on Side (iCavityClosureSide): 1; Number of Skins to Turn: 1; Number from (gs_nTurnDir): Outside Face; Number from (iCavityClosureTurnDir): 1; Place Closer on Side 1: yes; Place Closer on Side 2: yes; Place Closer on Top: no; Place Closer on Bottom: no; Place Closer to Skin: 1; Place Closer from Side (gs_cc_dutch_ClosureToSide): 1; Gap at Outside Skin: yes; Turn Skin to Closer: no; Insert Insulation Strip: yes; Show Insulation Strip: yes; Contour Pen (gs_penJoint): Openings - Cut Non-Structural; Contour Line Type (gs_ltJoint): 1; Fill Type (gs_fillJoint): Rigid Insulation; Fill Pen (gs_penJointFg): General - General; Fill Background Pen (gs_penJointBg): 2D Elements - Drafting; Custom Surface: no; Surface: Wood - Pine Grained Horizontal; Contour Pen (gs_penPlug): Openings - Cut Non-Structural; Contour Line Type (gs_ltPlug): 1; Fill Type (gs_fillPlug): Rigid Insulation; Fill Pen (gs_penPlugFg): General - General; Fill Background Pen (gs_penPlugBg): 2D Elements - Drafting; Edited Jamb Side: 1; Edited Wall Side: 1; Edited Skin Number: 1; Turn-in Skin: no; Consider Skin as Plaster: no; Turn-in Thickness: 1; Hatch Orientation: 1; Separating Line at Turn-in: no; Separating Line Pen: General - General; Last Selected Side: no; Closure Method Changed Automatically: no; Connection on Side 1: no; Connection on Side 2: no; Connection on the Top: no; Opening Type (gs_leaf_optype): Side Hung; Opening Type (gs_leaf_optype_m): 5; End Panel Opening Side 1: no; End Panel Opening Side 2: no; Opening Angle in 2D: 90 deg; Opening Angle in 2D on Side 2: 90 deg; Opening Angle in 3D: 0 deg; End Panel Opening Angle in 3D on Side 2: 0 deg; Opening Angle of Main Sash Side 1 (openingAngle_05): 0 deg; Opening Angle of Main Sash Side 1 (openingAngle2_05): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle_09): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle2_09): 0 deg; Opening Angle of Middle Transom (openingAngle_02): 0 deg; Opening Angle of Middle Transom (openingAngle2_02): 0 deg; Opening Angle of Transom Side 1 (openingAngle_06): 0 deg; Opening Angle of Transom Side 1 (openingAngle2_06): 0 deg; Opening Angle of Transom Side 2 (openingAngle_10): 0 deg; Opening Angle of Transom Side 2 (openingAngle2_10): 0 deg; Double Acting Line Type: 4; Override MVO for 2D Symbolic Display: yes; Opening Line Type: 21; Opening Line Shape (or_SwingType): Curved; Opening Line Shape (or_iSwingType): 1; Opening Line Shape (or_iSlidingType): 0; Show Glazing Line in 2D: yes; Glazing Line Pen in 2D (or_iGlazingLinePen): 3; Glazing Line Pen in 2D (or_glazingLinePen): Openings - General; Override MVO for Door 3D Projections: yes; Show Opening Line (or_bOplines3d): yes; Line Type Opening Side (or_opLineType3dIn): Dashed; Line Type Opening Side (or_iOpLineType3dIn): 1; Line Type Opposite Side (or_opLineType3dOut): Dashed; Line Type Opposite Side (or_iOpLineType3dOut): 1; Line Orientation (or_oplineStyle): Handle; Line Orientation (or_iOplineStyle): 1; Opening Line Pen in 2D/3D (or_opLinePen): Roofs/Shells - Outlines and Cover Fills; Opening Line Pen in 2D/3D (or_iOpLinePen): 92; Override MVO for Sidelight/Transom 3D Projections: no; Show Opening Line (or_bWinOplines3d): yes; Line Type Opening Side (or_winOpLineType3dIn): Dashed; Line Type Opening Side (or_iWinOpLineType3dIn): 1; Line Type Opposite Side (or_winOpLineType3dOut): Solid Line; Line Type Opposite Side (or_iWinOpLineType3dOut): 0; Line Orientation (or_winOplineStyle): Handle; Line Orientation (or_iWinOplineStyle): 1; Opening Line Pen in 2D/3D (or_winOpLinePen): Openings - General; Opening Line Pen in 2D/3D (or_iWinOpLinePen): 3; Symbol Pen: Openings - General; Frame Contour Pen: Openings - Cut Structural; Casing Cut Line Pen on Both Sides: Openings - General; Leaf Contour Pen: Openings - General; Wall Contour Line (gs_wcont_line): Off; Wall Contour Line (iWallContourLine): 1; Wall Contour Line Type Inside: 1; Wall Contour Line Type Outside: 1; Hidden Wall Contour Line Type Inside: 4; Hidden Wall Contour Line Type Outside: 4; Sidelight Wall Contour Line (gs_wcont_line_sl): Both Sides; Sidelight Wall Contour Line (iWallContourLineSl): 4; Sidelight Wall Contour Line Type Inside: 1; Sidelight Wall Contour Line Type Outside: 1; Sidelight Hidden Wall Contour Line Type Inside: 4; Sidelight Hidden Wall Contour Line Type Outside: 4; Wall Contour Line Pen: Openings - General; Use Fills: yes; Frame Fill Type: Background; Frame Fill Pen: Openings - Cut Fills; Frame Fill Background Pen: Backgrounds - color 1; Leaf Fill Type: Air Space; Leaf Fill Pen: Backgrounds - color 1; Leaf Fill Background Pen: Backgrounds - color 1; Airtight Symbol Fill Type: Foreground; Airtight Symbol Fill Pen: General - General; Airtight Symbol Fill Background Pen: General - General; Door Plan Symbol Fill Type: Air Space; Door Plan Symbol Fill Pen: Transparent; Door Plan Symbol Fill Background Pen: Transparent; Sidelight Plan Symbol Fill Type: Background; Sidelight Plan Symbol Fill Pen: Backgrounds - color 1; Sidelight Plan Symbol Fill Background Pen: Backgrounds - color 1; Threshold and Sill Line Type: 1; Threshold Section Contour Pen: Openings - General; Threshold Section Fill Type: Background; Threshold Section Fill Pen: Backgrounds - color 1; Threshold Section Fill Background Pen: Backgrounds - color 1; Sill 3D and Uncut Pen: General - General; Sill Section Contour Pen: General - General; Sill Section Fill Type: Air Space; Sill Section Fill Pen: Backgrounds - color 1; Sill Section Fill Background Pen: Backgrounds - color 1; Section Insulation Contour Pen: General - General; Section Insulation Fill Type: Rigid Insulation; Section Insulation Fill Pen: General - General; Section Insulation Fill Background Pen: Backgrounds - color 1; Board 3D and Uncut Pen: General - General; Board Section Contour Pen: General - General; Board Section Fill Type: Air Space; Board Section Fill Pen: Backgrounds - color 1; Board Section Fill Bkg. Pen: Backgrounds - color 1; Casing Fill Type Inside: Air Space; Casing Fill Pen Inside: Backgrounds - color 1; Casing Fill Background Pen Inside: Backgrounds - color 1; Casing Fill Type Outside: Air Space; Casing Fill Pen Outside: Backgrounds - color 1; Casing Fill Background Pen Outside: Backgrounds - color 1; Arch Section Fill Type: Background; Arch Section Fill Pen: Backgrounds - color 1; Arch Section Fill Bkg. Pen: Backgrounds - color 1; Sunshade Symbol Line Type: 1; Sunshade Cut Line Pen: General - General; 3D/Section Uncut Line Pen: General - General; Sunshade Cut Fill Type: Background; Sunshade Cut Fill Pen: General - General; Sunshade Cut Fill Background Pen: Window Background; Sunshade Insulation Fill Type: Batt Insulation; Sunshade Insulation Fill Pen: General - General; Sunshade Insulation Background Pen: Window Background; Uncut Fill Type: Background; Uncut Fill Pen: Backgrounds - color 1; Uncut Fill Background Pen: Backgrounds - color 1; Opening Side Values (gs_opside_list): Custom; Opening Side Values (gs_opside_list_m): 0; Frame Element Joinery (gs_SashText_typ): Butt Joint; Frame Element Joinery (gs_SashText_typ_num): 2; Frame Pen: Openings - General; Leaf Pen: Openings - General; Sash Glass Pen: Openings - Cut Non-Structural; Leaf Glass Pen: Openings - Cut Non-Structural; Masonry Arch Pen: Walls/Curtain Walls - General; Curve Resolution: 64; Shadow: yes; Uniform Door Surfaces: yes; Frame Outside: Metal - Aluminium; Frame Inside: Metal - Aluminium; Leaf Outside: Metal - Aluminium; Leaf Inside: Metal - Aluminium; Leaf 2: Metal - Aluminium; Leaf 3: Metal - Aluminium; Lock: Paint - Anthracite; Grid Outside (gs_grill_mat): Metal - Aluminium; Grid Inside (gs_grill_mat2): Metal - Aluminium; Grid Outside (gs_leaf_grill_mat): Metal - Aluminium; Grid Inside (gs_leaf_grill_mat2): Metal - Aluminium; Solid Panel Outside: Metal - Aluminium; Solid Panel Inside: Metal - Aluminium; Sash Glass: Glass - Clear Fast; Leaf Glass: Glass - Clear Fast; Rail (gs_rail_mat): Metal - Iron; Louver Outside: Wood - Pine Grained Horizontal; Louver Inside: Wood - Pine Grained Horizontal; Kick Plate: Metal - Aluminium; Uniform Casing Surfaces: yes; Interior Casing: Wood - Pine Grained Horizontal; Exterior Casing: Wood - Pine Grained Horizontal; Shutter Panel: Wood - Pine Grained Horizontal; Shutter Panel Frame: Wood - Pine Grained Horizontal; Rolling Shutter Box: Metal - Stainless Steel; Rolling Shutter Blades: Paint - Glossy White; Rolling Shutter Rail: Paint - Glossy White; Venetian Blinds Box: Metal - Stainless Steel; Venetian Blinds Segments: Paint - Glossy White; Sliding Shutter Rail: Metal - Stainless Steel; Threshold (gs_treshold_mat): Wood - Pine Grained Horizontal; Threshold Metal: Metal - Aluminium; Sill (gs_sill_mat): Brick - Running Bond; Brick Sill Mortar: Stucco - White Rough; Board (gs_board_mat): Wood - Pine Grained Horizontal; Handle: Metal - Stainless Steel; Handle Accessories: Metal - Iron; Kick Board Outside (matKickBoardOut): Metal - Stainless Steel; Kick Board Inside (matKickBoardIn): Metal - Stainless Steel; Masonry Arch Brick: Brick - Running Bond; Masonry Arch Mortar: Stucco - White Rough; Masonry Arch Keystone: Stone - Sandstone 01; Niche: Paint - Lead Oxide Yellow; Tags and Labels: 1; Show Leaf Width Dimensions: yes; Show Door ID: no; Show Custom Text: no; Custom Text: <Custom Text>; Always Readable: yes; Font Type: Arial; Font Size: 2; Font Style: 0; Text Pen (iPenText): 1; Text Pen (penText): General - General; Door belongs to the Zone into which it opens: yes; Cost: 0; Location as: Custom; Total Glazed Area (gs_list_glassarea_tmp): 0; Override Glazed Area: no; Total Glazed Area (gs_list_glassarea): 3.91387; Total Glass Perimeter: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg; Door Orientation Definition: 0; Door Orientation: L; Door Closer: no; Vision Panel Type: No Vision Panel; Hold Open Device: no; Door Leaf Widths: 87 / 87; IFC Operation (ifc_optypestr): Double Door Single Swing; IFC Operation (ifc_optype): 2
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.20.20 Portes de façanes; 104.AMB.ClassificacioCodi: 30.10.20.20; 105.AMB.ClassificacioDescripcio: Portes de façanes; 107.AMB.NomTipus: PE201_PortaExtTipusV; 109.AMB.CodiTipus: PE201; 111.AMB.DescripcioTipus: Porta doble batent; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: PortaExtTipusV
ArchiCADQuantities - W/D Opening Opening Volume: 0.465909 m3; W/D Opening Nominal Volume: 0.476019 m3; W/D Opening Surface Area: 16.0625 m2; W/D Opening Nominal Surface Area: 5.95024 m2; W/D Opening Width on the Reveal Side: 1.78948 m; W/D Opening Height on the Reveal Side: 3.32512 m; W/D Opening Width on the Side Opposite to the Reveal Side: 1.78948 m; W/D Opening Height on the Side Opposite to the Reveal Side: 3.32512 m; W/D Opening Surface Area on the Reveal Side: 5.82386 m2; W/D Opening Surface Area on the Side Opposite to the Reveal Side: 5.82386 m2; Nominal W/D Opening Width on the Reveal Side: 1.78948 m; Nominal W/D Opening Height on the Reveal Side: 3.32512 m; Nominal W/D Opening Width on the Side Opposite to the Reveal Side: 1.78948 m; Nominal W/D Opening Height on the Side Opposite to the Reveal Side: 3.32512 m; Nominal W/D Opening Surface Area on the Reveal Side: 5.95024 m2; Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side: 5.95024 m2; Sill/Header Value: 1.71425 m; W/D Nominal Sill Height: 1.71425 m; W/D Sill Height on the Reveal Side: 0 m; W/D Sill Height on the Side Opposite to the Reveal Side: 0 m; W/D Nominal Head Height: 5.03937 m; W/D Head Height on the Reveal Side: 3.22512 m; W/D Head Height on the Side Opposite to the Reveal Side: 3.22512 m; Wall Thickness: 0.08 m; Frame Thickness: 0.115 m; Height: 3.32512 m; Volume (Net): 0.106502 m3; Width: 1.78948 m; Elevation to Project Zero: 1.71425 m; Elevation to 1st Reference Level: 1.71425 m; Elevation to 2nd Reference Level: 1.71425 m; Elevation to Sea Level: 11.0543 m; Elevation to Linked/Home Story: 1.71425 m; Home Offset: 1.71425 m; Surface Area: 16.0625 m2; Top Elevation To First Reference Level: 5.03937 m; Top Elevation To Home Story: 5.03937 m; Top Elevation To Project Zero: 5.03937 m; Top Elevation To Sea Level: 14.3794 m; Top Elevation To Second Reference Level: 5.03937 m; Bottom Elevation To First Reference Level: 1.71425 m; Bottom Elevation To Home Story: 1.71425 m; Bottom Elevation To Project Zero: 1.71425 m; Bottom Elevation To Sea Level: 11.0543 m; Bottom Elevation To Second Reference Level: 1.71425 m; Bottom Surface Area (Net): 16.0625 m2
AC_Equantity_Arch_Double_Door_27 - Width: 1.78948 m; Height: 3.32512 m; Z Dimension: 1 m; Bottom Level: 1 m; Top Level: 0 m; Sill Height to Current Story: 1.71425 m; Reveal to Wall Core: -0.03 m; New Wall Fill Width Right: 0.15 m; New Wall Fill Width Left: 0.15 m; Shoulder Height: 3.113 m; Sidelight 1 Width (gs_sidelight_width_right): 0 m; Sidelight 1 Width (gs_sidelight_width_right_half): 0.3 m; Sidelight 1 Width (gs_sidelight_width_right_orig): 0.6 m; Sidelight 1 Sill Height: 0 m; Sidelight 2 Width (gs_sidelight_width_left): 0 m; Sidelight 2 Width (gs_sidelight_width_left_half): 0.3 m; Sidelight 2 Width (gs_sidelight_width_left_orig): 0.3 m; Sidelight 2 Sill Height: 0 m; Transom Height: 0.3 m; Pivot Axis Offset: 0.275 m; Tolerance Side / Upper: 0 m; Tolerance Side 1 Lower: 0 m; Tolerance Sidelight 1 Bottom: 0 m; Tolerance Side 2: 0 m; Tolerance Side 2 Lower: 0 m; Tolerance Sidelight 2 Bottom: 0 m; Tolerance Upper: 0 m; Tolerance Lower: 0 m; Wallhole Width: 1.78948 m; Wallhole Height: 3.32512 m; Reveal Width: 1.78948 m; Reveal Height: 3.32512 m; Unit Width: 1.78948 m; Unit Height: 3.32512 m; Egress Width: 1.70948 m; Egress Height: 3.28512 m; Nominal Leaf Width: 1.73348 m; Nominal Leaf Height: 3.29712 m; Frame Thickness: 0.115 m; Frame Thickness Inside: 0.115 m; Leaf Offset: 0 m; Frame Width: 0.04 m; Frame Oversize: 0.01 m; Frame Outer Thickness: 0.01 m; Frame Width Side 1: 0.04 m; Middle Frame Width Side 1: 0.04 m; Bottom Frame Width Side 1: 0.04 m; Frame Width Side 2: 0.04 m; Middle Frame Width Side 2: 0.04 m; Bottom Frame Width Side 2: 0.04 m; Transom Frame Width (gs_frame_width_transom): 0.04 m; Upper Frame Width: 0.04 m; Door Stop Thickness: 0.032 m; Door Stop Width: 0.016 m; Rebate Width: 0.012 m; Leaf Rebate Depth in 3D: 0.04 m; Sidelight and Transom Rebate Width: 0.01 m; Sidelight and Transom Rebate Depth: 0.018 m; Nominal Leaf Width Side 1: 0.722 m; Leaf Thickness: 0.04 m; Leaf Frame Width Side: 0.1 m; Leaf Frame Width Right: 0.1 m; Leaf Frame Width Left: 0.1 m; Leaf Frame Width Lower: 0.2 m; Leaf Frame Width Upper: 0.1 m; Leaf Frame Width Internal: 0.025 m; Leaf Undercut: 0 m; Grid Width: 0.012 m; Grid Thickness: 0.025 m; Glass Thickness: 0.012 m; Handle Height (gs_han_height): 1 m; Handle Position (gs_han_pos): 0.05 m; Handle Height (gs_han_height2): 1 m; Handle Position (gs_han_pos2): 0.05 m; Kick Board Height: 0.1 m; Horizontal Division Height Sidelight Side 1: 0.9 m; Horizontal Division Height Sidelight Side 2: 0.9 m; Horizontal Division Height Middle Transom: 0.9 m; Horizontal Division Height Transom Side 1: 0.9 m; Horizontal Division Height Transom Side 2: 0.9 m; Sidelight and Transom Frame Thickness: 0.044 m; Transom Frame Width (gs_sash_width): 0.067 m; Sidelight Frame Width: 0.067 m; Grill Width: 0.02 m; Grill Thickness: 0.025 m; Sidelight Division Width: 0.04 m; Sidelight Division Thickness: 0.115 m; Width Side (gs_tw_right_out): 0.05 m; Width Side (gs_tw_left_out): 0.05 m; Width Top (gs_tw_top_out): 0.05 m; Thickness on Wall (gs_trim_thk_out): 0.019 m; Thickness in Wallhole (gs_trim_width_out): 0.025 m; Offset (gs_trim_offs_out): 0.012 m; Nosing (gs_trim_jambext_nosing_out): 0.05 m; Top Overhang (gs_trimov_top_left_out): 0 m; Top Overhang (gs_trimov_top_right_out): 0 m; Width Side (gs_tw_right_in): 0.05 m; Width Side (gs_tw_left_in): 0.05 m; Width Top (gs_tw_top_in): 0.05 m; Thickness on Wall (gs_trim_thk_in): 0.019 m; Thickness in Wallhole (gs_trim_width_in): 0.03 m; Offset (gs_trim_offs_in): 0.012 m; Nosing (gs_trim_jambext_nosing_in): 0.03 m; Top Overhang (gs_trimov_top_left_in): 0 m; Top Overhang (gs_trimov_top_right_in): 0 m; Threshold Thickness: 0.012 m; Threshold Width: 0.01 m; Threshold External Thickness: 0.00580738 m; Threshold Nosing Outside: 0.025 m; Threshold Nosing Inside: 0.025 m; Side Overhang Outside: 0 m; Side Overhang Inside: 0 m; Sill Thickness: 0.1 m; Sill Front Side Thickness: 0.015 m; Sill Elevation: 0.005 m; Sill Drip Overlap: 0.02 m; Sill Drip Width: 0.03 m; Sill Nosing: 0.03 m; Sill Overhang Side 1: 0 m; Sill Overhang Side 2: 0 m; Sill Slip-in Depth: 0.02 m; Sill Top Width: 0.01 m; Sill Top Height: 0.01 m; Sill Slip from Wall: 0 m; Rear Hole Depth (gs_sill_holeDepthBehind): 0 m; Width of Sill: 0 m; Brick Thickness (gs_brick_sill_br_thk): 0.065 m; Mortar Thickness (gs_brick_sill_mort_thk): 0.015 m; Board Width: 0.1 m; Board Thickness: 0.025 m; Board Nosing: 0.03 m; Board Overhang Side 1: 0 m; Board Overhang Side 2: 0 m; Board Slip-in Depth: 0 m; Panel Height: 1.5 m; Inner Offset: 0.02 m; Closing Depth: 0 m; Extra Frame Width: 0.04 m; Extra Frame Thickness: 0.03 m; Rail Width: 0.03 m; Hanging Stick Length: 0.02 m; Hanging Stick Radius: 0.005 m; Panel Distance: 0.006 m; Outside Overhang: 0 m; Inner Panel Width: 0.12 m; 3D Opening Length: 1.5 m; 3D Closed Length: 0 m; 3D Opening Length 1: 0.56 m; 3D Opening Length 2: 0.14 m; 3D Opening Height: 1.5 m; 3D Closed Height: 0 m; Panel Thickness: 0.05 m; Panel Frame Width: 0.05 m; Frame Width Bottom: 0.05 m; Panel Width: 0 m; Panel Fill Thickness: 0.01 m; Louver Thickness: 0.01 m; Louver Width: 0.04 m; Horizontal Frame Divider Width: 0.05 m; Vertical Frame Divider Width: 0.05 m; Hole Radius: 0.01 m; Vertical Board Width: 0.1 m; Z Frame Width: 0.05 m; Z Frame Thickness: 0.025 m; Vertical Boards Thickness: 0.025 m; Horizontal Boards Thickness: 0.025 m; Vertical Boards Approximate Width: 0.08 m; Horizontal Boards Approximate Width: 0.115 m; Box Height (gs_shutRoll_boxHeight): 0.2 m; Box Depth (gs_shutRoll_boxWidth): 0.15 m; Box Left Offset: 0 m; Box Right Offset: 0 m; Depth of Rails: 0.0725 m; Distance from Wall (gs_shutRoll_distFromWall): 0 m; Distance from Header (gs_shutRoll_distFromHead): 0 m; Slat Width: 0.05 m; Box Height (gs_shutLam_boxHeight): 0.2 m; Box Depth (gs_shutLam_boxWidth): 0.15 m; Cover Width: 0 m; Distance from Wall (gs_shutLam_distFromWall): 0 m; Distance from Header (gs_shutLam_distFromHead): 0 m; Segment Width (gs_shutLam_segmentWidth): 0.06 m; Box Height (gs_shutLam2_boxHeight): 0.06 m; Box Width: 0.06 m; Distance from Window: 0.06 m; Distance from Header (gs_shutLam2_distFromHead): 0.06 m; Box Axis Height from Header: 0 m; Segment Width (gs_shutLam2_segmentWidth): 0.06 m; Distance between Arch and Door: 0 m; Masonry Arch Overhang Side 1: 0 m; Masonry Arch Overhang Side 2: 0 m; Masonry Arch Rise: 0.03 m; Masonry Arch Projection: 0 m; Masonry Arch Height: 0.25 m; Masonry Arch Depth: 0.12 m; Rear Hole Depth (gs_masonry_arch_rearHoleDepth): 0 m; Brick Thickness (gs_masonry_arch_brick_thk): 0.065 m; Mortar Thickness (gs_masonry_arch_mort_thk): 0.01 m; Keystone Width: 0.1 m; Keystone Oversize: 0 m; Keystone Projection: 0.01 m; Reveal Depth (gs_wido_sill): -0.03 m; Reveal Depth (AC_wido_sill): -0.03 m; Jamb Depth: 0.06 m; Jamb Depth Side 2: 0.06 m; Lower Jamb Depth Side 1: 0.06 m; Lower Jamb Depth Side 2: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_splayed_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_splayed_innerRight): 0.06 m; Inner Jamb Depth (gs_reveal_double_innerRight): 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_double_innerLeft): 0.06 m; Inner Lower Jamb Depth Side 1: 0.06 m; Inner Lower Jamb Depth Side 2: 0.06 m; Head Depth: 0.06 m; Sill Depth: 0.06 m; Sill Depth Side 1: 0.06 m; Sill Depth Side 2: 0.06 m; Inner Head Depth (gs_reveal_splayed_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_splayed_innerBottom): 0.06 m; Inner Head Depth (gs_reveal_double_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_double_innerBottom): 0.06 m; Inner Sill Depth Side 1: 0 m; Inner Sill Depth Side 2: 0 m; Outer Jamb Depth: 0.08 m; Plaster Thickness Limit: 0.04 m; Distance of Skin from Closer: 0 m; Closer Width: 0.038 m; Closer Thickness: 0.1 m; Strip Thickness: 0.025 m; Profile Width: 0.15 m; Custom Thickness: 0.015 m; Skin Overhang to Frame Depth: 0 m; Left Opening Oversize: 0 m; Right Opening Oversize: 0 m; Upper Opening Oversize: 0 m; Lower Opening Oversize: 0 m; Opening Width in 3D: 0 m; Opening Width in 3D on Side 2: 0 m; Opening Width in 2D: 0 m; Opening Width in 2D on Side 2: 0 m; Opening Distance 1 Main Sash Side 1: 0 m; Opening Distance 2 Main Sash Side 1: 0 m; Opening Distance 1 Main Sash Side 2: 0 m; Opening Distance 2 Main Sash Side 2: 0 m; Opening Distance 1 Middle Transom: 0 m; Opening Distance 2 Middle Transom: 0 m; Opening Distance 1 Transom Side 1: 0 m; Opening Distance 2 Transom Side 1: 0 m; Opening Distance 1 Transom Side 2: 0 m; Opening Distance 2 Transom Side 2: 0 m; Opening Side Width 2: 0.1 m; Opening Side Width 1: 0.1 m; Opening Side Depth: 1.8 m; Opposite Side Width 2: 0.1 m; Opposite Side Width 1: 0.1 m; Opposite Side Depth: 1.2 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m; Real Frame Thickness: 0.115 m; ID Offset X: 0 m; ID Offset Y: 0 m; Custom Text Offset X: 0 m; Custom Text Offset Y: 0 m; Leaf Width Offset X: 0 m; Leaf Width Offset Y: 0 m
5 AMB.Geometria - 502.AMB.Amplada: 1.78948 m; 503.AMB.Altura: 3.32512 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.106502 m3; Component, Component Volume (Gross): 0.106502 m3

# IfcBuildingElementProxy: Arch Top Window 27 (4)
In: planta baixa
Classification: 30.10.20.10 Finestres de façanes (GuBIMclass CA)
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0; Status: NEW
ArchiCADProperties - Wall Structure: Insulation; Marker Text: <Custom Text>; Opening Library Part Name: Arch Top Window 27; Opening Side Fill Index: Background; Layer: 00_TABIQUE; Library Part Name: Arch Top Window 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Lateral; Locked: no; Element Type: Window; Parent ID: F5; Surfaces (All): Wood - Pine Grained Horizontal; Glass - Clear Fast; Metal - Aluminium; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Arch_Top_Window_27 - Wall Contours (0-None,1-Full,2-Side,3-Length): 0; Hotspots 0-None,1-2D,2-3D,3-All: 3; Floor Plan Display Option: 3; Hole Position Angle: 0 deg; Hole has Wall's Side Surface: yes; Hole Surface's Split is Curved in Curved Walls: no; Show 2D Hotspots in 3D: yes; Wall Type: 1; Reveal Anchor Position: 1; Flip: no; Semicircular Arch Top: no; Demolition / New construction: 1; New Wall Fill Type: Masonry Block; New Wall Fill Pen: General - General; New Wall Fill Background Pen: Backgrounds - color 1; Show new construction on Wall: no; Demolition line type: 4; Show Demolition/New parameter: no; Fully Editable: yes; 2D Detail Level: 1; Show Reveal on Symbol: 1; 3D Detail Level: 8; Nominal Size: 0; Set Wallhole Size as Nominal Size: yes; Set Reveal Size as Nominal Size: no; Set Unit Size as Nominal Size: no; Transfer Current Nominal Size to Selection: no; Transom: no; Uniform Sashes: no; Fixed Glass Direction (FixGlassDir): By Opening Direction; Fixed Glass Direction (FixGlassDir_m): 1; Opening Type Main Sash: Fixed Glass; Opening Type (gs_optype_m_01): 1; Opening Type Transom Sash: Fixed Glass; Opening Type (gs_optype_m_02): 1; Sash Type (MullionStyle_00): No Grid; Sash Type (iMullionStyle_00): 1; Sash Type Main Sash: No Grid; Sash Type (iMullionStyle_01): 1; Sash Type Transom Sash: No Grid; Sash Type (iMullionStyle_02): 1; Mirrored Custom Panel (gs_bMirr_cust_panel_01): no; Mirrored Custom Panel (gs_bMirr_cust_panel2_01): no; Hotspot Grill Editing: no; Grid Position (MullionPosition): Throughout; Grid Position (iMullionPosition): 3; Panes Number Vertically Main Sash: 3; Panes Number Horizontally Main Sash: 3; Panes Number Vertically 2 Main Sash: 3; Panes Number Horizontally 2 Main Sash: 3; Panes Number Vertically Transom Sash: 2; Panes Number Horizontally Transom Sash: 2; Panes Number Vertically 2 Transom Sash: 2; Panes Number Horizontally 2 Transom Sash: 2; Louvers Style (iLouverStyle): 1; Opening Angle of Louvers: 0 deg; Window Handle: no; Window Handle Type (gs_handle_type_win): Style 1; Window Handle Type (gs_handle_type_win_m): 1; Casing Outside: no; Casing Type Outside (gs_trimtype_out): Simple; Casing Type Outside (gs_trimtype_out_int): 1; Uniform Casing Widths (gs_trim_outside_uniform): yes; Casing Inside: yes; Casing Type Inside (gs_trimtype_in): Simple; Casing Type Inside (gs_trimtype_in_int): 1; Cover Inner Wall Surface: no; Uniform Casing Widths (gs_trim_inside_uniform): yes; Sill (gs_sill_outside): no; Sill Oversize: no; Type of the Sill: 1; Sill Angle: 3 deg; Sill is Curved in Curved Walls: yes; Insulation below Sill: yes; Use Wall Insulation Skin: no; Brick Sill 3D Detail Level: 1; Board (gs_board_inside): no; Board Angle: 0 deg; Board is Curved in Curved Walls: yes; Board in Polygonal Walls: 1; Natural Ventilation: no; Natural Ventilation Type: 3; Main Sash: yes; Sunshade: no; Sunshade Type: 1; Enabled Sunshade Types: 38; Number of Panels: 2; Number of Panels 2: 1; Panel Position (gs_shutter_panelPos): Symmetric; Panel Position (gs_shutter_iPanelPos): 1; Automatic Shutter Height: yes; Extra Frame: no; Cover Type (gs_slidingShutter_cover): Z-Profile; Cover Type (gs_slidingShutter_iCover): 1; Stacking Direction (gs_foldingShutter_stacking): Inside; Stacking Direction (gs_foldingShutter_iStacking): 1; Open in 3D: yes; 3D Opening Angle: 180 deg; Show 2D Symbol: yes; Show Opening Lines on Symbol: no; Panel Type (gs_shutPanel_type): Style 1; Panel Type (gs_shutPanel_iType): 1; Different Bottom Frame Width: no; Automatic Shutter Width: yes; Louver Angle: 30 deg; Holes Number Horizontal: 5; Holes Number Vertical: 8; Rolling Shutter Placement (gs_shutRoll_placement): On Facade; Rolling Shutter Placement (gs_shutRoll_iPlacement): 1; Box Type (gs_shutRoll_boxType): Rectangular; Box Type (gs_shutRoll_iBoxType): 1; Rail Position (gs_shutRoll_railPos): On Casing; Rail Position (gs_shutRoll_iRailPos): 1; Show Casing behind Sunshade (gs_shutRoll_showCasingBehind): no; Insulation behind Box (gs_shutRoll_cutWallBehind): no; Include Height in Wallhole Height: no; Box Top Angle: 10 deg; Box Default Width (gs_shutRoll_boxDefaultSize): Reveal Width; Box Default Width (gs_shutRoll_iBoxDefaultSize): 1; Venetian Blinds Placement (gs_shutLam_placement): Fixed on Facade; Venetian Blinds Placement (gs_shutLam_iPlacement): 1; Insulation behind Box (gs_shutLam_cutWallBehind): no; Opened Box: yes; Rail: yes; Rail Position (gs_shutLam_railPos): On Casing; Rail Position (gs_shutLam_iRailPos): 1; Show Casing behind Sunshade (gs_shutLam_showCasingBehind): no; Rotation Angle of Slats (gs_shutLam_rotation): 45 deg; Rotation Angle of Slats (gs_shutLam2_rotation): 45 deg; Masonry Arch (bMasonryArch): no; Masonry Arch (gs_masonry_arch_int): 5; Masonry Arch Type (gs_masonry_arch_structure): Stucco Arch; Masonry Arch Type (gs_masonry_arch_structure_int): 1; Arch on Header: yes; Niche below Arch: yes; Skewback Angle: 75 deg; Custom Niche Surface: no; Reveal Type (gs_reveal_type_new): No Reveal; Reveal Type (gs_reveal_type_int): 2; Bottom Reveal Type (gs_reveal_type_bottom): Uniform; Bottom Reveal Type (gs_reveal_type_bottom_int): 1; Outer Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleOuterTypeInt): 0; Inner Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleInnerTypeInt): 0; Uniform Jamb Depth: yes; Angle Side 2: 20 deg; Angle Side: 20 deg; Upper Side Angle: 20 deg; Bottom Side Angle: 20 deg; Use Wall Finish Component: no; Auto Turn Inside Face Plaster: yes; Turn Inside Face Plaster: 0; Auto Turn Outside Face Plaster: yes; Turn Outside Face Plaster: 0; Dimensionable on 2D: no; Show in 3D: no; Closure Type (gs_closure_type): No Closure; Closure Type (gs_closure_type_int): 1; Turn Skin on Side (gs_cavity_side): Both; Turn Skin on Side (iCavityClosureSide): 1; Number of Skins to Turn: 1; Number from (gs_nTurnDir): Outside Face; Number from (iCavityClosureTurnDir): 1; Place Closer on Side 2: yes; Place Closer on Side 1: yes; Place Closer on Top: no; Place Closer on Bottom: no; Place Closer to Skin: 1; Place Closer from Side (gs_cc_dutch_ClosureToSide): 1; Gap at Outside Skin: yes; Turn Skin to Closer: no; Insert Insulation Strip: yes; Show Insulation Strip: yes; Contour Pen (gs_penJoint): Openings - Cut Non-Structural; Contour Line Type (gs_ltJoint): 1; Fill Type (gs_fillJoint): Rigid Insulation; Fill Pen (gs_penJointFg): General - General; Fill Background Pen (gs_penJointBg): 2D Elements - Drafting; Custom Surface: no; Surface: Wood - Pine Grained Horizontal; Contour Pen (gs_penPlug): Openings - Cut Non-Structural; Contour Line Type (gs_ltPlug): 1; Fill Type (gs_fillPlug): Rigid Insulation; Fill Pen (gs_penPlugFg): General - General; Fill Background Pen (gs_penPlugBg): 2D Elements - Drafting; Edited Jamb Side: 1; Edited Wall Side: 1; Edited Skin Number: 1; Turn-in Skin: no; Consider Skin as Plaster: no; Turn-in Thickness: 1; Hatch Orientation: 1; Separating Line at Turn-in: no; Separating Line Pen: General - General; Last Selected Side: no; Closure Method Changed Automatically: no; Connection on the Left: no; Connection on the Right: no; Connection on the Top: no; Connection on the Bottom: no; Wall Inset: no; Wall Inset Sizes (gs_parapet_sizes_st): Automatic; Wall Inset Sizes (iParapetSize): 1; Auto Width and Height Dimensions: yes; Wall Inset Bottom at (gs_parapet_bottom_st): Current Story; Wall Inset Bottom at (iParapetBottom): 1; Show Hidden Parapet: yes; Hidden Parapet Line Type: 1; Opening Angle of Main Sash (openingAngle_01): 0 deg; Opening Angle of Main Sash (openingAngle2_01): 0 deg; Opening Angle of Transom Sash (openingAngle_02): 0 deg; Opening Angle of Transom Sash (openingAngle2_02): 0 deg; Opening Angle in 2D: 0 deg; Override MVO for 2D Symbolic Display: no; Opening Line Type: 1; Opening Line Shape (or_SwingType): Curved; Opening Line Shape (or_iSwingType): 1; Opening Line Shape (or_iSlidingType): 0; Opening Line Pen in 2D/3D (or_opLinePen): Roofs/Shells - Outlines and Cover Fills; Opening Line Pen in 2D/3D (or_iOpLinePen): 92; Override MVO for 3D Projections: yes; Show Opening Line: yes; Line Type Opening Side (or_opLineType3dIn): Dashed; Line Type Opening Side (or_iOpLineType3dIn): 1; Line Type Opposite Side (or_opLineType3dOut): Dashed; Line Type Opposite Side (or_iOpLineType3dOut): 1; Line Orientation (or_oplineStyle): Handle; Line Orientation (or_iOplineStyle): 1; Uncut Line Pen: Openings - General; Cut Line Pen: Openings - Cut Structural; Casing Cut Line Pen on Both Sides: Openings - General; Wall Contour Line (gs_wcont_line): Both Sides; Wall Contour Line (iWallContourLine): 4; Wall Contour Line Type Inside: 1; Wall Contour Line Type Outside: 1; Hidden Wall Contour Line Type Inside: 4; Hidden Wall Contour Line Type Outside: 4; Wall Contour Line Pen: Openings - General; Use Fills: yes; Frame Fill Type: Background; Frame Fill Pen: Openings - Cut Fills; Frame Fill Background Pen: Backgrounds - color 1; Sash Fill Type: Air Space; Sash Fill Pen: Openings - Cut Fills; Sash Fill Background Pen: Backgrounds - color 1; Uncut Fill Type: Background; Uncut Fill Pen: Openings - Cut Fills; Uncut Fill Background Pen: Backgrounds - color 1; Plan Symbol Fill Type: Background; Plan Symbol Fill Pen: Backgrounds - color 1; Plan Symbol Fill Background Pen: Backgrounds - color 1; Sill 3D and Uncut Pen: General - General; Sill Section Contour Pen: General - General; Sill Section Fill Type: Air Space; Sill Section Fill Pen: Backgrounds - color 1; Sill Section Fill Bkg. Pen: Backgrounds - color 1; Section Insulation Contour Pen: General - General; Section Insulation Fill Type: Rigid Insulation; Section Insulation Fill Pen: General - General; Section Insulation Fill Background Pen: Backgrounds - color 1; Board 3D and Uncut Pen: General - General; Board Section Contour Pen: General - General; Board Section Fill Type: Air Space; Board Section Fill Pen: Backgrounds - color 1; Board Section Fill Bkg. Pen: Backgrounds - color 1; Casing Fill Type Inside: Air Space; Casing Fill Pen Inside: Backgrounds - color 1; Casing Fill Background Pen Inside: Backgrounds - color 1; Casing Fill Type Outside: Air Space; Casing Fill Pen Outside: Backgrounds - color 1; Casing Fill Background Pen Outside: Backgrounds - color 1; Arch Section Fill Type: Background; Arch Section Fill Pen: Backgrounds - color 1; Arch Section Fill Bkg. Pen: Backgrounds - color 1; Ventilation Profile Section Fill Type: Air Space; Ventilation Profile Section Fill Pen: Backgrounds - color 1; Ventilation Profile Section Fill Background Pen: Backgrounds - color 1; Sunshade Symbol Line Type: 1; Sunshade Cut Line Pen: General - General; 3D/Section Uncut Line Pen: General - General; Sunshade Cut Fill Type: Background; Sunshade Cut Fill Pen: General - General; Sunshade Cut Fill Background Pen: Window Background; Sunshade Insulation Fill Type: Batt Insulation; Sunshade Insulation Fill Pen: General - General; Sunshade Insulation Background Pen: Window Background; Frame Element Joinery: 2; Frame Pen: Openings - General; Sash Pen: Openings - General; Glass Pen: Openings - Cut Non-Structural; Masonry Arch Pen: Walls/Curtain Walls - General; Shadow: yes; Uniform Window Surfaces: yes; Frame Outside: Metal - Aluminium; Frame Inside: Metal - Aluminium; Sash Outside: Metal - Aluminium; Sash Inside: Metal - Aluminium; Louvers: Wood - Pine Grained Horizontal; Glass: Glass - Clear Fast; Grid Outside: Metal - Aluminium; Grid Inside: Metal - Aluminium; Solid Panel Outside: Metal - Aluminium; Solid Panel Inside: Metal - Aluminium; Handle: Metal - Stainless Steel; Uniform Casing Surfaces: yes; Interior Casing: Wood - Pine Grained Horizontal; Exterior Casing: Wood - Pine Grained Horizontal; Ventilation Profile: Metal - Aluminium; Shutter Panel: Wood - Pine Grained Horizontal; Shutter Panel Frame: Wood - Pine Grained Horizontal; Rolling Shutter Box: Metal - Stainless Steel; Rolling Shutter Blades: Paint - Glossy White; Rolling Shutter Rail: Paint - Glossy White; Venetian Blinds Box: Metal - Stainless Steel; Venetian Blinds Segments: Paint - Glossy White; Sliding Shutter Rail: Metal - Stainless Steel; Sill (gs_sill_mat): Wood - Pine Grained Horizontal; Brick Sill Mortar: Stucco - White Rough; Board (gs_board_mat): Wood - Pine Grained Horizontal; Masonry Arch Brick: Brick - Running Bond; Masonry Arch Mortar: Stucco - White Rough; Masonry Arch Keystone: Stone - Sandstone 01; Niche: Paint - Lead Oxide Yellow; Opening Direction: 1; Head Depth on Symbol: no; Head Depth Symbol Line Type: 21; Head Depth Symbol Pen: Annotation Text - General; Window belongs to the Zone into which it opens: no; Cost: 0; Total Glazed Area (gs_list_glassarea_tmp): 0; Override Glazed Area: no; Total Glass Perimeter: 0; Free Air Performance (mm2/l/m): 0; Group Type (FM_Type): Default Objects; Group Type (iFMType): 1; Object Weight: 0; Object Weight Unit: kg; Window Orientation Definition: 0; IFC Operation (ifc_optypestr): Other; IFC Operation (ifc_optype): 10; Shutter Opening Angle: 180 deg; Opening Line Style: 1
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.20.10 Finestres de façanes; 104.AMB.ClassificacioCodi: 30.10.20.10; 105.AMB.ClassificacioDescripcio: Finestres de façanes; 111.AMB.DescripcioTipus: Finestra fixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
ArchiCADQuantities - Wall Thickness: 0.08 m; Frame Thickness: 0.05 m
