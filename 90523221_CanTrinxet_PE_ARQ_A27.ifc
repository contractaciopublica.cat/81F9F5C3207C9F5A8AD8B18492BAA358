Properties of the parts of a building model (IFC2X3), part 5 of 99

# IfcBuildingElementProxy: Concrete - Structural 400 (8)
Name | Classification | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Layer | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | AUX_107.NomTipus | Concrete - Structural, Embodied Carbon | Concrete - Structural, Embodied Energy (MJ) | Maximum Height of the Wall (m) = Height (m) = 503.AMB.Altura (m) = Concrete - Structural, Rectangular Component Height (m) | Minimum Height of the Wall (m) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Length of Reference Line (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) = Length of the Wall on the Inside Face (m) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) = Concrete - Structural, Component Volume (Net) (m3) = Concrete - Structural, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Concrete - Structural, Mass (kg) | Concrete - Structural, Projected Component Area (Net) (m2) = Concrete - Structural, Projected Component Area (Gross) (m2) | Concrete - Structural, Component Cross Section Area (m2)
FO2 | 20.10 Fonaments i contenció de terres (GuBIMclass CA) | FO2 | 00_FUNDACIONES | 20.10 Fonaments i contenció de terres | 20.10 | Fonaments i contenció de terres | FO2_FonamentsFormigo | Fonaments a la Nau Santa Eulalia (vestíbul) | FonamentsFormigo | 972.974 (kgCO₂) | 9434.9 | 0.678082 | 0 | 7.47621 | 5.34381 | 5.33882 | 7.87341 | 7.07901 | 5.34381 | 5.33882 | 3.15084 | 2.13653 | -0.958082 | 8.38192 | 7.90338 | 2.13653 | 16.0804 | -0.28 | 9.06 | 6.30167 | 4914.01 | 5.35915 | 0.271233
F2 | 20.20.10.30 Murs estructurals (GuBIMclass CA) | F2 | 00_MURO HORMIGON | 20.20.10.30 Murs estructurals | 20.20.10.30 | Murs estructurals | F2_Mur_400_Formigo | Mur de formigó armat vist amb 20% d'arids reciclats de maó | Mur_400_Formigo | 287.986 (kgCO₂) | 2792.59 | 4.28 | 4.28 | 0.369381 | 1.58095 | 1.58095 | 0.369381 | 0.369381 | 1.58095 | 1.58095 | 0.147752 | 0.63238 | -0.28 | 9.06 | 0.369381 | 0.63238 | 1.53876 | 4 | 13.34 | 3.7195 | 1454.47 | 1.58095 | 1.712 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
F2 | 20.20.10.30 Murs estructurals (GuBIMclass CA) | F2 | 00_MURO HORMIGON | 20.20.10.30 Murs estructurals | 20.20.10.30 | Murs estructurals | F2_Mur_400_Formigo | Mur de formigó armat vist amb 20% d'arids reciclats de maó | Mur_400_Formigo | 286.873 (kgCO₂) | 2781.8 | 4.28 | 0 | 0.367961 | 1.45732 | 1.57466 | 0.36791 | 0.368011 | 1.57509 | 1.57466 | 0.147184 | 0.629936 | -0.28 | 9.06 | 0.368011 | 0.629949 | 1.53592 | 4 | 13.34 | 1.87837 | 1448.85 | 1.57509 | 1.712 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia; Vestíbul
F2 | 20.20.10.30 Murs estructurals (GuBIMclass CA) | F2 | 00_MURO HORMIGON | 20.20.10.30 Murs estructurals | 20.20.10.30 | Murs estructurals | F2_Mur_400_Formigo | Mur de formigó armat vist amb 20% d'arids reciclats de maó | Mur_400_Formigo | 285.889 (kgCO₂) | 2772.25 | 4.28 | 0 | 0.366732 | 1.45294 | 1.56888 | 0.36656 | 0.366903 | 1.57035 | 1.56888 | 0.146693 | 0.627775 | -0.28 | 9.06 | 0.366903 | 0.627845 | 1.53346 | 4 | 13.34 | 1.87739 | 1443.88 | 1.57035 | 1.712 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
F2 | 20.20.10.30 Murs estructurals (GuBIMclass CA) | F2 | 00_MURO HORMIGON | 20.20.10.30 Murs estructurals | 20.20.10.30 | Murs estructurals | F2_Mur_400_Formigo | Mur de formigó armat vist amb 20% d'arids reciclats de maó | Mur_400_Formigo | 298.15 (kgCO₂) | 2891.15 | 4.28 | 4.28 | 0.382418 | 1.63675 | 1.63675 | 0.382418 | 0.382418 | 1.63675 | 1.63675 | 0.152967 | 0.654699 | -0.28 | 9.06 | 0.382418 | 0.654699 | 1.56484 | 4 | 13.34 | 3.72993 | 1505.81 | 1.63675 | 1.712 | ArchiCADProperties - Colliding Zones: Nau Santa Eulàlia
FO2 | 20.10 Fonaments i contenció de terres (GuBIMclass CA) | FO2 | 00_FUNDACIONES | 20.10 Fonaments i contenció de terres | 20.10 | Fonaments i contenció de terres | FO2_FonamentsFormigo | Fonaments a la Nau Santa Eulalia (vestíbul) | FonamentsFormigo | 510.396 (kgCO₂) | 4949.3 | 0.678082 | 0 | 4.53323 | 2.80191 | 2.80191 | 4.93435 | 4.13211 | 3.3459 | 3.3459 | 1.65284 | 1.12076 | -0.958082 | 8.38192 | 4.16209 | 1.33836 | 10.2002 | -0.28 | 9.06 | 3.30569 | 2577.76 | 2.82224 | 0.271233
FO2 | 20.10 Fonaments i contenció de terres (GuBIMclass CA) | FO2 | 00_FUNDACIONES | 20.10 Fonaments i contenció de terres | 20.10 | Fonaments i contenció de terres | FO2_FonamentsFormigo | Fonaments a la Nau Santa Eulalia (vestíbul) | FonamentsFormigo | 509.788 (kgCO₂) | 4943.4 | 0.678082 | 0 | 4.52782 | 2.79857 | 2.79857 | 4.92846 | 4.12718 | 3.3419 | 3.3419 | 1.65087 | 1.11943 | -0.958082 | 8.38192 | 4.1498 | 1.33676 | 10.1884 | -0.28 | 9.06 | 3.30175 | 2574.69 | 2.8139 | 0.271233
FO2 | 20.10 Fonaments i contenció de terres (GuBIMclass CA) | FO2 | 00_FUNDACIONES | 20.10 Fonaments i contenció de terres | 20.10 | Fonaments i contenció de terres | FO2_FonamentsFormigo | Fonaments a la Nau Santa Eulalia (vestíbul) | FonamentsFormigo | 983.257 (kgCO₂) | 9534.61 | 0.678082 | 0 | 7.55946 | 5.39527 | 5.40026 | 7.96402 | 7.15489 | 5.39527 | 5.40026 | 3.18413 | 2.15911 | -0.958082 | 8.38192 | 7.98663 | 2.15911 | 16.2574 | -0.28 | 9.06 | 6.36827 | 4965.94 | 5.41559 | 0.271233

# IfcBuildingElementProxy: Concrete - Structural 600 (27)
In: planta baixa
Classification: 20.10 Fonaments i contenció de terres (GuBIMclass CA); Material: Concrete - Structural
ArchiCADProperties - Reference Plane Location: Top; Layer: 00_FUNDACIONES; Building Material / Composite / Profile / Fill: Concrete - Structural; Building Material: Concrete - Structural; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Basic; Building Materials (All): Concrete - Structural; Cover Fill: Background; Number of Openings: 0; Top Surface: Concrete - Smooth Finish; Edge Surface: Concrete - Smooth Finish; Bottom Surface: Concrete - Smooth Finish; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 20.10 Fonaments i contenció de terres; 104.AMB.ClassificacioCodi: 20.10; 105.AMB.ClassificacioDescripcio: Fonaments i contenció de terres; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Si
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 20; AUX_107.NomTipus: FonamentsFormigo
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Height: 0.6 m; Thickness: 0.6 m; Floor Plan Holes Perimeter: 0 m
5 AMB.Geometria - 503.AMB.Altura: 0.6 m; 504.AMB.Gruix: 0.6 m; 506.AMB.Profunditat: 0 m
Component Quantities - Concrete - Structural, Component Thickness: 0.6 m
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Name | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Surfaces (All) | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | Concrete - Structural, Embodied Carbon | Concrete - Structural, Embodied Energy (MJ) | Elevation Bottom (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Surface Area of the Slab Top (Conditional) (m2) = Area (m2) = Surface Area (m2) = Top Surface Area (Net) (m2) = Top Surface Area (Conditional) (m2) = Bottom Surface Area (Net) (m2) = Bottom Surface Area (Conditional) (m2) = Concrete - Structural, Projected Component Area (Net) (m2) = Concrete - Structural, Projected Component Area (Gross) (m2) | Surface Area of the Slab Bottom (Gross) (m2) = Surface Area of the Slab Bottom (Gross, with holes) (m2) = Surface Area of the Slab Top (Gross) (m2) = Surface Area of the Slab Top (Gross, with holes) (m2) = Bottom Surface Area (Gross) (m2) = Top Surface Area (Gross) (m2) | Surface Area of the Slab Edges (Gross) (m2) = Surface Area of the Slab Edges (Gross, with holes) (m2) = Edge Surface Area (Gross) (m2) | Holes Surface Area (m2) | Elevation Top (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Volume (Net) (m3) = Volume (Conditional) (m3) = Concrete - Structural, Component Volume (Net) (m3) = Concrete - Structural, Component Volume (Gross) (m3) | Elevation to Sea Level (m) = Top Elevation To Sea Level (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Bottom Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Concrete - Structural, Mass (kg)
19 x FO1 | FO1 | Concrete - Smooth Finish | FO1_FonamentsFormigo | Fonaments a la Nau Santa Eulalia | Nau Santa Eulalia | 396.796 (kgCO₂) | 3847.72 | -0.82 | 1.45219 | 1.45219 | 4.41251 | 0 | -0.22 | 0.871314 | 9.12 | 0.871314 | 7.35418 | 8.52 | 4.41251 | 2004.02
FO4 | FO4 | Concrete - Smooth Finish | FO4_FonamentsFormigo | Fonaments a la Nau Lateral Sud | Nau Lateral | 318.97 (kgCO₂) | 3093.04 | 0.624253 | 1.16736 | 1.16736 | 3.65297 | 0 | 1.22425 | 0.700418 | 10.5643 | 0.700418 | 6.08828 | 9.96425 | 3.65297 | 1610.96 | ArchiCADProperties - Colliding Zones: Nau Lateral; Sala de reunions
FO4 | FO4 | Concrete - Smooth Finish | FO4_FonamentsFormigo | Fonaments a la Nau Lateral Sud | Nau Lateral | 343.537 (kgCO₂) | 3331.27 | 0.624253 | 1.25727 | 1.25727 | 3.89272 | 0 | 1.22425 | 0.754363 | 10.5643 | 0.754363 | 6.48787 | 9.96425 | 3.89272 | 1735.03 | ArchiCADProperties - Colliding Zones: Distribuïdor; Nau Lateral
FO4 | FO4 | Concrete - Smooth Finish | FO4_FonamentsFormigo | Fonaments a la Nau Lateral Sud | Nau Lateral | 163.135 (kgCO₂) | 1581.91 | 0.624253 | 0.597038 | 0.597038 | 2.1321 | 0 | 1.22425 | 0.358223 | 10.5643 | 0.358223 | 3.5535 | 9.96425 | 2.1321 | 823.912 | ArchiCADProperties - Colliding Zones: Nau Lateral; Sala d'actes; Sala de reunions
FO4 | FO4 | Concrete - Smooth Finish | FO4_FonamentsFormigo | Fonaments a la Nau Lateral Sud | Nau Lateral | 392.218 (kgCO₂) | 3803.33 | 0.624253 | 1.43544 | 1.43544 | 4.36783 | 0 | 1.22425 | 0.861261 | 10.5643 | 0.861261 | 7.27971 | 9.96425 | 4.36783 | 1980.9 | ArchiCADProperties - Colliding Zones: Nau Lateral; Sala de reunions
FO3 | FO3 | Concrete - Smooth Finish | FO3_FonamentsFormigo | Fonaments a l'Annex | Annex | 159.744 (kgCO₂) | 1549.03 | 0.1 | 0.584627 | 0.584627 | 2.09901 | 0 | 0.7 | 0.350776 | 10.04 | 0.350776 | 3.49834 | 9.44 | 2.09901 | 806.786 | ArchiCADProperties - Colliding Zones: Lavabo; Nau Annexa
FO3 | FO3 | Concrete - Smooth Finish; Concrete - Bush hammered | FO3_FonamentsFormigo | Fonaments a l'Annex | Annex | 159.373 (kgCO₂) | 1545.44 | 0.1 | 0.583272 | 0.584627 | 2.09901 | 0.0013556 | 0.7 | 0.349963 | 10.04 | 0.350776 | 3.49834 | 9.44 | 1.31825 | 804.915 | ArchiCADProperties - Colliding Zones: Lavabo; Nau Annexa
FO3 | FO3 | Concrete - Smooth Finish | FO3_FonamentsFormigo | Fonaments a l'Annex | Annex | 231.264 (kgCO₂) | 2242.56 | 0.1 | 0.846377 | 0.846377 | 2.797 | 0 | 0.7 | 0.507826 | 10.04 | 0.507826 | 4.66167 | 9.44 | 2.797 | 1168 | ArchiCADProperties - Colliding Zones: Instal·lacions; Nau Annexa
FO3 | FO3 | Concrete - Smooth Finish | FO3_FonamentsFormigo | Fonaments a l'Annex | Annex | 231.264 (kgCO₂) | 2242.56 | 0.1 | 0.846377 | 0.846377 | 2.797 | 0 | 0.7 | 0.507826 | 10.04 | 0.507826 | 4.66167 | 9.44 | 2.797 | 1168 | ArchiCADProperties - Colliding Zones: Lavabo; Nau Annexa

# IfcBuildingElementProxy: Concrete 10-22-5 470 (4)
In: planta baixa
Classification: 40.20.20.20 Paviments (GuBIMclass CA)
ArchiCADProperties - Reference Plane Location: Top; Element ID: S1; Hotlink and Element ID: S1; Layer: 00_PAVIMENTOS; Building Material / Composite / Profile / Fill: Concrete 10-22-5; Composite Structure: Concrete 10-22-5; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Slab; Structure Type: Composite; Parent ID: S1; Building Materials (All): Stone - Finish; Plaster - Gypsum; Insulation - Mineral Soft; Concrete - Structural; Air Space - Frame; Concrete - Structural; Surfaces (All): Stone - Marble Carrara White; Paint - Titanium White; Stucco - Beige Rough; Insulation - Cellulose; Concrete - Bush hammered; Pavement - Terrazo; Cover Fill: Carpet; Number of Openings: 0; Top Surface: Pavement - Terrazo; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 40.20.20.20 Paviments; 104.AMB.ClassificacioCodi: 40.20.20.20; 105.AMB.ClassificacioDescripcio: Paviments; 107.AMB.NomTipus: S1_SoleraVentilada; 109.AMB.CodiTipus: S1; 111.AMB.DescripcioTipus: Solera de formigó ventilada amb capa d'aïllament XPS, morter i terratzo fet in situ; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40; AUX_107.NomTipus: SoleraVentilada
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Height: 0.47 m; Thickness: 0.47 m; Floor Plan Holes Perimeter: 0 m
5 AMB.Geometria - 503.AMB.Altura: 0.47 m; 504.AMB.Gruix: 0.47 m; 506.AMB.Profunditat: 0 m
Name | Colliding Zones | 117.AMB.Localitzacio | Elevation Bottom (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Surface Area of the Slab Top (Conditional) (m2) = Top Surface Area (Conditional) (m2) | Surface Area of the Slab Bottom (Gross) (m2) = Surface Area of the Slab Bottom (Gross, with holes) (m2) = Surface Area of the Slab Top (Gross) (m2) = Surface Area of the Slab Top (Gross, with holes) (m2) = Bottom Surface Area (Gross) (m2) = Top Surface Area (Gross) (m2) | Surface Area of the Slab Edges (Gross) (m2) = Surface Area of the Slab Edges (Gross, with holes) (m2) = Edge Surface Area (Gross) (m2) | Holes Surface Area (m2) | Elevation Top (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Area (m2) = Surface Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) | Elevation to Sea Level (m) = Top Elevation To Sea Level (m) | Volume (Conditional) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Bottom Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) = Bottom Surface Area (Conditional) (m2)
S1 | Despatx; Espai d'atenció; Espai d'espera; Lavabo; Lavabo; Nau Santa Eulàlia; Neteja; Office | Nau Santa Eulalia | -0.2 | 124.474 | 145.856 | 27.3154 | 20.262 | 0.27 | 125.594 | 58.7059 | 9.61 | 58.5029 | 68.5525 | 58.1179 | 9.14 | 1.6366 | 124.474
S1 | Nau Santa Eulàlia; Vestíbul | Nau Santa Eulalia | -0.2 | 34.5016 | 34.5819 | 13.8483 | 0.0803476 | 0.27 | 34.5016 | 16.0615 | 9.61 | 16.0615 | 16.2535 | 29.4644 | 9.14 | 12.4988 | 33.9819
S1 | Despatx; Espai d'atenció; Espai de treball; Espai d'espera; Espai públic; Lavabo; Nau Santa Eulàlia; Office; Rack; Sala de reunions | Nau Santa Eulalia | -0.2 | 129.48 | 151.709 | 28.3118 | 21.1318 | 0.27 | 130.577 | 61.1116 | 9.61 | 60.8556 | 71.3033 | 60.2379 | 9.14 | 1.76996 | 129.48
S1 | Distribuïdor; Nau Lateral; Sala d'actes; Sala de reunions | Nau Lateral | 1.24425 | 99.8884 | 100.426 | 19.5247 | 0 | 1.71425 | 100.426 | 47.0214 | 11.0543 | 46.9475 | 47.2001 | 41.5419 | 10.5843 | 18.73 | 99.8884

# IfcBuildingElementProxy: Concrete 114 (2)
In: planta baixa
Classification: 30.20.10 Cobertes (GuBIMclass CA); Material: Concrete
ArchiCADProperties - Geometry Method: Single-plane; Pitch: -14.4 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: Cu1; Hotlink and Element ID: Cu1; Layer: 00_CLT; Building Material / Composite / Profile / Fill: Concrete; Building Material: Concrete; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Roof; Structure Type: Basic; Parent ID: Cu1; Building Materials (All): Concrete; Surfaces (All): Paint - Anthracite; Concrete - Bush hammered; Cover Fill: Roof Tile 01; Edge Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 107.AMB.NomTipus: Cu1_CobertaInclinadaR60; 109.AMB.CodiTipus: Cu1; 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: CobertaInclinadaR60
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.114459 m; Vertical Thickness: 0.118171 m; Height: 0.114459 m
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Component Quantities - Concrete, Component Thickness: 0.114459 m
5 AMB.Geometria - 503.AMB.Altura: 0.114459 m; 504.AMB.Gruix: 0.114459 m; 506.AMB.Profunditat: 0 m
Name | Concrete, Embodied Carbon | Concrete, Embodied Energy (MJ) | Surface Area of the Roof Bottom (Gross) (m2) = Surface Area of the Roof Top (Gross) (m2) = Surface Area of the Roof Bottom (Net) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Concrete, Mass (kg) | Concrete, Projected Component Area (Net) (m2) = Concrete, Projected Component Area (Gross) (m2) | Concrete, Component Volume (Net) (m3) = Concrete, Component Volume (Gross) (m3)
Cu1 | 2997.42 (kgCO₂) | 20729.8 | 135.97 | 6.67522 | 6.14098 | 15.481 | 6.32314 | 15.6631 | 4.70998 | 14.05 | 28013.3 | 136.656 | 15.5629
Cu1 | 2899.28 (kgCO₂) | 20051.1 | 131.518 | 6.43476 | 6.16548 | 15.5055 | 6.31815 | 15.6581 | 4.68118 | 14.0212 | 27096.1 | 132.174 | 15.0534

# IfcBuildingElementProxy: Concrete 15-10-15 (1) 400 (4)
In: planta baixa
Classification: Wall (ARCHICAD Classification); 30.10.10.10 Façanes in situ (GuBIMclass CA)
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Brick - Aged Natural; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F7; Hotlink and Element ID: F7; Layer: 00_MURO LADRILLO; Building Material / Composite / Profile / Fill: Concrete 15-10-15 (1); Composite Structure: Concrete 15-10-15 (1); Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Composite; Parent ID: F7; Building Materials (All): Brick; Insulation - Mineral Soft; Brick; Surfaces (All): Brick - Aged Natural; Insulation - Cellulose; Slant Angle: 90 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.10 Façanes in situ; 104.AMB.ClassificacioCodi: 30.10.10.10; 105.AMB.ClassificacioDescripcio: Façanes in situ; 107.AMB.NomTipus: F7_Mur_400_Mao; 109.AMB.CodiTipus: F7; 111.AMB.DescripcioTipus: Mur de tancament de maó; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: Mur_400_Mao
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Minimum Height of the Wall: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0.15 m; Wall Component Thickness on the Outside Face: 0.15 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Analytic Volume of the Openings: 0 m3; End Thickness of the Wall: 0.4 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.4 m; Elevation to Project Zero: -0.28 m; Elevation to 1st Reference Level: -0.28 m; Elevation to 2nd Reference Level: -0.28 m; Elevation to Sea Level: 9.06 m; Elevation to Linked/Home Story: -0.28 m; Home Offset: -0.28 m; Top Offset: 0 m; Thickness: 0.4 m; Insulation Skin Thickness: 0.1 m; Bottom Elevation To First Reference Level: -0.28 m; Bottom Elevation To Home Story: -0.28 m; Bottom Elevation To Project Zero: -0.28 m; Bottom Elevation To Sea Level: 9.06 m; Bottom Elevation To Second Reference Level: -0.28 m
5 AMB.Geometria - 502.AMB.Amplada: 0.4 m; 504.AMB.Gruix: 0.4 m; 506.AMB.Profunditat: 0 m
Name | Maximum Height of the Wall Skin on the Inside Face (m) = Maximum Height of the Wall (m) = Maximum Height of the Wall Skin on the Outside Face (m) = Height (m) = 503.AMB.Altura (m) | Minimum Height of the Wall Skin on the Inside Face (m) = Minimum Height of the Wall Skin on the Outside Face (m) | Wall Component Volume on the Inside Face (Net) (m3) = Volume of the Wall Inside Face Component (Conditional) (m3) | Wall Component Volume on the Outside Face (Net) (m3) = Volume of the Wall Outside Face Component (Conditional) (m3) | Average length of the Wall (m) = Length of the Wall Inside Face (Conditional) (m) = Length of the Wall at the Center (m) = Length of the Wall on the Inside Face (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Length of Reference Line (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) = 501.AMB.Longitud (m) | Surface Area of the Wall Inside Face (Gross) (m2) = Surface Area of the Wall Outside Face (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) = Volume (Conditional) (m3) | 3D Length (m) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2)
F7 | 5.73834 | 0 | 0.174324 | 0.174324 | 0.2 | 1.16216 | 1.16216 | 0.2 | 6.07218 | 0.304 | 0.464864 | 0.76 | 2.42887 | 1.2 | 5.45834 | 14.7983 | 0.16
F7 | 5.73834 | 1.33227e-15 | 0.174824 | 0.174824 | 0.200186 | 1.16549 | 1.16549 | 0.200186 | 6.09053 | 0.304074 | 0.466198 | 0.760186 | 2.43621 | 1.20037 | 5.45834 | 14.7983 | 0.160074
F7 | 6.45647 | 0 | 0.211382 | 0.211377 | 0.199185 | 1.40921 | 1.40922 | 0.199186 | 4.80924 | 0.303674 | 0.563681 | 0.759186 | 1.9237 | 1.19837 | 6.17647 | 15.5165 | 2.62191
F7 | 6.46104 | 0 | 0.193945 | 0.193945 | 0.2 | 1.29296 | 1.29296 | 0.2 | 6.99745 | 0.304 | 0.517186 | 0.76 | 2.79898 | 1.2 | 6.18104 | 15.521 | 0.16

# IfcBuildingElementProxy: Concrete 15-10-15 400 (6)
In: planta baixa
Classification: 20.20.10.30 Murs estructurals (GuBIMclass CA)
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Concrete - Bush hammered; Outside Face Surface: Concrete - Bush hammered; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F2; Hotlink and Element ID: F2; Layer: 00_MURO HORMIGON; Building Material / Composite / Profile / Fill: Concrete 15-10-15; Composite Structure: Concrete 15-10-15; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Composite; Parent ID: F2; Building Materials (All): Concrete - Structural; Insulation - Mineral Soft; Concrete - Structural; Surfaces (All): Insulation - Cellulose; Concrete - Bush hammered; Slant Angle: 90 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 20.20.10.30 Murs estructurals; 104.AMB.ClassificacioCodi: 20.20.10.30; 105.AMB.ClassificacioDescripcio: Murs estructurals; 107.AMB.NomTipus: F2_Mur_400_Formigo; 109.AMB.CodiTipus: F2; 111.AMB.DescripcioTipus: Mur de formigó armat vist amb 20% d'arids reciclats de maó; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: Si
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 20; AUX_107.NomTipus: Mur_400_Formigo
Pset_BuildingElementProxyCommon - Status: NEW
5 AMB.Geometria - 502.AMB.Amplada: 0.4 m; 504.AMB.Gruix: 0.4 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 4.28 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Wall Component Thickness on the Inside Face: 0.15 m; Wall Component Thickness on the Outside Face: 0.15 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; End Thickness of the Wall: 0.4 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.4 m; Elevation to Project Zero: -0.28 m; Elevation to 1st Reference Level: -0.28 m; Elevation to 2nd Reference Level: -0.28 m; Elevation to Sea Level: 9.06 m; Elevation to Linked/Home Story: -0.28 m; Home Offset: -0.28 m; Top Offset: 0 m; Thickness: 0.4 m; Insulation Skin Thickness: 0.1 m; Bottom Elevation To First Reference Level: -0.28 m; Bottom Elevation To Home Story: -0.28 m; Bottom Elevation To Project Zero: -0.28 m; Bottom Elevation To Sea Level: 9.06 m; Bottom Elevation To Second Reference Level: -0.28 m
Name | Colliding Zones | Edge Surface | 501.AMB.Longitud (m) = Length of Reference Line (m) = Length of the Wall Outside Face (Conditional) (m) = Length of the Wall on the Outside Face (m) | 503.AMB.Altura (m) = Height (m) | Number of Doors | Maximum Height of the Wall (m) = Maximum Height of the Wall Skin on the Outside Face (m) | Area of the Doors (m2) | Combined Width of Doors (m) | Wall Component Volume on the Inside Face (Net) (m3) | Wall Component Volume on the Outside Face (Net) (m3) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of the Wall Inside Face (Conditional) (m) = Length of the Wall on the Inside Face (m) | Volume of the Wall Inside Face Component (Conditional) (m3) | Volume of the Wall Outside Face Component (Conditional) (m3) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Area (m2) = Top Surface Area (Net) (m2) | Volume (Net) (m3) | 3D Length (m) | Volume (Conditional) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2)
F2 | Nau Santa Eulàlia | Concrete - Bush hammered | 0.776666 | 4.78 | 0 | 4.78 | 0 | 0 | 0.229615 | 0.416108 | 0 | 0 | 0.565041 | 1.51262 | 2.79432 | 0 | 0.353416 | 0.229615 | 0.416108 | 3.60438 | 3.71246 | 0.198472 | 0.869575 | 0.626426 | 0.869575 | 1.46337 | 2.11244 | 4.5 | 13.84 | 1.9438
F2 | Nau Santa Eulàlia |  | 7.96412 | 4.78 | 1 | 4.78 | 6.24 | 2.4 | 3.68216 | 4.71175 | 6.6 | 6.648 | 7.5595 | 24.5417 | 31.4205 | 2.652 | 7.15488 | 4.67216 | 5.70895 | 38.0215 | 38.0685 | 3.09282 | 11.2414 | 7.97259 | 11.2414 | 15.218 | 16.2575 | 4.5 | 13.84 | 4.27269
F2 | Nau Santa Eulàlia |  | 7.87249 | 4.78 | 1 | 4.78 | 5.2 | 2 | 3.80572 | 4.71456 | 5.5 | 5.51366 | 7.47534 | 25.3775 | 31.4129 | 2.2 | 7.07819 | 4.63072 | 5.53956 | 37.6512 | 37.6305 | 3.0588 | 11.3736 | 7.88377 | 13.5736 | 15.0563 | 16.0786 | 4.5 | 13.84 | 4.2255
F2 | Nau Santa Eulàlia; Vestíbul | Concrete - Bush hammered | 0.8 | 4.78 | 0 | 4.28 | 0 | 0 | 0.240436 | 0.41342 | 0 | 0 | 0.58445 | 1.46084 | 2.78019 | 0 | 0.3689 | 0.240436 | 0.41342 | 3.68069 | 3.824 | 0.206202 | 0.882541 | 0.649678 | 0.882541 | 1.50094 | 2.15706 | 4 | 13.34 | 0.206202
F2 | Nau Santa Eulàlia | Concrete - Bush hammered | 0.799958 | 4.28 | 0 | 4.28 | 0 | 0 | 0.271892 | 0.420663 | 0 | 0 | 0.614602 | 1.69982 | 2.78001 | 0 | 0.429247 | 0.271892 | 0.420663 | 3.55401 | 3.42382 | 0.218263 | 0.934144 | 0.661156 | 0.934144 | 1.39557 | 2.17481 | 4 | 13.34 | 0.436527
F2 | Nau Santa Eulàlia | Concrete - Bush hammered | 0.8 | 4.28 | 0 | 4.28 | 0 | 0 | 0.268183 | 0.419868 | 0 | 0 | 0.610985 | 1.80603 | 2.78098 | 0 | 0.42197 | 0.268183 | 0.419868 | 3.52076 | 3.424 | 0.21685 | 0.928118 | 0.658239 | 0.928118 | 1.38895 | 2.17234 | 4 | 13.34 | 2.1457

# IfcBuildingElementProxy: Concrete 18 (1) 140 (5)
In: planta baixa
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Center; Inside Face Surface: Wood - Pine Grained Horizontal blank; Outside Face Surface: Wood - Pine Grained Horizontal blank; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Layer: 00_TABIQUE; Building Material / Composite / Profile / Fill: Concrete 18 (1); Composite Structure: Concrete 18 (1); Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Composite; Building Materials (All): Gypsum Plasterboard; Insulation - Mineral Soft; Gypsum Plasterboard; Surfaces (All): Paint - Anthracite; Insulation - Cellulose; Wood - Pine Grained Horizontal blank; Slant Angle: 90 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 111.AMB.DescripcioTipus: Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40; AUX_107.NomTipus: Enva_140
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Air Skin Thickness: 0 m; Wall Component Thickness on the Inside Face: 0.03 m; Wall Component Thickness on the Outside Face: 0.03 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; End Thickness of the Wall: 0.14 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.14 m; Top Offset: 0 m; Thickness: 0.14 m; Insulation Skin Thickness: 0.08 m
5 AMB.Geometria - 502.AMB.Amplada: 0.14 m; 504.AMB.Gruix: 0.14 m; 506.AMB.Profunditat: 0 m
Name | Classification | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Colliding Zones | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | Number of Doors | Maximum Height of the Wall Skin on the Inside Face (m) = Maximum Height of the Wall (m) | Minimum Height of the Wall Skin on the Inside Face (m) = Minimum Height of the Wall (m) = Minimum Height of the Wall Skin on the Outside Face (m) | Maximum Height of the Wall Skin on the Outside Face (m) | Area of the Doors (m2) = Analytic Surface Area of Openings on the Inside Face (m2) = Analytic Surface Area of Openings on the Outside Face (m2) | Combined Width of Doors (m) | Wall Component Volume on the Inside Face (Net) (m3) | Wall Component Volume on the Outside Face (Net) (m3) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Length of the Wall Outside Face (Conditional) (m) | Volume of the Wall Inside Face Component (Conditional) (m3) | Volume of the Wall Outside Face Component (Conditional) (m3) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) = 3D Length (m) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | Volume (Conditional) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Edge Surface Area (Net) (m2)
T5 | Wall (ARCHICAD Classification); 40.10.10 Compartimentació interior vertical (GuBIMclass CA) | T5 | Lavabo; Nau Santa Eulàlia | 40.10.10 Compartimentació interior vertical | 40.10.10 | Compartimentació interior vertical | T5_Enva_140 | 1 | 3.69645 | 2.6 | 3.69645 | 2.08 | 0.8 | 0.138736 | 0.138736 | 1.87434 | 4.62454 | 4.62454 | 0.383077 | 1.94434 | 1.07434 | 1.07434 | 0.201136 | 0.201136 | 7.08325 | 7.08325 | 1.87434 | 1.87434 | 0.114658 | 5.003 | 0.555558 | 0.27 | 9.61 | 0.938636 | 0.991655 | 4.02869 | 3.96645 | 13.3064 | 0.27 | 9.61 | 0.869618
T3 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | T3 | Nau Santa Eulàlia; Office | 40.10.10.10 Envans | 40.10.10.10 | Envans | T3_Enva_140 | 1 | 3.69645 | 0 | 3.69645 | 2.08 | 0.8 | 0.138819 | 0.138826 | 1.87822 | 4.62726 | 4.62758 | 0.383078 | 1.94822 | 1.07817 | 1.07828 | 0.201219 | 0.201226 | 7.09696 | 7.09728 | 1.87817 | 1.87828 | 0.115201 | 5.003 | 0.555962 | 0.27 | 9.61 | 0.939039 | 0.993597 | 4.03644 | 3.96645 | 13.3064 | 0.27 | 9.61 | 0.382225
T3 | 40.10.10.10 Envans (GuBIMclass CA) | T3 | Nau Santa Eulàlia | 40.10.10.10 Envans | 40.10.10.10 | Envans | T3_Enva_140 | 1 | 4.56578 | 4.04204 | 4.56577 | 2.08 | 0.8 | 0.202895 | 0.202895 | 2.05469 | 6.76318 | 6.76317 | 0.2912 | 2.05469 | 1.25469 | 1.25469 | 0.265295 | 0.265295 | 8.84318 | 8.84317 | 2.05469 | 2.05469 | 0.175656 | 5.3 | 0.946845 | 0.27 | 9.61 | 1.23804 | 1.23804 | 4.38937 | 4.83578 | 14.1758 | 0.27 | 9.61 | 1.6776
Te1 | Wall (ARCHICAD Classification); 40.10.10 Compartimentació interior vertical (GuBIMclass CA) | Te1 | Lavabo; Nau Santa Eulàlia | 40.10.10 Compartimentació interior vertical | 40.10.10 | Compartimentació interior vertical | Te1_Enva_140 | 0 | 1.51399 | 0.886896 | 1.51399 | 0 | 0 | 0.0341971 | 0.0341971 | 1.07411 | 1.1399 | 1.1399 | 0 | 1.07411 | 1.07411 | 1.07411 | 0.0341971 | 0.0341971 | 1.62619 | 1.62619 | 1.07411 | 1.07411 | 0.150375 | 1.51399 | 0.159587 | 2.47 | 11.81 | 0.159587 | 0.227667 | 2.42822 | 3.98399 | 13.324 | 2.47 | 11.81 | 0.479556
T1 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | T1 | Nau Santa Eulàlia; Office; Rack | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | 1 | 3.32145 | 2.6 | 3.32145 | 2.08 | 0.8 | 0.115373 | 0.115373 | 1.84974 | 3.84577 | 3.84577 | 0.2912 | 1.91974 | 1.84974 | 1.84974 | 0.177773 | 0.177773 | 6.98678 | 6.98678 | 1.84974 | 1.84974 | 0.146963 | 5.3 | 0.538408 | -0.027 | 9.313 | 0.829608 | 0.978149 | 3.97948 | 3.59145 | 12.9314 | 0.27 | 9.61 | 0.431838

# IfcBuildingElementProxy: Concrete 18 (5) 110 (12)
In: planta baixa
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Insulation - Cellulose; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Layer: 00_TABIQUE; Building Material / Composite / Profile / Fill: Concrete 18 (5); Composite Structure: Concrete 18 (5); Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Composite; Building Materials (All): Gypsum Plasterboard; Insulation - Mineral Soft; Slant Angle: 90 deg; Number of Openings: 0; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 111.AMB.DescripcioTipus: Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40; AUX_107.NomTipus: Enva_140
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Air Skin Thickness: 0 m; Wall Component Thickness on the Inside Face: 0.08 m; Wall Component Thickness on the Outside Face: 0.03 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; End Thickness of the Wall: 0.11 m; Surface Area of Empty Openings in the Wall: 0 m2; Width: 0.11 m; Top Offset: 0 m; Thickness: 0.11 m; Insulation Skin Thickness: 0.08 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11 m; 504.AMB.Gruix: 0.11 m; 506.AMB.Profunditat: 0 m
Name | Classification | Outside Face Surface | Element ID = Hotlink and Element ID = Parent ID | Colliding Zones | Surfaces (All) | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 109.AMB.CodiTipus | Number of Doors | Maximum Height of the Wall Skin on the Inside Face (m) | Minimum Height of the Wall Skin on the Inside Face (m) = Minimum Height of the Wall (m) | Maximum Height of the Wall (m) = Maximum Height of the Wall Skin on the Outside Face (m) | Minimum Height of the Wall Skin on the Outside Face (m) | Area of the Doors (m2) = Analytic Surface Area of Openings on the Inside Face (m2) = Analytic Surface Area of Openings on the Outside Face (m2) | Combined Width of Doors (m) | Wall Component Volume on the Inside Face (Net) (m3) | Wall Component Volume on the Outside Face (Net) (m3) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) = Surface Area of the Wall Inside Face (Conditional) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area of the Wall Outside Face (Conditional) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Length of the Wall Outside Face (Conditional) (m) | Volume of the Wall Inside Face Component (Conditional) (m3) | Volume of the Wall Outside Face Component (Conditional) (m3) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | 3D Length (m) | Volume (Conditional) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Edge Surface Area (Net) (m2)
T3 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Tiles - Terracota Arena 10x20 | T3 | Nau Santa Eulàlia | Insulation - Cellulose; Wood - Pine Grained Horizontal blank; Tiles - Terracota Arena 10x20 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | T1 | 0 | 2.2 | 0 | 2.2 | 0 | 0 | 0 | 0.224247 | 0.0842989 | 1.31613 | 2.73856 | 2.83416 | 0 | 1.32373 | 1.344 | 1.28825 | 0.224247 | 0.0842989 | 2.9568 | 3.13424 | 1.344 | 1.28825 | 0.140248 | 2.2 | 0.308545 | 0.27 | 9.61 | 1.30346 | 0.308545 | 0.335007 | 2.86557 | 2.47 | 11.81 | 0.522496
T3 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Tiles - Terracota Arena 10x20 | T3 | Nau Santa Eulàlia | Insulation - Cellulose; Wood - Pine Grained Horizontal blank; Tiles - Terracota Arena 10x20 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | T1 | 0 | 2.2 | 0 | 2.2 | 0 | 0 | 0 | 0.21742 | 0.0767151 | 1.20908 | 2.62547 | 2.59177 | 0 | 1.22768 | 1.27728 | 1.14088 | 0.21742 | 0.0767151 | 2.81001 | 3.06376 | 1.27728 | 1.14088 | 0.133698 | 2.2 | 0.294135 | 0.27 | 9.61 | 1.27728 | 0.294135 | 0.323058 | 2.67788 | 2.47 | 11.81 | 0.267395
T3 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Tiles - Terracota Arena 10x20 | T3 | Nau Santa Eulàlia | Insulation - Cellulose; Wood - Pine Grained Horizontal blank; Tiles - Terracota Arena 10x20 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | T1 | 0 | 2.2 | 0 | 2.2 | 0 | 0 | 0 | 0.237882 | 0.087265 | 1.3358 | 2.94573 | 2.91924 | 0 | 1.3468 | 1.37613 | 1.29547 | 0.237882 | 0.087265 | 3.02748 | 3.10378 | 1.37613 | 1.29547 | 0.147794 | 2.2 | 0.325147 | 0.27 | 9.61 | 1.40135 | 0.325147 | 0.337219 | 2.918 | 2.47 | 11.81 | 0.537588
T3 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Tiles - Terracota Arena 10x20 | T3 | Nau Santa Eulàlia | Insulation - Cellulose; Wood - Pine Grained Horizontal blank; Tiles - Terracota Arena 10x20 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T3_Enva_140 | T3 | 0 | 2.2 | 0 | 2.2 | 0 | 0 | 0 | 0.217489 | 0.0767411 | 1.20947 | 2.62634 | 2.59264 | 0 | 1.22807 | 1.27767 | 1.14127 | 0.217489 | 0.0767411 | 2.81088 | 3.06462 | 1.27767 | 1.14127 | 0.133741 | 2.2 | 0.29423 | 0.27 | 9.61 | 1.27767 | 0.29423 | 0.323153 | 2.67866 | 2.47 | 11.81 | 0.267482
T3 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Tiles - Terracota Arena 10x20 | T3 | Nau Santa Eulàlia | Insulation - Cellulose; Wood - Pine Grained Horizontal blank; Tiles - Terracota Arena 10x20 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T3_Enva_140 | T3 | 0 | 2.2 | 0 | 2.2 | 0 | 0 | 0 | 0.168893 | 0.0635414 | 1.00162 | 2.04664 | 2.14224 | 0 | 1.00922 | 1.02949 | 0.973747 | 0.168893 | 0.0635414 | 2.26488 | 2.44233 | 1.02949 | 0.973747 | 0.105652 | 2.2 | 0.232435 | 0.27 | 9.61 | 0.988951 | 0.232435 | 0.258897 | 2.23656 | 2.47 | 11.81 | 0.453304
T3 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Tiles - Terracota Arena 10x20 | T3 | Nau Santa Eulàlia | Insulation - Cellulose; Wood - Pine Grained Horizontal blank; Tiles - Terracota Arena 10x20 | 40.10.10.10 Envans | 40.10.10.10 | Envans | T3_Enva_140 | T3 | 0 | 2.2 | 0 | 2.2 | 0 | 0 | 0 | 0.237868 | 0.087265 | 1.3358 | 2.9456 | 2.91924 | 0 | 1.3468 | 1.37613 | 1.29547 | 0.237868 | 0.087265 | 3.02748 | 3.10378 | 1.37613 | 1.29547 | 0.147788 | 2.2 | 0.325133 | 0.27 | 9.61 | 1.40135 | 0.325133 | 0.337219 | 2.918 | 2.47 | 11.81 | 0.537575
T3 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia; Neteja | Paint - Anthracite; Insulation - Cellulose; Wood - Pine Grained Horizontal blank | 40.10.10.10 Envans | 40.10.10.10 | Envans | T1_Enva_140 | T1 | 1 | 3.45275 | 3.43236 | 5.003 | 3.45275 | 2.08 | 0.8 | 0.483797 | 0.217048 | 2.69449 | 7.16846 | 7.24693 | 0.320678 | 2.69449 | 1.89449 | 1.89449 | 0.742075 | 0.279448 | 13.4805 | 13.4805 | 2.69449 | 2.69449 | 0.172644 | 5.003 | 0.700845 | 0.27 | 9.61 | 2.69449 | 1.02152 | 1.48286 | 5.60898 | 5.273 | 14.613 | 0.969787
T3 | Wall (ARCHICAD Classification); 40.10.10 Compartimentació interior vertical (GuBIMclass CA) | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Paint - Anthracite; Insulation - Cellulose; Wood - Pine Grained Horizontal blank | 40.10.10 Compartimentació interior vertical | 40.10.10 | Compartimentació interior vertical | T3_Enva_140 | T3 | 0 | 1.49492 | 0 | 1.49492 | 0 | 0 | 0 | 0.125164 | 0.0466167 | 1.22768 | 1.53926 | 1.56339 | 0 | 1.22768 | 1.22768 | 1.22768 | 0.125162 | 0.0466167 | 1.93569 | 1.9891 | 1.22768 | 1.22768 | 0.130008 | 1.53992 | 0.171779 | 2.47 | 11.81 | 1.19836 | 0.171779 | 0.215864 | 2.67536 | 3.96492 | 13.3049 | 0.261988
T3 | Wall (ARCHICAD Classification); 40.10.10 Compartimentació interior vertical (GuBIMclass CA) | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Paint - Anthracite; Insulation - Cellulose; Wood - Pine Grained Horizontal blank | 40.10.10 Compartimentació interior vertical | 40.10.10 | Compartimentació interior vertical | T3_Enva_140 | T3 | 0 | 1.53992 | 0 | 1.53992 | 0 | 0 | 0 | 0.146027 | 0.0520986 | 1.3468 | 1.80989 | 1.74615 | 0 | 1.3468 | 1.3468 | 1.3468 | 0.146028 | 0.0520968 | 2.11912 | 2.17253 | 1.3468 | 1.3468 | 0.150765 | 1.53992 | 0.198124 | 2.47 | 11.81 | 1.40135 | 0.198124 | 0.236041 | 2.91359 | 4.00992 | 13.3499 | 0.329026
T1 | Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA) | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Paint - Anthracite; Insulation - Cellulose; Wood - Pine Grained Horizontal blank | 40.10.10.10 Envans | 40.10.10.10 | Envans | T3_Enva_140 | T3 | 1 | 3.4532 | 3.43281 | 3.46085 | 3.4532 | 2.08 | 0.8 | 0.77503 | 0.292074 | 3.41791 | 9.65303 | 9.74886 | 0.2288 | 3.41791 | 2.61791 | 2.61791 | 0.94143 | 0.354474 | 17.0998 | 17.0998 | 3.41791 | 3.41791 | 0.28797 | 5.003 | 1.0671 | 0.27 | 9.61 | 3.41791 | 1.2959 | 1.88098 | 7.05582 | 3.73085 | 13.0708 | 1.04627
T3 | Wall (ARCHICAD Classification); 40.10.10 Compartimentació interior vertical (GuBIMclass CA) | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Paint - Anthracite; Insulation - Cellulose; Wood - Pine Grained Horizontal blank | 40.10.10 Compartimentació interior vertical | 40.10.10 | Compartimentació interior vertical | T3_Enva_140 | T3 | 0 | 2.31898 | 0 | 2.31898 | 0 | 0 | 0 | 0.16128 | 0.0566394 | 1.3468 | 2.02157 | 1.89628 | 0 | 1.3468 | 1.3468 | 1.3468 | 0.16128 | 0.0566394 | 3.19121 | 3.27164 | 1.3468 | 1.3468 | 0.150765 | 2.31898 | 0.21792 | 2.47 | 11.81 | 1.40135 | 0.21792 | 0.355457 | 2.91359 | 4.78898 | 14.129 | 0.418395
T3 | Wall (ARCHICAD Classification); 40.10.10 Compartimentació interior vertical (GuBIMclass CA) | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Paint - Anthracite; Insulation - Cellulose; Wood - Pine Grained Horizontal blank | 40.10.10 Compartimentació interior vertical | 40.10.10 | Compartimentació interior vertical | T3_Enva_140 | T3 | 0 | 1.49545 | 0 | 1.49545 | 0 | 0 | 0 | 0.12952 | 0.0482317 | 1.22807 | 1.59316 | 1.61744 | 0 | 1.22807 | 1.22807 | 1.22807 | 0.12952 | 0.0482317 | 3.5103 | 3.59073 | 1.22807 | 1.22807 | 0.130051 | 2.803 | 0.177751 | 2.47 | 11.81 | 1.19874 | 0.177751 | 0.390557 | 2.67614 | 3.96545 | 13.3054 | 0.26703

# IfcBuildingElementProxy: Concrete 20-10-20 (1) 500, Cu2
In: planta coberta
Classification: 30.20.10 Cobertes (GuBIMclass CA)
5 AMB.Geometria - 503.AMB.Altura: 0.5 m; 504.AMB.Gruix: 0.5 m; 506.AMB.Profunditat: 0 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: CobertaTransitable
ArchiCADQuantities - Elevation Bottom: 4 m; Surface Area of the Slab Top (Conditional): 37.8933 m2; Surface Area of the Slab Bottom (Gross): 40.6204 m2; Surface Area of the Slab Bottom (Gross, with holes): 39.8336 m2; Surface Area of the Slab Edges (Gross): 13.2499 m2; Surface Area of the Slab Edges (Gross, with holes): 14.8233 m2; Surface Area of the Slab Top (Gross): 40.6204 m2; Surface Area of the Slab Top (Gross, with holes): 39.8336 m2; Holes Surface Area: 3.51382 m2; Elevation Top: 4.5 m; Area: 37.1066 m2; Height: 0.5 m; Volume (Net): 18.1805 m3; Elevation to Project Zero: 4.5 m; Elevation to 1st Reference Level: 4.5 m; Elevation to 2nd Reference Level: 4.5 m; Elevation to Sea Level: 13.84 m; Elevation to Linked/Home Story: -6.21725e-15 m; Home Offset: -6.21725e-15 m; Surface Area: 37.1066 m2; Thickness: 0.5 m; Volume (Conditional): 18.5738 m3; Volume (Gross): 20.3102 m3; Floor Plan Perimeter: 29.6413 m; Floor Plan Holes Perimeter: 3.14159 m; Top Elevation To First Reference Level: 4.5 m; Top Elevation To Home Story: 0 m; Top Elevation To Project Zero: 4.5 m; Top Elevation To Sea Level: 13.84 m; Top Elevation To Second Reference Level: 4.5 m; Bottom Elevation To First Reference Level: 4 m; Bottom Elevation To Home Story: -0.5 m; Bottom Elevation To Project Zero: 4 m; Bottom Elevation To Sea Level: 13.34 m; Bottom Elevation To Second Reference Level: 4 m; Top Surface Area (Net): 37.1066 m2; Top Surface Area (Conditional): 37.8933 m2; Edge Surface Area (Net): 6.23685 m2; Bottom Surface Area (Net): 35.8638 m2; Bottom Surface Area (Conditional): 36.6506 m2; Bottom Surface Area (Gross): 40.6204 m2; Edge Surface Area (Gross): 13.2499 m2; Top Surface Area (Gross): 40.6204 m2
Pset_BuildingElementProxyCommon - Status: NEW
1 AMB.Identificacio - 103.AMB.Classificacio: 30.20.10 Cobertes; 104.AMB.ClassificacioCodi: 30.20.10; 105.AMB.ClassificacioDescripcio: Cobertes; 107.AMB.NomTipus: Cu2_CobertaTransitable; 109.AMB.CodiTipus: Cu2; 111.AMB.DescripcioTipus: Sistema de coberta amb doble impermeabilització i paviment de terracota sobre aïllament XPS; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
ArchiCADProperties - Reference Plane Location: Top; Element ID: Cu2; Hotlink and Element ID: Cu2; Layer: 00_PAVIMENTOS; Building Material / Composite / Profile / Fill: Concrete 20-10-20 (1); Composite Structure: Concrete 20-10-20 (1); Colliding Zones: Espai públic; Nau Santa Eulàlia; Vestíbul; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Slab; Structure Type: Composite; Parent ID: Cu2; Building Materials (All): Tile - Wall; Concrete; Insulation - Mineral Soft; Concrete; Concrete - Structural; Surfaces (All): Tiles - White Matte 15x15; Insulation - Cellulose; Tiles - Red 30x30; Concrete - Bush hammered; Cover Fill: Grid 20x20; Number of Openings: 0; Top Surface: Tiles - Red 30x30; Bottom Surface: Concrete - Bush hammered; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Concrete 20-5-5 300, S2
In: planta baixa
Classification: 40.20.20.20 Paviments (GuBIMclass CA)
