Properties of the parts of a building model (IFC2X3), part 79 of 99

# IfcBuildingElementProxy: Rhino_Object_230, Object_230
Component Quantities - Component, Component Volume (Net): 0.0152724 m3; Component, Component Volume (Gross): 0.0152724 m3

# IfcBuildingElementProxy: Rhino_Object_231, Object_231
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_231; Hotlink and Element ID: Object_231; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_231; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_231; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_231 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_231_; 109.AMB.CodiTipus: Object_231; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152724 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.693129 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426578 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693129 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0152724 m3; Component, Component Volume (Gross): 0.0152724 m3
AC_Equantity_Rhino_Object_231 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -1.77636e-15 m; Top Level: 1.11675 m

# IfcBuildingElementProxy: Rhino_Object_232, Object_232
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_232; Hotlink and Element ID: Object_232; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_232; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_232; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_232 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_232_; 109.AMB.CodiTipus: Object_232; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152724 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.693129 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426575 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693129 m2
AC_Equantity_Rhino_Object_232 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -1.77636e-15 m; Top Level: 1.11675 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0152724 m3; Component, Component Volume (Gross): 0.0152724 m3

# IfcBuildingElementProxy: Rhino_Object_233, Object_233
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_233 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_233; Hotlink and Element ID: Object_233; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_233; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_233; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_233_; 109.AMB.CodiTipus: Object_233; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.346573 m; Area: 0.028024 m2; Height: 1.11675 m; Volume (Net): 0.0152724 m3; Width: 0.0808603 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.693129 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426582 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.028024 m2; Bottom Surface Area (Net): 0.693129 m2
AC_Equantity_Rhino_Object_233 - Dimension 1: 0.346573 m; Dimension 2: 0.0808603 m; Height: 1.11675 m; Bottom Level: -1.77636e-15 m; Top Level: 1.11675 m
Component Quantities - Component, Component Volume (Net): 0.0152724 m3; Component, Component Volume (Gross): 0.0152724 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0808603 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_234, Object_234
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.474 deg; Surface: Brick - Aged Natural; Element ID: Object_234; Hotlink and Element ID: Object_234; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_234; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_234; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_234_; 109.AMB.CodiTipus: Object_234; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_234 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.348867 m; Area: 0.0282585 m2; Height: 1.11675 m; Volume (Net): 0.0130788 m3; Width: 0.0810007 m; Elevation to Project Zero: 4.53906 m; Elevation to 1st Reference Level: 4.53906 m; Elevation to 2nd Reference Level: 4.53906 m; Elevation to Sea Level: 13.8791 m; Elevation to Linked/Home Story: 4.53906 m; Home Offset: 4.53906 m; Surface Area: 0.605393 m2; Top Elevation To First Reference Level: 5.65582 m; Top Elevation To Home Story: 5.65582 m; Top Elevation To Project Zero: 5.65582 m; Top Elevation To Sea Level: 14.9958 m; Top Elevation To Second Reference Level: 5.65582 m; Bottom Elevation To First Reference Level: 4.53906 m; Bottom Elevation To Home Story: 4.53906 m; Bottom Elevation To Project Zero: 4.53906 m; Bottom Elevation To Sea Level: 13.8791 m; Bottom Elevation To Second Reference Level: 4.53906 m; Survey Coordinate X: 426581 m; Survey Coordinate Y: 4579791 m; Survey Coordinate Z: 13.8791 m; Top Surface Area (Net): 0.0282585 m2; Bottom Surface Area (Net): 0.605393 m2
AC_Equantity_Rhino_Object_234 - Dimension 1: 0.348867 m; Dimension 2: 0.0810007 m; Height: 1.11675 m; Bottom Level: -1.77636e-15 m; Top Level: 1.11675 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Component Quantities - Component, Component Volume (Net): 0.0130788 m3; Component, Component Volume (Gross): 0.0130788 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0810007 m; 503.AMB.Altura: 1.11675 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_2973, Object_2973
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.275 deg; Surface: Brick - Aged Natural; Element ID: Object_2973; Hotlink and Element ID: Object_2973; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_2973; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_2973; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_2973 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 7; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_2973_; 109.AMB.CodiTipus: Object_2973; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_2973 - Dimension 1: 0.146547 m; Dimension 2: 2.24656 m; Height: 0.405923 m; Bottom Level: 0 m; Top Level: 0.405923 m
5 AMB.Geometria - 502.AMB.Amplada: 2.24656 m; 503.AMB.Altura: 0.405923 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0134029 m3; Component, Component Volume (Gross): 0.0134029 m3
ArchiCADQuantities - Length (A): 0.146547 m; Area: 0.329228 m2; Height: 0.405923 m; Volume (Net): 0.0134029 m3; Width: 2.24656 m; Elevation to Project Zero: 3.60968 m; Elevation to 1st Reference Level: 3.60968 m; Elevation to 2nd Reference Level: 3.60968 m; Elevation to Sea Level: 12.9497 m; Elevation to Linked/Home Story: 3.60968 m; Home Offset: 3.60968 m; Surface Area: 0.721242 m2; Top Elevation To First Reference Level: 3.83882 m; Top Elevation To Home Story: 3.83882 m; Top Elevation To Project Zero: 3.83882 m; Top Elevation To Sea Level: 13.1788 m; Top Elevation To Second Reference Level: 3.83882 m; Bottom Elevation To First Reference Level: 3.60968 m; Bottom Elevation To Home Story: 3.60968 m; Bottom Elevation To Project Zero: 3.60968 m; Bottom Elevation To Sea Level: 12.9497 m; Bottom Elevation To Second Reference Level: 3.60968 m; Survey Coordinate X: 426560 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 12.9497 m; Top Surface Area (Net): 0.329228 m2; Bottom Surface Area (Net): 0.721242 m2

# IfcBuildingElementProxy: Rhino_Object_2974, Object_2974
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.275 deg; Surface: Brick - Aged Natural; Element ID: Object_2974; Hotlink and Element ID: Object_2974; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_2974; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_2974; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_2974 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 7; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_2974_; 109.AMB.CodiTipus: Object_2974; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.17805 m; Area: 0.410813 m2; Height: 0.370731 m; Volume (Net): 0.00846181 m3; Width: 2.3073 m; Elevation to Project Zero: 3.67468 m; Elevation to 1st Reference Level: 3.67468 m; Elevation to 2nd Reference Level: 3.67468 m; Elevation to Sea Level: 13.0147 m; Elevation to Linked/Home Story: 3.67468 m; Home Offset: 3.67468 m; Surface Area: 0.711445 m2; Top Elevation To First Reference Level: 3.86882 m; Top Elevation To Home Story: 3.86882 m; Top Elevation To Project Zero: 3.86882 m; Top Elevation To Sea Level: 13.2088 m; Top Elevation To Second Reference Level: 3.86882 m; Bottom Elevation To First Reference Level: 3.67468 m; Bottom Elevation To Home Story: 3.67468 m; Bottom Elevation To Project Zero: 3.67468 m; Bottom Elevation To Sea Level: 13.0147 m; Bottom Elevation To Second Reference Level: 3.67468 m; Survey Coordinate X: 426560 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 13.0147 m; Top Surface Area (Net): 0.410813 m2; Bottom Surface Area (Net): 0.711445 m2
AC_Equantity_Rhino_Object_2974 - Dimension 1: 0.17805 m; Dimension 2: 2.3073 m; Height: 0.370731 m; Bottom Level: 0 m; Top Level: 0.370731 m
5 AMB.Geometria - 502.AMB.Amplada: 2.3073 m; 503.AMB.Altura: 0.370731 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00846181 m3; Component, Component Volume (Gross): 0.00846181 m3

# IfcBuildingElementProxy: Rhino_Object_2975, Object_2975
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 15.2778 deg; Surface: Brick - Aged Natural; Element ID: Object_2975; Hotlink and Element ID: Object_2975; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_2975; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_2975; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_2975_; 109.AMB.CodiTipus: Object_2975; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_2975 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 7; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_2975 - Dimension 1: 0.113292 m; Dimension 2: 2.11632 m; Height: 3.84526 m; Bottom Level: -2.82885e-13 m; Top Level: 3.84526 m
5 AMB.Geometria - 502.AMB.Amplada: 2.11632 m; 503.AMB.Altura: 3.84526 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.103949 m3; Component, Component Volume (Gross): 0.103949 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.113292 m; Area: 0.239763 m2; Height: 3.84526 m; Volume (Net): 0.103949 m3; Width: 2.11632 m; Elevation to Project Zero: 0.105791 m; Elevation to 1st Reference Level: 0.105791 m; Elevation to 2nd Reference Level: 0.105791 m; Elevation to Sea Level: 9.44579 m; Elevation to Linked/Home Story: 0.105791 m; Home Offset: 0.105791 m; Surface Area: 4.62048 m2; Top Elevation To First Reference Level: 3.77382 m; Top Elevation To Home Story: 3.77382 m; Top Elevation To Project Zero: 3.77382 m; Top Elevation To Sea Level: 13.1138 m; Top Elevation To Second Reference Level: 3.77382 m; Bottom Elevation To First Reference Level: 0.105791 m; Bottom Elevation To Home Story: 0.105791 m; Bottom Elevation To Project Zero: 0.105791 m; Bottom Elevation To Sea Level: 9.44579 m; Bottom Elevation To Second Reference Level: 0.105791 m; Survey Coordinate X: 426560 m; Survey Coordinate Y: 4579786 m; Survey Coordinate Z: 9.44579 m; Top Surface Area (Net): 0.239763 m2; Bottom Surface Area (Net): 4.62048 m2

# IfcBuildingElementProxy: Rhino_Object_3348, Object_3348
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3348; Hotlink and Element ID: Object_3348; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_3348; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3348; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_3348 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3348_; 109.AMB.CodiTipus: Object_3348; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 1.98971 m; Area: 0.0994857 m2; Height: 1.41391 m; Volume (Net): 0.037587 m3; Width: 0.05 m; Elevation to Project Zero: 7.11375 m; Elevation to 1st Reference Level: 7.11375 m; Elevation to 2nd Reference Level: 7.11375 m; Elevation to Sea Level: 16.4538 m; Elevation to Linked/Home Story: 7.11375 m; Home Offset: 7.11375 m; Surface Area: 1.89271 m2; Top Elevation To First Reference Level: 8.52767 m; Top Elevation To Home Story: 8.52767 m; Top Elevation To Project Zero: 8.52767 m; Top Elevation To Sea Level: 17.8677 m; Top Elevation To Second Reference Level: 8.52767 m; Bottom Elevation To First Reference Level: 7.11375 m; Bottom Elevation To Home Story: 7.11375 m; Bottom Elevation To Project Zero: 7.11375 m; Bottom Elevation To Sea Level: 16.4538 m; Bottom Elevation To Second Reference Level: 7.11375 m; Survey Coordinate X: 426529 m; Survey Coordinate Y: 4579802 m; Survey Coordinate Z: 16.4538 m; Top Surface Area (Net): 0.0994857 m2; Bottom Surface Area (Net): 1.89271 m2
AC_Equantity_Rhino_Object_3348 - Dimension 1: 1.98971 m; Dimension 2: 0.05 m; Height: 1.41391 m; Bottom Level: 0 m; Top Level: 1.41391 m
5 AMB.Geometria - 502.AMB.Amplada: 0.05 m; 503.AMB.Altura: 1.41391 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.037587 m3; Component, Component Volume (Gross): 0.037587 m3

# IfcBuildingElementProxy: Rhino_Object_3349, Object_3349
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3349; Hotlink and Element ID: Object_3349; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_3349; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3349; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3349_; 109.AMB.CodiTipus: Object_3349; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 1.51482 m; Area: 0.0757409 m2; Height: 1.41791 m; Volume (Net): 0.0141224 m3; Width: 0.05 m; Elevation to Project Zero: 7.56157 m; Elevation to 1st Reference Level: 7.56157 m; Elevation to 2nd Reference Level: 7.56157 m; Elevation to Sea Level: 16.9016 m; Elevation to Linked/Home Story: 7.56157 m; Home Offset: 7.56157 m; Surface Area: 0.870118 m2; Top Elevation To First Reference Level: 8.22098 m; Top Elevation To Home Story: 8.22098 m; Top Elevation To Project Zero: 8.22098 m; Top Elevation To Sea Level: 17.561 m; Top Elevation To Second Reference Level: 8.22098 m; Bottom Elevation To First Reference Level: 7.32187 m; Bottom Elevation To Home Story: 7.32187 m; Bottom Elevation To Project Zero: 7.32187 m; Bottom Elevation To Sea Level: 16.6619 m; Bottom Elevation To Second Reference Level: 7.32187 m; Survey Coordinate X: 426531 m; Survey Coordinate Y: 4579803 m; Survey Coordinate Z: 16.9016 m; Top Surface Area (Net): 0.0757409 m2; Bottom Surface Area (Net): 0.870118 m2
AC_Equantity_Rhino_Object_3349 - Dimension 1: 1.51482 m; Dimension 2: 0.05 m; Height: 1.41791 m; Bottom Level: -0.499227 m; Top Level: 0.918688 m
5 AMB.Geometria - 502.AMB.Amplada: 0.05 m; 503.AMB.Altura: 1.41791 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0141224 m3; Component, Component Volume (Gross): 0.0141224 m3
AC_Pset_Rhino_Object_3349 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg

# IfcBuildingElementProxy: Rhino_Object_3521 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3521; Hotlink and Element ID: Object_3521; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_3521; Colliding Zones: Espai públic; Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3521; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3521 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3521_; 109.AMB.CodiTipus: Object_3521; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.29 m; Area: 0.0841 m2; Height: 4.31469 m; Volume (Net): 0.341723 m3; Width: 0.29 m; Surface Area: 5.16344 m2; Survey Coordinate X: 426533 m; Survey Coordinate Y: 4579794 m; Top Surface Area (Net): 0.0841 m2; Bottom Surface Area (Net): 5.16344 m2
AC_Equantity_Rhino_Object_3521 - Dimension 1: 0.29 m; Dimension 2: 0.29 m; Height: 4.31469 m; Bottom Level: 0 m; Top Level: 4.31469 m
5 AMB.Geometria - 502.AMB.Amplada: 0.29 m; 503.AMB.Altura: 4.31469 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.341723 m3; Component, Component Volume (Gross): 0.341723 m3
Name | Building Material / Composite / Profile / Fill = Fill Type | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m)
Object_3521 | Common Brick | 0.101684 | 9.44168 | 4.41637 | 13.7564
Object_3521 | Background | 1.04973 | 10.3897 | 5.36442 | 14.7044

# IfcBuildingElementProxy: Rhino_Object_3522, Object_3522
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3522; Hotlink and Element ID: Object_3522; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_3522; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3522; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3522 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3522_; 109.AMB.CodiTipus: Object_3522; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.29 m; Area: 0.0846614 m2; Height: 0.100955 m; Volume (Net): 0.00844546 m3; Width: 0.291936 m; Elevation to Project Zero: 5.36347 m; Elevation to 1st Reference Level: 5.36347 m; Elevation to 2nd Reference Level: 5.36347 m; Elevation to Sea Level: 14.7035 m; Elevation to Linked/Home Story: 5.36347 m; Home Offset: 5.36347 m; Surface Area: 0.285151 m2; Top Elevation To First Reference Level: 5.46442 m; Top Elevation To Home Story: 5.46442 m; Top Elevation To Project Zero: 5.46442 m; Top Elevation To Sea Level: 14.8044 m; Top Elevation To Second Reference Level: 5.46442 m; Bottom Elevation To First Reference Level: 5.36347 m; Bottom Elevation To Home Story: 5.36347 m; Bottom Elevation To Project Zero: 5.36347 m; Bottom Elevation To Sea Level: 14.7035 m; Bottom Elevation To Second Reference Level: 5.36347 m; Survey Coordinate X: 426533 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 14.7035 m; Top Surface Area (Net): 0.0846614 m2; Bottom Surface Area (Net): 0.285151 m2
AC_Equantity_Rhino_Object_3522 - Dimension 1: 0.29 m; Dimension 2: 0.291936 m; Height: 0.100955 m; Bottom Level: 0 m; Top Level: 0.100955 m
5 AMB.Geometria - 502.AMB.Amplada: 0.291936 m; 503.AMB.Altura: 0.100955 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00844546 m3; Component, Component Volume (Gross): 0.00844546 m3

# IfcBuildingElementProxy: Rhino_Object_3523 (3)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_3523; Hotlink and Element ID: Object_3523; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_3523; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3523; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3523 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3523_; 109.AMB.CodiTipus: Object_3523; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.290002 m; Area: 0.0199253 m2; Height: 0.290151 m; Volume (Net): 0.004616 m3; Width: 0.0687073 m; Elevation to Project Zero: 5.12427 m; Elevation to 1st Reference Level: 5.12427 m; Elevation to 2nd Reference Level: 5.12427 m; Elevation to Sea Level: 14.4643 m; Elevation to Linked/Home Story: 5.12427 m; Home Offset: 5.12427 m; Surface Area: 0.239072 m2; Top Elevation To First Reference Level: 5.41443 m; Top Elevation To Home Story: 5.41443 m; Top Elevation To Project Zero: 5.41443 m; Top Elevation To Sea Level: 14.7544 m; Top Elevation To Second Reference Level: 5.41443 m; Bottom Elevation To First Reference Level: 5.12427 m; Bottom Elevation To Home Story: 5.12427 m; Bottom Elevation To Project Zero: 5.12427 m; Bottom Elevation To Sea Level: 14.4643 m; Bottom Elevation To Second Reference Level: 5.12427 m; Survey Coordinate Z: 14.4643 m; Top Surface Area (Net): 0.0199253 m2; Bottom Surface Area (Net): 0.239072 m2
AC_Equantity_Rhino_Object_3523 - Dimension 1: 0.290002 m; Dimension 2: 0.0687073 m; Height: 0.290151 m; Bottom Level: -1.95377e-10 m; Top Level: 0.290151 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0687073 m; 503.AMB.Altura: 0.290151 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.004616 m3; Component, Component Volume (Gross): 0.004616 m3
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_3523 | 103.501 | 426532 | 4579798
Object_3523 | 13.5006 | 426533 | 4579794
Object_3523 | 103.501 | 426533 | 4579794

# IfcBuildingElementProxy: Rhino_Object_3524, Object_3524
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3524; Hotlink and Element ID: Object_3524; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_3524; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3524; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3524 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3524_; 109.AMB.CodiTipus: Object_3524; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.096668 m; Area: 0.00941195 m2; Height: 0.0490955 m; Volume (Net): 0.000457726 m3; Width: 0.0973637 m; Elevation to Project Zero: 5.46564 m; Elevation to 1st Reference Level: 5.46564 m; Elevation to 2nd Reference Level: 5.46564 m; Elevation to Sea Level: 14.8056 m; Elevation to Linked/Home Story: 5.46564 m; Home Offset: 5.46564 m; Surface Area: 0.0376683 m2; Top Elevation To First Reference Level: 5.51474 m; Top Elevation To Home Story: 5.51474 m; Top Elevation To Project Zero: 5.51474 m; Top Elevation To Sea Level: 14.8547 m; Top Elevation To Second Reference Level: 5.51474 m; Bottom Elevation To First Reference Level: 5.46564 m; Bottom Elevation To Home Story: 5.46564 m; Bottom Elevation To Project Zero: 5.46564 m; Bottom Elevation To Sea Level: 14.8056 m; Bottom Elevation To Second Reference Level: 5.46564 m; Survey Coordinate X: 426533 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 14.8056 m; Top Surface Area (Net): 0.00941195 m2; Bottom Surface Area (Net): 0.0376683 m2
AC_Equantity_Rhino_Object_3524 - Dimension 1: 0.096668 m; Dimension 2: 0.0973637 m; Height: 0.0490955 m; Bottom Level: 0 m; Top Level: 0.0490955 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0973637 m; 503.AMB.Altura: 0.0490955 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000457726 m3; Component, Component Volume (Gross): 0.000457726 m3

# IfcBuildingElementProxy: Rhino_Object_3525 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3525; Hotlink and Element ID: Object_3525; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_3525; Colliding Zones: Espai públic; Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3525; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3525_; 109.AMB.CodiTipus: Object_3525; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.290262 m; Area: 0.0842521 m2; Height: 4.31469 m; Volume (Net): 0.341723 m3; Width: 0.290262 m; Surface Area: 5.16344 m2; Survey Coordinate X: 426532 m; Survey Coordinate Y: 4579799 m; Top Surface Area (Net): 0.0842521 m2; Bottom Surface Area (Net): 5.16344 m2
AC_Equantity_Rhino_Object_3525 - Dimension 1: 0.290262 m; Dimension 2: 0.290262 m; Height: 4.31469 m; Bottom Level: 0 m; Top Level: 4.31469 m
5 AMB.Geometria - 502.AMB.Amplada: 0.290262 m; 503.AMB.Altura: 4.31469 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.341723 m3; Component, Component Volume (Gross): 0.341723 m3
AC_Pset_Rhino_Object_3525 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Name | Building Material / Composite / Profile / Fill = Fill Type | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m)
Object_3525 | Common Brick | 0.101684 | 9.44168 | 4.41637 | 13.7564
Object_3525 | Background | 1.04973 | 10.3897 | 5.36442 | 14.7044

# IfcBuildingElementProxy: Rhino_Object_3526, Object_3526
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_3526; Hotlink and Element ID: Object_3526; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_3526; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_3526; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_3526 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_3526_; 109.AMB.CodiTipus: Object_3526; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.290264 m; Area: 0.0848145 m2; Height: 0.100955 m; Volume (Net): 0.00844546 m3; Width: 0.292198 m; Elevation to Project Zero: 5.36347 m; Elevation to 1st Reference Level: 5.36347 m; Elevation to 2nd Reference Level: 5.36347 m; Elevation to Sea Level: 14.7035 m; Elevation to Linked/Home Story: 5.36347 m; Home Offset: 5.36347 m; Surface Area: 0.285151 m2; Top Elevation To First Reference Level: 5.46442 m; Top Elevation To Home Story: 5.46442 m; Top Elevation To Project Zero: 5.46442 m; Top Elevation To Sea Level: 14.8044 m; Top Elevation To Second Reference Level: 5.46442 m; Bottom Elevation To First Reference Level: 5.36347 m; Bottom Elevation To Home Story: 5.36347 m; Bottom Elevation To Project Zero: 5.36347 m; Bottom Elevation To Sea Level: 14.7035 m; Bottom Elevation To Second Reference Level: 5.36347 m; Survey Coordinate X: 426532 m; Survey Coordinate Y: 4579799 m; Survey Coordinate Z: 14.7035 m; Top Surface Area (Net): 0.0848145 m2; Bottom Surface Area (Net): 0.285151 m2
AC_Equantity_Rhino_Object_3526 - Dimension 1: 0.290264 m; Dimension 2: 0.292198 m; Height: 0.100955 m; Bottom Level: 0 m; Top Level: 0.100955 m
5 AMB.Geometria - 502.AMB.Amplada: 0.292198 m; 503.AMB.Altura: 0.100955 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00844546 m3; Component, Component Volume (Gross): 0.00844546 m3

# IfcBuildingElementProxy: Rhino_Object_3527, Object_3527
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_3527 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
