Properties of the parts of a building model (IFC2X3), part 43 of 99

# IfcBuildingElementProxy: Rhino_Object_139, Object_139
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1390, Object_1390
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1390; Hotlink and Element ID: Object_1390; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1390; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1390; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1390 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1390_; 109.AMB.CodiTipus: Object_1390; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.258849 m; Area: 0.0941361 m2; Height: 4.62346 m; Volume (Net): 0.00000444587 m3; Width: 0.363671 m; Elevation to Project Zero: 1.22966 m; Elevation to 1st Reference Level: 1.22966 m; Elevation to 2nd Reference Level: 1.22966 m; Elevation to Sea Level: 10.5697 m; Elevation to Linked/Home Story: 1.22966 m; Home Offset: 1.22966 m; Surface Area: 0.00360027 m2; Top Elevation To First Reference Level: 1.34966 m; Top Elevation To Home Story: 1.34966 m; Top Elevation To Project Zero: 1.34966 m; Top Elevation To Sea Level: 10.6897 m; Top Elevation To Second Reference Level: 1.34966 m; Bottom Elevation To First Reference Level: 1.22966 m; Bottom Elevation To Home Story: 1.22966 m; Bottom Elevation To Project Zero: 1.22966 m; Bottom Elevation To Sea Level: 10.5697 m; Bottom Elevation To Second Reference Level: 1.22966 m; Survey Coordinate X: 426557 m; Survey Coordinate Y: 4579783 m; Survey Coordinate Z: 10.5697 m; Top Surface Area (Net): 0.0941361 m2; Bottom Surface Area (Net): 0.00360027 m2
AC_Equantity_Rhino_Object_1390 - Dimension 1: 0.258849 m; Dimension 2: 0.363671 m; Height: 4.62346 m; Bottom Level: -1.23421 m; Top Level: 3.38925 m
5 AMB.Geometria - 502.AMB.Amplada: 0.363671 m; 503.AMB.Altura: 4.62346 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00000444587 m3; Component, Component Volume (Gross): 0.00000444587 m3

# IfcBuildingElementProxy: Rhino_Object_1391, Object_1391
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1391; Hotlink and Element ID: Object_1391; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1391; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1391; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1391 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1391_; 109.AMB.CodiTipus: Object_1391; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.258849 m; Area: 0.0941361 m2; Height: 4.62346 m; Volume (Net): 0.00000631253 m3; Width: 0.363671 m; Elevation to Project Zero: 1.23589 m; Elevation to 1st Reference Level: 1.23589 m; Elevation to 2nd Reference Level: 1.23589 m; Elevation to Sea Level: 10.5759 m; Elevation to Linked/Home Story: 1.23589 m; Home Offset: 1.23589 m; Surface Area: 0.00430864 m2; Top Elevation To First Reference Level: 1.3559 m; Top Elevation To Home Story: 1.3559 m; Top Elevation To Project Zero: 1.3559 m; Top Elevation To Sea Level: 10.6959 m; Top Elevation To Second Reference Level: 1.3559 m; Bottom Elevation To First Reference Level: 1.23589 m; Bottom Elevation To Home Story: 1.23589 m; Bottom Elevation To Project Zero: 1.23589 m; Bottom Elevation To Sea Level: 10.5759 m; Bottom Elevation To Second Reference Level: 1.23589 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5759 m; Top Surface Area (Net): 0.0941361 m2; Bottom Surface Area (Net): 0.00430864 m2
AC_Equantity_Rhino_Object_1391 - Dimension 1: 0.258849 m; Dimension 2: 0.363671 m; Height: 4.62346 m; Bottom Level: -1.2376 m; Top Level: 3.38586 m
5 AMB.Geometria - 502.AMB.Amplada: 0.363671 m; 503.AMB.Altura: 4.62346 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00000631253 m3; Component, Component Volume (Gross): 0.00000631253 m3

# IfcBuildingElementProxy: Rhino_Object_1392, Object_1392
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1392; Hotlink and Element ID: Object_1392; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1392; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1392; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1392 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1392_; 109.AMB.CodiTipus: Object_1392; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.258849 m; Area: 0.0941361 m2; Height: 4.62346 m; Volume (Net): 0.000959107 m3; Width: 0.363671 m; Elevation to Project Zero: 1.23615 m; Elevation to 1st Reference Level: 1.23615 m; Elevation to 2nd Reference Level: 1.23615 m; Elevation to Sea Level: 10.5762 m; Elevation to Linked/Home Story: 1.23615 m; Home Offset: 1.23615 m; Surface Area: 0.0632946 m2; Top Elevation To First Reference Level: 1.35621 m; Top Elevation To Home Story: 1.35621 m; Top Elevation To Project Zero: 1.35621 m; Top Elevation To Sea Level: 10.6962 m; Top Elevation To Second Reference Level: 1.35621 m; Bottom Elevation To First Reference Level: 1.23615 m; Bottom Elevation To Home Story: 1.23615 m; Bottom Elevation To Project Zero: 1.23615 m; Bottom Elevation To Sea Level: 10.5762 m; Bottom Elevation To Second Reference Level: 1.23615 m; Survey Coordinate X: 426541 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.5762 m; Top Surface Area (Net): 0.0941361 m2; Bottom Surface Area (Net): 0.0632946 m2
AC_Equantity_Rhino_Object_1392 - Dimension 1: 0.258849 m; Dimension 2: 0.363671 m; Height: 4.62346 m; Bottom Level: -1.23786 m; Top Level: 3.3856 m
5 AMB.Geometria - 502.AMB.Amplada: 0.363671 m; 503.AMB.Altura: 4.62346 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000959107 m3; Component, Component Volume (Gross): 0.000959107 m3

# IfcBuildingElementProxy: Rhino_Object_1393, Object_1393
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1393; Hotlink and Element ID: Object_1393; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1393; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1393; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1393 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1393_; 109.AMB.CodiTipus: Object_1393; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 23.6207 m; Area: 37.1052 m2; Height: 4.62346 m; Volume (Net): 0.0386035 m3; Width: 1.57088 m; Elevation to Project Zero: 1.39817 m; Elevation to 1st Reference Level: 1.39817 m; Elevation to 2nd Reference Level: 1.39817 m; Elevation to Sea Level: 10.7382 m; Elevation to Linked/Home Story: 1.39817 m; Home Offset: 1.39817 m; Surface Area: 1.59449 m2; Top Elevation To First Reference Level: 1.56829 m; Top Elevation To Home Story: 1.56829 m; Top Elevation To Project Zero: 1.56829 m; Top Elevation To Sea Level: 10.9083 m; Top Elevation To Second Reference Level: 1.56829 m; Bottom Elevation To First Reference Level: 1.39817 m; Bottom Elevation To Home Story: 1.39817 m; Bottom Elevation To Project Zero: 1.39817 m; Bottom Elevation To Sea Level: 10.7382 m; Bottom Elevation To Second Reference Level: 1.39817 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.7382 m; Top Surface Area (Net): 37.1052 m2; Bottom Surface Area (Net): 1.59449 m2
AC_Equantity_Rhino_Object_1393 - Dimension 1: 23.6207 m; Dimension 2: 1.57088 m; Height: 4.62346 m; Bottom Level: -1.39987 m; Top Level: 3.22358 m
5 AMB.Geometria - 502.AMB.Amplada: 1.57088 m; 503.AMB.Altura: 4.62346 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0386035 m3; Component, Component Volume (Gross): 0.0386035 m3

# IfcBuildingElementProxy: Rhino_Object_1394, Object_1394
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Component Quantities - Component, Component Volume (Net): 0.187801 m3; Component, Component Volume (Gross): 0.187801 m3
5 AMB.Geometria - 502.AMB.Amplada: 1.57088 m; 503.AMB.Altura: 4.6263 m; 506.AMB.Profunditat: 0 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1394_; 109.AMB.CodiTipus: Object_1394; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Equantity_Rhino_Object_1394 - Dimension 1: 23.6207 m; Dimension 2: 1.57088 m; Height: 4.6263 m; Bottom Level: -1.40272 m; Top Level: 3.22358 m
ArchiCADQuantities - Length (A): 23.6207 m; Area: 37.1052 m2; Height: 4.6263 m; Volume (Net): 0.187801 m3; Width: 1.57088 m; Elevation to Project Zero: 1.39817 m; Elevation to 1st Reference Level: 1.39817 m; Elevation to 2nd Reference Level: 1.39817 m; Elevation to Sea Level: 10.7382 m; Elevation to Linked/Home Story: 1.39817 m; Home Offset: 1.39817 m; Surface Area: 7.66578 m2; Top Elevation To First Reference Level: 1.56829 m; Top Elevation To Home Story: 1.56829 m; Top Elevation To Project Zero: 1.56829 m; Top Elevation To Sea Level: 10.9083 m; Top Elevation To Second Reference Level: 1.56829 m; Bottom Elevation To First Reference Level: 1.39817 m; Bottom Elevation To Home Story: 1.39817 m; Bottom Elevation To Project Zero: 1.39817 m; Bottom Elevation To Sea Level: 10.7382 m; Bottom Elevation To Second Reference Level: 1.39817 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.7382 m; Top Surface Area (Net): 37.1052 m2; Bottom Surface Area (Net): 7.66578 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1394; Hotlink and Element ID: Object_1394; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1394; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1394; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1394 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg

# IfcBuildingElementProxy: Rhino_Object_1395, Object_1395
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1395; Hotlink and Element ID: Object_1395; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1395; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1395; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1395 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1395_; 109.AMB.CodiTipus: Object_1395; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 23.6163 m; Area: 35.4556 m2; Height: 4.62346 m; Volume (Net): 0.00490762 m3; Width: 1.50132 m; Elevation to Project Zero: 1.34816 m; Elevation to 1st Reference Level: 1.34816 m; Elevation to 2nd Reference Level: 1.34816 m; Elevation to Sea Level: 10.6882 m; Elevation to Linked/Home Story: 1.34816 m; Home Offset: 1.34816 m; Surface Area: 0.526479 m2; Top Elevation To First Reference Level: 1.39816 m; Top Elevation To Home Story: 1.39816 m; Top Elevation To Project Zero: 1.39816 m; Top Elevation To Sea Level: 10.7382 m; Top Elevation To Second Reference Level: 1.39816 m; Bottom Elevation To First Reference Level: 1.34816 m; Bottom Elevation To Home Story: 1.34816 m; Bottom Elevation To Project Zero: 1.34816 m; Bottom Elevation To Sea Level: 10.6882 m; Bottom Elevation To Second Reference Level: 1.34816 m; Survey Coordinate X: 426538 m; Survey Coordinate Y: 4579778 m; Survey Coordinate Z: 10.6882 m; Top Surface Area (Net): 35.4556 m2; Bottom Surface Area (Net): 0.526479 m2
AC_Equantity_Rhino_Object_1395 - Dimension 1: 23.6163 m; Dimension 2: 1.50132 m; Height: 4.62346 m; Bottom Level: -1.34987 m; Top Level: 3.27358 m
5 AMB.Geometria - 502.AMB.Amplada: 1.50132 m; 503.AMB.Altura: 4.62346 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00490762 m3; Component, Component Volume (Gross): 0.00490762 m3

# IfcBuildingElementProxy: Rhino_Object_1396, Object_1396
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1396; Hotlink and Element ID: Object_1396; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1396; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1396; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1396_; 109.AMB.CodiTipus: Object_1396; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Pset_Rhino_Object_1396 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADQuantities - Length (A): 23.6163 m; Area: 35.4556 m2; Height: 4.6263 m; Volume (Net): 0.0238747 m3; Width: 1.50132 m; Elevation to Project Zero: 1.34816 m; Elevation to 1st Reference Level: 1.34816 m; Elevation to 2nd Reference Level: 1.34816 m; Elevation to Sea Level: 10.6882 m; Elevation to Linked/Home Story: 1.34816 m; Home Offset: 1.34816 m; Surface Area: 2.54963 m2; Top Elevation To First Reference Level: 1.39816 m; Top Elevation To Home Story: 1.39816 m; Top Elevation To Project Zero: 1.39816 m; Top Elevation To Sea Level: 10.7382 m; Top Elevation To Second Reference Level: 1.39816 m; Bottom Elevation To First Reference Level: 1.34816 m; Bottom Elevation To Home Story: 1.34816 m; Bottom Elevation To Project Zero: 1.34816 m; Bottom Elevation To Sea Level: 10.6882 m; Bottom Elevation To Second Reference Level: 1.34816 m; Survey Coordinate X: 426542 m; Survey Coordinate Y: 4579779 m; Survey Coordinate Z: 10.6882 m; Top Surface Area (Net): 35.4556 m2; Bottom Surface Area (Net): 2.54963 m2
5 AMB.Geometria - 502.AMB.Amplada: 1.50132 m; 503.AMB.Altura: 4.6263 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0238747 m3; Component, Component Volume (Gross): 0.0238747 m3
AC_Equantity_Rhino_Object_1396 - Dimension 1: 23.6163 m; Dimension 2: 1.50132 m; Height: 4.6263 m; Bottom Level: -1.35271 m; Top Level: 3.27358 m

# IfcBuildingElementProxy: Rhino_Object_140, Object_140
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_140 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_140_; 109.AMB.CodiTipus: Object_140; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426572 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_140 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_140; Hotlink and Element ID: Object_140; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_140; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_140; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_141, Object_141
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_141 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426572 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_141_; 109.AMB.CodiTipus: Object_141; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_141 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_141; Hotlink and Element ID: Object_141; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_141; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_141; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1411, Object_1411
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1411; Hotlink and Element ID: Object_1411; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_1411; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1411; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1411 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1411_; 109.AMB.CodiTipus: Object_1411; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.80216 m; Area: 0.0866332 m2; Height: 1.52646 m; Volume (Net): 0.0466455 m3; Width: 0.108 m; Elevation to Project Zero: 2.24347 m; Elevation to 1st Reference Level: 2.24347 m; Elevation to 2nd Reference Level: 2.24347 m; Elevation to Sea Level: 11.5835 m; Elevation to Linked/Home Story: 2.24347 m; Home Offset: 2.24347 m; Surface Area: 1.98451 m2; Top Elevation To First Reference Level: 3.76992 m; Top Elevation To Home Story: 3.76992 m; Top Elevation To Project Zero: 3.76992 m; Top Elevation To Sea Level: 13.1099 m; Top Elevation To Second Reference Level: 3.76992 m; Bottom Elevation To First Reference Level: 2.24347 m; Bottom Elevation To Home Story: 2.24347 m; Bottom Elevation To Project Zero: 2.24347 m; Bottom Elevation To Sea Level: 11.5835 m; Bottom Elevation To Second Reference Level: 2.24347 m; Survey Coordinate X: 426583 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 11.5835 m; Top Surface Area (Net): 0.0866332 m2; Bottom Surface Area (Net): 1.98451 m2
AC_Equantity_Rhino_Object_1411 - Dimension 1: 0.80216 m; Dimension 2: 0.108 m; Height: 1.52646 m; Bottom Level: -9.45142e-11 m; Top Level: 1.52646 m
5 AMB.Geometria - 502.AMB.Amplada: 0.108 m; 503.AMB.Altura: 1.52646 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0466455 m3; Component, Component Volume (Gross): 0.0466455 m3

# IfcBuildingElementProxy: Rhino_Object_1412, Object_1412
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1412; Hotlink and Element ID: Object_1412; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_1412; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1412; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1412 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1412_; 109.AMB.CodiTipus: Object_1412; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 1.04472 m; Area: 0.128096 m2; Height: 2.20146 m; Volume (Net): 0.0705511 m3; Width: 0.122613 m; Elevation to Project Zero: 1.56847 m; Elevation to 1st Reference Level: 1.56847 m; Elevation to 2nd Reference Level: 1.56847 m; Elevation to Sea Level: 10.9085 m; Elevation to Linked/Home Story: 1.56847 m; Home Offset: 1.56847 m; Surface Area: 2.99892 m2; Top Elevation To First Reference Level: 3.76992 m; Top Elevation To Home Story: 3.76992 m; Top Elevation To Project Zero: 3.76992 m; Top Elevation To Sea Level: 13.1099 m; Top Elevation To Second Reference Level: 3.76992 m; Bottom Elevation To First Reference Level: 1.56847 m; Bottom Elevation To Home Story: 1.56847 m; Bottom Elevation To Project Zero: 1.56847 m; Bottom Elevation To Sea Level: 10.9085 m; Bottom Elevation To Second Reference Level: 1.56847 m; Survey Coordinate X: 426582 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 10.9085 m; Top Surface Area (Net): 0.128096 m2; Bottom Surface Area (Net): 2.99892 m2
AC_Equantity_Rhino_Object_1412 - Dimension 1: 1.04472 m; Dimension 2: 0.122613 m; Height: 2.20146 m; Bottom Level: -6.72262e-12 m; Top Level: 2.20146 m
5 AMB.Geometria - 502.AMB.Amplada: 0.122613 m; 503.AMB.Altura: 2.20146 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0705511 m3; Component, Component Volume (Gross): 0.0705511 m3

# IfcBuildingElementProxy: Rhino_Object_1413, Object_1413
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1413; Hotlink and Element ID: Object_1413; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_1413; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1413; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1413 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1413_; 109.AMB.CodiTipus: Object_1413; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 1.04472 m; Area: 0.128096 m2; Height: 2.20146 m; Volume (Net): 0.0705511 m3; Width: 0.122613 m; Elevation to Project Zero: 1.56847 m; Elevation to 1st Reference Level: 1.56847 m; Elevation to 2nd Reference Level: 1.56847 m; Elevation to Sea Level: 10.9085 m; Elevation to Linked/Home Story: 1.56847 m; Home Offset: 1.56847 m; Surface Area: 2.99892 m2; Top Elevation To First Reference Level: 3.76992 m; Top Elevation To Home Story: 3.76992 m; Top Elevation To Project Zero: 3.76992 m; Top Elevation To Sea Level: 13.1099 m; Top Elevation To Second Reference Level: 3.76992 m; Bottom Elevation To First Reference Level: 1.56847 m; Bottom Elevation To Home Story: 1.56847 m; Bottom Elevation To Project Zero: 1.56847 m; Bottom Elevation To Sea Level: 10.9085 m; Bottom Elevation To Second Reference Level: 1.56847 m; Survey Coordinate X: 426575 m; Survey Coordinate Y: 4579796 m; Survey Coordinate Z: 10.9085 m; Top Surface Area (Net): 0.128096 m2; Bottom Surface Area (Net): 2.99892 m2
AC_Equantity_Rhino_Object_1413 - Dimension 1: 1.04472 m; Dimension 2: 0.122613 m; Height: 2.20146 m; Bottom Level: -6.72262e-12 m; Top Level: 2.20146 m
5 AMB.Geometria - 502.AMB.Amplada: 0.122613 m; 503.AMB.Altura: 2.20146 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0705511 m3; Component, Component Volume (Gross): 0.0705511 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1414, Object_1414
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1414; Hotlink and Element ID: Object_1414; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_1414; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1414; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1414 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1414_; 109.AMB.CodiTipus: Object_1414; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.80216 m; Area: 0.0866332 m2; Height: 1.52646 m; Volume (Net): 0.0466455 m3; Width: 0.108 m; Elevation to Project Zero: 2.24347 m; Elevation to 1st Reference Level: 2.24347 m; Elevation to 2nd Reference Level: 2.24347 m; Elevation to Sea Level: 11.5835 m; Elevation to Linked/Home Story: 2.24347 m; Home Offset: 2.24347 m; Surface Area: 1.98451 m2; Top Elevation To First Reference Level: 3.76992 m; Top Elevation To Home Story: 3.76992 m; Top Elevation To Project Zero: 3.76992 m; Top Elevation To Sea Level: 13.1099 m; Top Elevation To Second Reference Level: 3.76992 m; Bottom Elevation To First Reference Level: 2.24347 m; Bottom Elevation To Home Story: 2.24347 m; Bottom Elevation To Project Zero: 2.24347 m; Bottom Elevation To Sea Level: 11.5835 m; Bottom Elevation To Second Reference Level: 2.24347 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 11.5835 m; Top Surface Area (Net): 0.0866332 m2; Bottom Surface Area (Net): 1.98451 m2
AC_Equantity_Rhino_Object_1414 - Dimension 1: 0.80216 m; Dimension 2: 0.108 m; Height: 1.52646 m; Bottom Level: -9.45142e-11 m; Top Level: 1.52646 m
Component Quantities - Component, Component Volume (Net): 0.0466455 m3; Component, Component Volume (Gross): 0.0466455 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.108 m; 503.AMB.Altura: 1.52646 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1416, Object_1416
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1416; Hotlink and Element ID: Object_1416; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1416; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1416; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1416 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1416_; 109.AMB.CodiTipus: Object_1416; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.458551 m; Area: 0.196379 m2; Height: 1.69405 m; Volume (Net): 0.267578 m3; Width: 0.428261 m; Elevation to Project Zero: 4.25992 m; Elevation to 1st Reference Level: 4.25992 m; Elevation to 2nd Reference Level: 4.25992 m; Elevation to Sea Level: 13.5999 m; Elevation to Linked/Home Story: 4.25992 m; Home Offset: 4.25992 m; Surface Area: 3.17705 m2; Top Elevation To First Reference Level: 5.95398 m; Top Elevation To Home Story: 5.95398 m; Top Elevation To Project Zero: 5.95398 m; Top Elevation To Sea Level: 15.294 m; Top Elevation To Second Reference Level: 5.95398 m; Bottom Elevation To First Reference Level: 4.25992 m; Bottom Elevation To Home Story: 4.25992 m; Bottom Elevation To Project Zero: 4.25992 m; Bottom Elevation To Sea Level: 13.5999 m; Bottom Elevation To Second Reference Level: 4.25992 m; Survey Coordinate X: 426569 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.5999 m; Top Surface Area (Net): 0.196379 m2; Bottom Surface Area (Net): 3.17705 m2
AC_Equantity_Rhino_Object_1416 - Dimension 1: 0.458551 m; Dimension 2: 0.428261 m; Height: 1.69405 m; Bottom Level: 0 m; Top Level: 1.69405 m
5 AMB.Geometria - 502.AMB.Amplada: 0.428261 m; 503.AMB.Altura: 1.69405 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.267578 m3; Component, Component Volume (Gross): 0.267578 m3

# IfcBuildingElementProxy: Rhino_Object_1417, Object_1417
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1417; Hotlink and Element ID: Object_1417; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1417; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1417; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1417 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1417_; 109.AMB.CodiTipus: Object_1417; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.461591 m; Area: 0.199514 m2; Height: 1.69405 m; Volume (Net): 0.268467 m3; Width: 0.432231 m; Elevation to Project Zero: 4.2526 m; Elevation to 1st Reference Level: 4.2526 m; Elevation to 2nd Reference Level: 4.2526 m; Elevation to Sea Level: 13.5926 m; Elevation to Linked/Home Story: 4.2526 m; Home Offset: 4.2526 m; Surface Area: 3.18456 m2; Top Elevation To First Reference Level: 5.94666 m; Top Elevation To Home Story: 5.94666 m; Top Elevation To Project Zero: 5.94666 m; Top Elevation To Sea Level: 15.2867 m; Top Elevation To Second Reference Level: 5.94666 m; Bottom Elevation To First Reference Level: 4.2526 m; Bottom Elevation To Home Story: 4.2526 m; Bottom Elevation To Project Zero: 4.2526 m; Bottom Elevation To Sea Level: 13.5926 m; Bottom Elevation To Second Reference Level: 4.2526 m; Survey Coordinate X: 426560 m; Survey Coordinate Y: 4579785 m; Survey Coordinate Z: 13.5926 m; Top Surface Area (Net): 0.199514 m2; Bottom Surface Area (Net): 3.18456 m2
AC_Equantity_Rhino_Object_1417 - Dimension 1: 0.461591 m; Dimension 2: 0.432231 m; Height: 1.69405 m; Bottom Level: 0 m; Top Level: 1.69405 m
5 AMB.Geometria - 502.AMB.Amplada: 0.432231 m; 503.AMB.Altura: 1.69405 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.268467 m3; Component, Component Volume (Gross): 0.268467 m3

# IfcBuildingElementProxy: Rhino_Object_1418 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_1418; Hotlink and Element ID: Object_1418; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1418; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1418; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
