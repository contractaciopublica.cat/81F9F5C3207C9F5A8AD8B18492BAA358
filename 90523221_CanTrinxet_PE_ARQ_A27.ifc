Properties of the parts of a building model (IFC2X3), part 8 of 99

# IfcBuildingElementProxy: Door 27 (9)
Name | Classification | Reveal Dimensions = Wallhole Dimensions = Unit Dimensions = Nominal W x H Size | Egress Dimensions | Leaf Dimensions | Nominal W x H x T Size | Wall Structure | Orientation = Door Orientation | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Colliding Zones | Parent ID | Surfaces (All) | Wall Direction Type | Opening Direction | Parapet Wall Inset Value | 2D Detail Level | Frame Style (gs_frame_style) | Frame Style (gs_frame_style_m) | Uniform Frame Width | Door Panel Style | Opening Handle (gs_handle_type_m) | Reveal Type (gs_reveal_type_new) | Reveal Type (gs_reveal_type_int) | Bottom Reveal Type (gs_reveal_type_bottom) | Bottom Reveal Type (gs_reveal_type_bottom_int) | Rail (gs_door_rail_ext) | Rail (gs_door_rail_ext_m) | Auto Turn Inside Face Plaster = Auto Turn Outside Face Plaster | Opening Angle in 3D (deg) | Opening Line Type | Opening Line Shape (or_iSlidingType) | Use Fills | Door Plan Symbol Fill Type | Door Plan Symbol Fill Pen | Door Plan Symbol Fill Background Pen | Uncut Fill Type | Uncut Fill Pen = Uncut Fill Background Pen | Curve Resolution | Uniform Door Surfaces | Frame Outside = Frame Inside = Leaf Outside = Leaf Inside = Leaf 2 = Leaf 3 = Grid Outside (gs_grill_mat) = Grid Inside (gs_grill_mat2) = Grid Outside (gs_leaf_grill_mat) = Grid Inside (gs_leaf_grill_mat2) = Solid Panel Outside = Solid Panel Inside | Handle | Total Glazed Area (gs_list_glassarea) | Group Type (FM_Type) | Group Type (iFMType) | Door Leaf Widths | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_107.NomTipus | W/D Opening Opening Volume (m3) = W/D Opening Nominal Volume (m3) | W/D Opening Surface Area (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | W/D Opening Nominal Surface Area (m2) = W/D Opening Surface Area on the Reveal Side (m2) = W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | W/D Opening Width on the Reveal Side (m) = W/D Opening Width on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Width on the Reveal Side (m) = Nominal W/D Opening Width on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Width (m) = AC_Equantity_Door_27, Width (m) = Wallhole Width (m) = Reveal Width (m) = Unit Width (m) = 502.AMB.Amplada (m) | W/D Opening Height on the Reveal Side (m) = W/D Opening Height on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Height on the Reveal Side (m) = Nominal W/D Opening Height on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Height (m) = AC_Equantity_Door_27, Height (m) = Wallhole Height (m) = Reveal Height (m) = Unit Height (m) = 503.AMB.Altura (m) | Sill/Header Value (m) = W/D Nominal Sill Height (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) = Sill Height to Current Story (m) | W/D Sill Height on the Reveal Side (m) = W/D Sill Height on the Side Opposite to the Reveal Side (m) | W/D Nominal Head Height (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | W/D Head Height on the Reveal Side (m) = W/D Head Height on the Side Opposite to the Reveal Side (m) | Wall Thickness (m) | ArchiCADQuantities, Frame Thickness (m) = AC_Equantity_Door_27, Frame Thickness (m) = Real Frame Thickness (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Top Elevation To Sea Level (m) | Reveal to Wall Core (m) = Reveal Depth (gs_wido_sill) (m) = Reveal Depth (AC_wido_sill) (m) | Shoulder Height (m) | Sidelight 2 Width (gs_sidelight_width_left_half) (m) | Sidelight 2 Width (gs_sidelight_width_left_orig) (m) | Egress Width (m) | Egress Height (m) | Nominal Leaf Width (m) | Nominal Leaf Height (m) | Leaf Offset (m) | Frame Width (m) | Door Stop Thickness (m) | Door Stop Width (m) | Rebate Width (m) | Nominal Leaf Width Side 1 (m) | Leaf Frame Width Side (m) = Leaf Frame Width Upper (m) | Leaf Frame Width Lower (m) | Sidelight Division Thickness (m) | Sill Thickness (m) | Opening Width in 2D (m) | Opening Side Width 2 (m) | Opening Side Width 1 (m) = Opposite Side Width 1 (m) | Opening Side Depth (m) | Opening Handle (gs_handle_type)
PI001 | 80.10.40.20 Portes d'accés (GuBIMclass CA) | 800,0×2.600,0 | 740,0×2.570,0 | 740,0×2.570,0 | 800,0×2.600,0×110,0 | Concrete 18 (5) | L | PI001 | Nau Santa Eulàlia | T1 | Metal - Stainless Steel; Wood - Pine Grained Horizontal | 1 | 1 | 2 | 1 | Block | 1 | yes | 1 | 19 | No Reveal - Edge | 1 | Uniform | 1 | Rail at Bottom | 2 | yes | 90 | 1 | 1 | yes | Air Space | Transparent | Transparent | Background | Backgrounds - color 1 | 24 | no | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 0 | Default Objects | 1 | 74 | PI001_PortaIntTipusD | Porta de pi amb doble fulla de 72.5cm | Nau Santa Eulalia | PortaIntTipusD | 0.2288 | 6.14527 | 2.08 | 0.8 | 2.6 | 0.27 | 0 | 2.87 | 2.5 | 0.11 | 0.14 | 0.101102 | 9.61 | 12.21 | 0 | 2.2 | 0.15 | 0.3 | 0.74 | 2.57 | 0.74 | 2.57 | 0.01 | 0.03 | 0 | 0 | 0 | 0.37 | 0.1 | 0.2 | 0.05 | 0.1 | 0.1 | 0.25 | 0.21 | 1.2 | Handle 9 | AC_Pset_Door_27 - Opening Line Shape (or_SlidingType): Arrow
PI002 | 80.10.40.20 Portes d'accés (GuBIMclass CA) | 800,0×2.600,0 | 740,0×2.570,0 | 740,0×2.570,0 | 800,0×2.600,0×140,0 | Concrete 18 (1) | L | PI002 | Nau Santa Eulàlia; Office; Rack | T1 | Wood - Pine Grained Horizontal | 3 | 1 | 2 | 1 | Block | 1 | yes | 1 | 0 | No Reveal - Edge | 1 | Uniform | 1 | Rail at Bottom | 2 | yes | 0 | 1 | 1 | yes | Air Space | Transparent | Transparent | Background | Backgrounds - color 1 | 24 | no | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 0 | Default Objects | 1 | 74 | PI002_PortaIntTipusD | Porta de pi amb doble fulla de 72.5cm | Nau Santa Eulalia | PortaIntTipusD | 0.2912 | 6.1132 | 2.08 | 0.8 | 2.6 | 0.27 | 0.197 | 2.87 | 2.797 | 0.14 | 0.14 | 0.10102 | 9.61 | 12.21 | 0 | 2.2 | 0.15 | 0.3 | 0.74 | 2.57 | 0.74 | 2.57 | 0.01 | 0.03 | 0 | 0 | 0 | 0.37 | 0.1 | 0.2 | 0.05 | 0.1 | 0.1 | 0.25 | 0.31 | 1.2 | AC_Pset_Door_27 - Opening Line Shape (or_SlidingType): Arrow
PE101 | 80.10.40.20 Portes d'accés (GuBIMclass CA); Door (ARCHICAD Classification) | 1.200,0×2.685,0 | 1.120,0×2.645,0 | 1.144,0×2.657,0 | 1.200,0×2.685,0×165,0 | Tr1 Plywood | L | PE101 | Nau Annexa | F3 | Metal - Nickel | 0 | 1 | 2 | 2 | Simple Rebate | 3 | no | 1 | 0 | No Reveal | 2 | Uniform | 1 | Off | 1 | no | 0 | 21 | 0 | yes | Background | Backgrounds - color 1 | Transparent | Background | Backgrounds - color 1 | 32 | yes | Metal - Nickel | Metal - Stainless Steel | 0 | Others | 25 | 1,14 | PE101_PortaExtTipusX | Finestra doble oscil·lant | Annex | PortaExtTipusX | 0.531631 | 10.2727 | 3.22201 | 1.2 | 2.68501 | 1 | 0 | 3.68501 | 2.58501 | 0.165 | 0.255 | 0.184694 | 10.34 | 13.025 | -0.14 | 2.55648 | 0.3 | 0.6 | 1.12 | 2.64501 | 1.144 | 2.65701 | 0 | 0.04 | 0.032 | 0.016 | 0.012 | 0.372 | 0.15 | 0.15 | 0.115 | 0.025 | 0 | 0.3 | 0.1 | 1.8

# IfcBuildingElementProxy: Double Door 27 (6)
In: planta baixa
ArchiCADProperties - Opening Library Part Name: Double Door 27; Opening Side Fill Index: Background; Library Part Name: Double Door 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Door; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Double_Door_27 - Wall Contours (0-None,1-Full,2-Side,3-Length): 0; Hotspots 0-None,1-2D,2-3D,3-All: 3; Show 2D Hotspots in 3D: yes; Floor Plan Display Option: 3; Hole Position Angle: 0 deg; Hole has Wall's Side Surface: yes; Hole Surface's Split is Curved in Curved Walls: no; Wall Type: 1; Reveal Anchor Position: 1; Flip: no; Demolition / New construction: 1; New Wall Fill Type: Masonry Block; New Wall Fill Pen: General - General; New Wall Fill Background Pen: Backgrounds - color 1; Show new construction on Wall: no; Demolition line type: 1; Show Demolition/New parameter: no; Display as Transom: no; Sidelight (gs_SidelightTransomRelation): Under Transom; Sidelight (gs_SidelightTransomRelation_m): 1; Sidelight 1: no; Sidelight 2: no; Transom: no; Uniform Tolerances: yes; Nominal Size: 0; Set Wallhole Size as Nominal Size: yes; Set Reveal Size as Nominal Size: no; Set Unit Size as Nominal Size: no; Set Egress Size as Nominal Size: no; Set Leaf Size as Nominal Size: no; Transfer Current Nominal Size to Selection: no; Show Editable Hotspots: yes; Show Reveal on Symbol: 1; Symbolic Display of Opening: no; Opening Direction Sidelight (gs_opening_dir_sl): Opposite to Leaf; Opening Direction Sidelight (gs_opening_dir_sl_m): 2; Door Frame (gs_pocket_door_frame): yes; Frame Thickness=Wall Thickness: no; Uniform Frame Thickness: yes; Centered Leaf: yes; Uniform Frame Width: yes; Frame Style Changed Automatically: no; Number of Door Leaves: 4; Number of Door Leaves - Side 2: 3; Leaves Configuration (gs_LeavesConfig): Uniform Leaves; Leaves Configuration (gs_iLeavesConfig): 1; Grid Position (gs_grill_pos): Throughout; Grid Position (gs_grill_pos_m): 3; Show as Glass Panel on Symbol: no; Show Chinese Spring Door Symbol: no; Show Symbol as Airtight Panel: no; Uniform Handles: no; Show Handle on Symbol: no; Kick Board Outside (bKickBoardOut): no; Kick Board Inside (bKickBoardIn): no; Uniform Sashes: no; Opening Type (gs_optype_m_05): 3; Opening Type (gs_optype_m_09): 3; Opening Type (gs_optype_m_02): 1; Opening Type (gs_optype_m_06): 1; Opening Type (gs_optype_m_10): 1; Sash Type (MullionStyle_00): No Grid; Sash Type (iMullionStyle_00): 1; Sash Type (iMullionStyle_05): 1; Sash Type (iMullionStyle_09): 1; Sash Type (iMullionStyle_02): 1; Sash Type (iMullionStyle_06): 1; Sash Type (iMullionStyle_10): 1; Hotspot Grill Editing: yes; Grid Position (MullionPosition): Throughout; Grid Position (iMullionPosition): 3; Panes Number Vertically Main Sash Side 1: 4; Panes Number Horizontally Main Sash Side 1: 2; Panes Number Vertically 2 Main Sash Side 1: 4; Panes Number Horizontally 2 Main Sash Side 1: 2; Panes Number Vertically Main Sash Side 2: 4; Panes Number Horizontally Main Sash Side 2: 2; Panes Number Vertically 2 Main Sash Side 2: 4; Panes Number Horizontally 2 Main Sash Side 2: 2; Panes Number Vertically Middle Transom: 2; Panes Number Horizontally Middle Transom: 2; Panes Number Vertically 2 Middle Transom: 2; Panes Number Horizontally 2 Middle Transom: 2; Panes Number Vertically Transom Side 1: 2; Panes Number Horizontally Transom Side 1: 2; Panes Number Vertically 2 Transom Side 1: 2; Panes Number Horizontally 2 Transom Side 1: 2; Panes Number Vertically Transom Side 2: 2; Panes Number Horizontally Transom Side 2: 2; Panes Number Vertically 2 Transom Side 2: 2; Panes Number Horizontally 2 Transom Side 2: 2; Casing Type Outside (gs_trimtype_out): Simple; Casing Type Outside (gs_trimtype_out_int): 1; Outside Casing Head Type: 1; Architrave Capital: yes; Architrave Capital Type: 1; Casing Type Inside (gs_trimtype_in): Simple; Casing Type Inside (gs_trimtype_in_int): 1; Threshold (bThreshold): no; Threshold Type: 2; Threshold Angle: 3.1996 deg; Threshold Changed Automatically: no; Sill - Door: no; Sill - Sidelight Side 1: no; Sill - Sidelight: no; Sill Oversize: no; Type of the Sill: 1; Sill Angle: 3 deg; Sill is Curved in Curved Walls: yes; Insulation below Sill: yes; Use Wall Insulation Skin: no; Brick Sill 3D Detail Level: 1; Sill Style Changed Automatically: no; Board - Sidelight Side 1: no; Board - Sidelight: no; Board - Door: no; Board Angle: 0 deg; Board is Curved in Curved Walls: yes; Board in Polygonal Walls: 1; Natural Ventilation: no; Natural Ventilation Type: 2; Sunshade: no; Sunshade Type: 1; Enabled Sunshade Types: 126; Number of Panels: 2; Number of Panels 2: 1; Panel Position (gs_shutter_panelPos): Symmetric; Panel Position (gs_shutter_iPanelPos): 1; Automatic Shutter Height: yes; Extra Frame: no; Cover Type (gs_slidingShutter_cover): Z-Profile; Cover Type (gs_slidingShutter_iCover): 1; Stacking Direction (gs_foldingShutter_stacking): Inside; Stacking Direction (gs_foldingShutter_iStacking): 1; Open in 3D: yes; 3D Opening Angle: 180 deg; Show 2D Symbol: yes; Show Opening Lines on Symbol: no; Panel Type (gs_shutPanel_type): Style 1; Panel Type (gs_shutPanel_iType): 1; Different Bottom Frame Width: no; Automatic Shutter Width: yes; Louver Angle: 30 deg; Holes Number Horizontal: 5; Holes Number Vertical: 8; Rolling Shutter Placement (gs_shutRoll_placement): On Facade; Rolling Shutter Placement (gs_shutRoll_iPlacement): 1; Box Type (gs_shutRoll_boxType): Rectangular; Box Type (gs_shutRoll_iBoxType): 1; Rail Position (gs_shutRoll_railPos): On Casing; Rail Position (gs_shutRoll_iRailPos): 1; Show Casing behind Sunshade (gs_shutRoll_showCasingBehind): no; Insulation behind Box (gs_shutRoll_cutWallBehind): no; Include Height in Wallhole Height: no; Box Top Angle: 10 deg; Box Default Width (gs_shutRoll_boxDefaultSize): Reveal Width; Box Default Width (gs_shutRoll_iBoxDefaultSize): 1; Venetian Blinds Placement (gs_shutLam_placement): Fixed on Facade; Venetian Blinds Placement (gs_shutLam_iPlacement): 1; Insulation behind Box (gs_shutLam_cutWallBehind): no; Opened Box: yes; Rail (gs_shutLam_bRail): yes; Rail Position (gs_shutLam_railPos): On Casing; Rail Position (gs_shutLam_iRailPos): 1; Show Casing behind Sunshade (gs_shutLam_showCasingBehind): no; Rotation Angle of Slats (gs_shutLam_rotation): 45 deg; Rotation Angle of Slats (gs_shutLam2_rotation): 45 deg; Masonry Arch (bMasonryArch): no; Masonry Arch (gs_masonry_arch_int): 2; Masonry Arch Type (gs_masonry_arch_structure): Stucco Arch; Masonry Arch Type (gs_masonry_arch_structure_int): 1; Arch on Header: yes; Niche below Arch: yes; Skewback Angle: 75 deg; Custom Niche Surface: no; Bottom Reveal Type (gs_reveal_type_bottom): Uniform; Bottom Reveal Type (gs_reveal_type_bottom_int): 1; Set Jamb Depth on Side: 1; Uniform Jamb Depth: yes; Outer Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleOuterTypeInt): 0; Inner Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleInnerTypeInt): 0; Angle Side 2: 20 deg; Angle Side: 20 deg; Upper Side Angle: 20 deg; Bottom Side Angle: 20 deg; Outer Angle Side 2: 20 deg; Outer Angle Side: 20 deg; Outer Angle Upper Side: 20 deg; Outer Angle Bottom Side: 20 deg; Rail under Leaves: no; Rail (gs_door_rail_ext): Off; Rail (gs_door_rail_ext_m): 1; Use Wall Finish Component: no; Auto Turn Inside Face Plaster: yes; Turn Inside Face Plaster: 0; Auto Turn Outside Face Plaster: yes; Turn Outside Face Plaster: 0; Dimensionable on 2D: no; Show in 3D: no; Closure Type (gs_closure_type): No Closure; Closure Type (gs_closure_type_int): 1; Turn Skin on Side (gs_cavity_side): Both; Turn Skin on Side (iCavityClosureSide): 1; Number of Skins to Turn: 1; Number from (gs_nTurnDir): Outside Face; Number from (iCavityClosureTurnDir): 1; Place Closer on Side 1: yes; Place Closer on Side 2: yes; Place Closer on Top: no; Place Closer on Bottom: no; Place Closer to Skin: 1; Place Closer from Side (gs_cc_dutch_ClosureToSide): 1; Gap at Outside Skin: yes; Turn Skin to Closer: no; Insert Insulation Strip: yes; Show Insulation Strip: yes; Contour Pen (gs_penJoint): Openings - Cut Non-Structural; Contour Line Type (gs_ltJoint): 1; Fill Type (gs_fillJoint): Rigid Insulation; Fill Pen (gs_penJointFg): General - General; Fill Background Pen (gs_penJointBg): 2D Elements - Drafting; Custom Surface: no; Surface: Wood - Pine Grained Horizontal; Contour Pen (gs_penPlug): Openings - Cut Non-Structural; Contour Line Type (gs_ltPlug): 1; Fill Type (gs_fillPlug): Rigid Insulation; Fill Pen (gs_penPlugFg): General - General; Fill Background Pen (gs_penPlugBg): 2D Elements - Drafting; Edited Jamb Side: 1; Edited Wall Side: 1; Edited Skin Number: 1; Turn-in Skin: no; Consider Skin as Plaster: no; Turn-in Thickness: 1; Hatch Orientation: 1; Separating Line at Turn-in: no; Separating Line Pen: General - General; Last Selected Side: no; Closure Method Changed Automatically: no; Connection on Side 1: no; Connection on Side 2: no; Connection on the Top: no; Opening Type (gs_leaf_optype): Side Hung; Opening Type (gs_leaf_optype_m): 5; End Panel Opening Side 1: no; End Panel Opening Side 2: no; Opening Angle of Main Sash Side 1 (openingAngle_05): 0 deg; Opening Angle of Main Sash Side 1 (openingAngle2_05): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle_09): 0 deg; Opening Angle of Main Sash Side 2 (openingAngle2_09): 0 deg; Opening Angle of Middle Transom (openingAngle_02): 0 deg; Opening Angle of Middle Transom (openingAngle2_02): 0 deg; Opening Angle of Transom Side 1 (openingAngle_06): 0 deg; Opening Angle of Transom Side 1 (openingAngle2_06): 0 deg; Opening Angle of Transom Side 2 (openingAngle_10): 0 deg; Opening Angle of Transom Side 2 (openingAngle2_10): 0 deg; Double Acting Line Type: 4; Override MVO for 2D Symbolic Display: yes; Opening Line Type: 21; Opening Line Shape (or_SwingType): Curved; Opening Line Shape (or_iSwingType): 1; Opening Line Shape (or_iSlidingType): 0; Show Glazing Line in 2D: yes; Glazing Line Pen in 2D (or_iGlazingLinePen): 3; Glazing Line Pen in 2D (or_glazingLinePen): Openings - General; Override MVO for Door 3D Projections: yes; Show Opening Line (or_bOplines3d): yes; Line Type Opening Side (or_opLineType3dIn): Dashed; Line Type Opening Side (or_iOpLineType3dIn): 1; Line Type Opposite Side (or_opLineType3dOut): Dashed; Line Type Opposite Side (or_iOpLineType3dOut): 1; Line Orientation (or_oplineStyle): Handle; Line Orientation (or_iOplineStyle): 1; Opening Line Pen in 2D/3D (or_opLinePen): Roofs/Shells - Outlines and Cover Fills; Opening Line Pen in 2D/3D (or_iOpLinePen): 92; Override MVO for Sidelight/Transom 3D Projections: no; Show Opening Line (or_bWinOplines3d): yes; Line Type Opening Side (or_winOpLineType3dIn): Dashed; Line Type Opening Side (or_iWinOpLineType3dIn): 1; Line Type Opposite Side (or_winOpLineType3dOut): Solid Line; Line Type Opposite Side (or_iWinOpLineType3dOut): 0; Line Orientation (or_winOplineStyle): Handle; Line Orientation (or_iWinOplineStyle): 1; Opening Line Pen in 2D/3D (or_winOpLinePen): Openings - General; Opening Line Pen in 2D/3D (or_iWinOpLinePen): 3; Symbol Pen: Openings - General; Frame Contour Pen: Openings - Cut Structural; Casing Cut Line Pen on Both Sides: Openings - General; Leaf Contour Pen: Openings - General; Wall Contour Line (gs_wcont_line): Off; Wall Contour Line (iWallContourLine): 1; Wall Contour Line Type Inside: 1; Wall Contour Line Type Outside: 1; Hidden Wall Contour Line Type Inside: 4; Hidden Wall Contour Line Type Outside: 4; Sidelight Wall Contour Line (gs_wcont_line_sl): Both Sides; Sidelight Wall Contour Line (iWallContourLineSl): 4; Sidelight Wall Contour Line Type Inside: 1; Sidelight Wall Contour Line Type Outside: 1; Sidelight Hidden Wall Contour Line Type Inside: 4; Sidelight Hidden Wall Contour Line Type Outside: 4; Wall Contour Line Pen: Openings - General; Use Fills: yes; Frame Fill Type: Background; Frame Fill Pen: Openings - Cut Fills; Frame Fill Background Pen: Backgrounds - color 1; Leaf Fill Type: Air Space; Airtight Symbol Fill Type: Foreground; Airtight Symbol Fill Pen: General - General; Airtight Symbol Fill Background Pen: General - General; Door Plan Symbol Fill Pen: Transparent; Door Plan Symbol Fill Background Pen: Transparent; Sidelight Plan Symbol Fill Type: Background; Sidelight Plan Symbol Fill Pen: Backgrounds - color 1; Sidelight Plan Symbol Fill Background Pen: Backgrounds - color 1; Threshold and Sill Line Type: 1; Threshold Section Contour Pen: Openings - General; Threshold Section Fill Type: Background; Threshold Section Fill Pen: Backgrounds - color 1; Threshold Section Fill Background Pen: Backgrounds - color 1; Sill 3D and Uncut Pen: General - General; Sill Section Contour Pen: General - General; Sill Section Fill Type: Air Space; Sill Section Fill Pen: Backgrounds - color 1; Sill Section Fill Background Pen: Backgrounds - color 1; Section Insulation Contour Pen: General - General; Section Insulation Fill Type: Rigid Insulation; Section Insulation Fill Pen: General - General; Section Insulation Fill Background Pen: Backgrounds - color 1; Board 3D and Uncut Pen: General - General; Board Section Contour Pen: General - General; Board Section Fill Type: Air Space; Board Section Fill Pen: Backgrounds - color 1; Board Section Fill Bkg. Pen: Backgrounds - color 1; Casing Fill Type Inside: Air Space; Casing Fill Pen Inside: Backgrounds - color 1; Casing Fill Background Pen Inside: Backgrounds - color 1; Casing Fill Type Outside: Air Space; Casing Fill Pen Outside: Backgrounds - color 1; Casing Fill Background Pen Outside: Backgrounds - color 1; Arch Section Fill Type: Background; Arch Section Fill Pen: Backgrounds - color 1; Arch Section Fill Bkg. Pen: Backgrounds - color 1; Ventilation Profile Section Fill Type: Air Space; Ventilation Profile Section Fill Pen: Backgrounds - color 1; Ventilation Profile Section Fill Background Pen: Backgrounds - color 1; Sunshade Symbol Line Type: 1; Sunshade Cut Line Pen: General - General; 3D/Section Uncut Line Pen: General - General; Sunshade Cut Fill Type: Background; Sunshade Cut Fill Pen: General - General; Sunshade Cut Fill Background Pen: Window Background; Sunshade Insulation Fill Type: Batt Insulation; Sunshade Insulation Fill Pen: General - General; Sunshade Insulation Background Pen: Window Background; Opening Side Values (gs_opside_list): Custom; Opening Side Values (gs_opside_list_m): 0; Frame Element Joinery (gs_SashText_typ): Butt Joint; Frame Element Joinery (gs_SashText_typ_num): 2; Frame Pen: Openings - General; Leaf Pen: Openings - General; Sash Glass Pen: Openings - Cut Non-Structural; Leaf Glass Pen: Openings - Cut Non-Structural; Masonry Arch Pen: Walls/Curtain Walls - General; Curve Resolution: 32; Shadow: yes; Lock: Paint - Anthracite; Sash Glass: Glass - Clear Fast; Rail (gs_rail_mat): Metal - Iron; Louver Outside: Wood - Pine Grained Horizontal; Louver Inside: Wood - Pine Grained Horizontal; Kick Plate: Metal - Aluminium; Uniform Casing Surfaces: yes; Ventilation Profile: Metal - Aluminium; Shutter Panel: Wood - Pine Grained Horizontal; Shutter Panel Frame: Wood - Pine Grained Horizontal; Rolling Shutter Box: Metal - Stainless Steel; Rolling Shutter Blades: Paint - Glossy White; Rolling Shutter Rail: Paint - Glossy White; Venetian Blinds Box: Metal - Stainless Steel; Venetian Blinds Segments: Paint - Glossy White; Sliding Shutter Rail: Metal - Stainless Steel; Threshold (gs_treshold_mat): Wood - Pine Grained Horizontal; Threshold Metal: Metal - Aluminium; Sill (gs_sill_mat): Brick - Running Bond; Brick Sill Mortar: Stucco - White Rough; Board (gs_board_mat): Wood - Pine Grained Horizontal; Handle Accessories: Metal - Iron; Kick Board Outside (matKickBoardOut): Metal - Stainless Steel; Kick Board Inside (matKickBoardIn): Metal - Stainless Steel; Masonry Arch Brick: Brick - Running Bond; Masonry Arch Mortar: Stucco - White Rough; Masonry Arch Keystone: Stone - Sandstone 01; Niche: Paint - Lead Oxide Yellow; Tags and Labels: 1; Show Leaf Width Dimensions: yes; Show Door ID: no; Show Custom Text: no; Custom Text: <Custom Text>; Always Readable: yes; Font Type: Arial; Font Size: 2; Font Style: 0; Text Pen (iPenText): 1; Text Pen (penText): General - General; Door belongs to the Zone into which it opens: yes; Cost: 0; Location as: Custom; Total Glazed Area (gs_list_glassarea_tmp): 0; Override Glazed Area: no; Total Glass Perimeter: 0; Free Air Performance (mm2/l/m): 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg; Door Orientation Definition: 0; Door Closer: no; Vision Panel Type: No Vision Panel; Hold Open Device: no; IFC Operation (ifc_optypestr): Double Door Single Swing; IFC Operation (ifc_optype): 2
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0
1 AMB.Identificacio - 115.AMB.Nivell: planta baixa
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADQuantities - W/D Opening Height on the Reveal Side: 2.6 m; W/D Opening Height on the Side Opposite to the Reveal Side: 2.6 m; Nominal W/D Opening Height on the Reveal Side: 2.6 m; Nominal W/D Opening Height on the Side Opposite to the Reveal Side: 2.6 m; Height: 2.6 m
5 AMB.Geometria - 503.AMB.Altura: 2.6 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Double_Door_27 - Height: 2.6 m; Z Dimension: 1 m; Bottom Level: 1 m; Top Level: 0 m; New Wall Fill Width Right: 0.15 m; New Wall Fill Width Left: 0.15 m; Sidelight 1 Width (gs_sidelight_width_right): 0 m; Sidelight 1 Width (gs_sidelight_width_right_half): 0.15 m; Sidelight 1 Width (gs_sidelight_width_right_orig): 0.3 m; Sidelight 1 Sill Height: 0 m; Sidelight 2 Width (gs_sidelight_width_left): 0 m; Sidelight 2 Width (gs_sidelight_width_left_half): 0.3 m; Sidelight 2 Width (gs_sidelight_width_left_orig): 0.6 m; Sidelight 2 Sill Height: 0 m; Transom Height: 0.3 m; Pivot Axis Offset: 0.275 m; Tolerance Side 1 Lower: 0 m; Tolerance Sidelight 1 Bottom: 0 m; Tolerance Side 2 Lower: 0 m; Tolerance Sidelight 2 Bottom: 0 m; Tolerance Lower: 0 m; Wallhole Height: 2.6 m; Reveal Height: 2.6 m; Frame Thickness Inside: 0.115 m; Leaf Offset: 0 m; Frame Oversize: 0.01 m; Frame Outer Thickness: 0.01 m; Frame Width Side 1: 0.04 m; Middle Frame Width Side 1: 0.04 m; Bottom Frame Width Side 1: 0.04 m; Frame Width Side 2: 0.04 m; Middle Frame Width Side 2: 0.04 m; Bottom Frame Width Side 2: 0.04 m; Transom Frame Width (gs_frame_width_transom): 0.04 m; Upper Frame Width: 0.04 m; Door Stop Thickness: 0.032 m; Door Stop Width: 0.016 m; Sidelight and Transom Rebate Width: 0.01 m; Sidelight and Transom Rebate Depth: 0.018 m; Leaf Frame Width Right: 0.1 m; Leaf Frame Width Left: 0.1 m; Leaf Frame Width Internal: 0.025 m; Leaf Undercut: 0 m; Handle Height (gs_han_height): 1 m; Handle Position (gs_han_pos): 0.05 m; Handle Height (gs_han_height2): 1 m; Handle Position (gs_han_pos2): 0.05 m; Kick Board Height: 0.1 m; Horizontal Division Height Sidelight Side 1: 0.9 m; Horizontal Division Height Sidelight Side 2: 0.9 m; Horizontal Division Height Middle Transom: 0.9 m; Horizontal Division Height Transom Side 1: 0.9 m; Horizontal Division Height Transom Side 2: 0.9 m; Sidelight and Transom Frame Thickness: 0.044 m; Transom Frame Width (gs_sash_width): 0.067 m; Sidelight Frame Width: 0.067 m; Grill Width: 0.02 m; Grill Thickness: 0.025 m; Sidelight Division Width: 0.04 m; Architrave Capital Width: 0.02 m; Width Side 2 (gs_tw_left_out): 0.05 m; Width Top (gs_tw_top_out): 0.05 m; Thickness on Wall (gs_trim_thk_out): 0.019 m; Top Overhang (gs_trimov_top_left_out): 0.1 m; Top Overhang (gs_trimov_top_right_out): 0.1 m; Width Side 2 (gs_tw_left_in): 0.05 m; Width Top (gs_tw_top_in): 0.05 m; Thickness on Wall (gs_trim_thk_in): 0.019 m; Top Overhang (gs_trimov_top_left_in): 0.1 m; Top Overhang (gs_trimov_top_right_in): 0.1 m; Threshold Thickness: 0.012 m; Threshold Width: 0.01 m; Threshold External Thickness: 0.00580738 m; Threshold Nosing Outside: 0.025 m; Threshold Nosing Inside: 0.025 m; Side Overhang Outside: 0 m; Side Overhang Inside: 0 m; Sill Thickness: 0.025 m; Sill Front Side Thickness: 0.015 m; Sill Elevation: 0.005 m; Sill Drip Overlap: 0.02 m; Sill Drip Width: 0.03 m; Sill Nosing: 0.03 m; Sill Overhang Side 1: 0 m; Sill Overhang Side 2: 0 m; Sill Slip-in Depth: 0.02 m; Sill Top Width: 0.01 m; Sill Top Height: 0.01 m; Sill Slip from Wall: 0 m; Rear Hole Depth (gs_sill_holeDepthBehind): 0 m; Width of Sill: 0 m; Brick Thickness (gs_brick_sill_br_thk): 0.065 m; Mortar Thickness (gs_brick_sill_mort_thk): 0.015 m; Board Width: 0.1 m; Board Thickness: 0.025 m; Board Nosing: 0.03 m; Board Overhang Side 1: 0 m; Board Overhang Side 2: 0 m; Board Slip-in Depth: 0 m; Profile Height: 0.065 m; Profile Thickness: 0.11 m; Panel Height: 1.5 m; Inner Offset: 0.02 m; Closing Depth: 0 m; Extra Frame Width: 0.04 m; Extra Frame Thickness: 0.03 m; Rail Width: 0.03 m; Hanging Stick Length: 0.02 m; Hanging Stick Radius: 0.005 m; Panel Distance: 0.006 m; Outside Overhang: 0 m; Inner Panel Width: 0.12 m; 3D Opening Length: 1.5 m; 3D Closed Length: 0 m; 3D Opening Length 1: 0.56 m; 3D Opening Length 2: 0.14 m; 3D Opening Height: 1.5 m; 3D Closed Height: 0 m; Panel Thickness: 0.05 m; Panel Frame Width: 0.05 m; Frame Width Bottom: 0.05 m; Panel Width: 0 m; Panel Fill Thickness: 0.01 m; Louver Thickness: 0.01 m; Louver Width: 0.04 m; Horizontal Frame Divider Width: 0.05 m; Vertical Frame Divider Width: 0.05 m; Hole Radius: 0.01 m; Vertical Board Width: 0.1 m; Z Frame Width: 0.05 m; Z Frame Thickness: 0.025 m; Vertical Boards Thickness: 0.025 m; Horizontal Boards Thickness: 0.025 m; Vertical Boards Approximate Width: 0.08 m; Horizontal Boards Approximate Width: 0.115 m; Box Height (gs_shutRoll_boxHeight): 0.2 m; Box Depth (gs_shutRoll_boxWidth): 0.15 m; Box Left Offset: 0 m; Box Right Offset: 0 m; Depth of Rails: 0.0725 m; Distance from Wall (gs_shutRoll_distFromWall): 0 m; Distance from Header (gs_shutRoll_distFromHead): 0 m; Slat Width: 0.05 m; Box Height (gs_shutLam_boxHeight): 0.2 m; Box Depth (gs_shutLam_boxWidth): 0.15 m; Cover Width: 0 m; Distance from Wall (gs_shutLam_distFromWall): 0 m; Distance from Header (gs_shutLam_distFromHead): 0 m; Segment Width (gs_shutLam_segmentWidth): 0.06 m; Box Height (gs_shutLam2_boxHeight): 0.06 m; Box Width: 0.06 m; Distance from Window: 0.06 m; Distance from Header (gs_shutLam2_distFromHead): 0.06 m; Box Axis Height from Header: 0 m; Segment Width (gs_shutLam2_segmentWidth): 0.06 m; Distance between Arch and Door: 0 m; Masonry Arch Overhang Side 1: 0 m; Masonry Arch Overhang Side 2: 0 m; Masonry Arch Rise: 0.03 m; Masonry Arch Projection: 0 m; Masonry Arch Height: 0.25 m; Masonry Arch Depth: 0.12 m; Rear Hole Depth (gs_masonry_arch_rearHoleDepth): 0 m; Brick Thickness (gs_masonry_arch_brick_thk): 0.065 m; Mortar Thickness (gs_masonry_arch_mort_thk): 0.01 m; Keystone Width: 0.1 m; Keystone Oversize: 0 m; Keystone Projection: 0.01 m; Jamb Depth: 0.06 m; Jamb Depth Side 2: 0.06 m; Lower Jamb Depth Side 1: 0.06 m; Lower Jamb Depth Side 2: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_splayed_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_splayed_innerRight): 0.06 m; Inner Jamb Depth (gs_reveal_double_innerRight): 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_double_innerLeft): 0.06 m; Inner Lower Jamb Depth Side 1: 0.06 m; Inner Lower Jamb Depth Side 2: 0.06 m; Head Depth: 0.06 m; Sill Depth: 0.06 m; Sill Depth Side 1: 0.06 m; Sill Depth Side 2: 0.06 m; Inner Head Depth (gs_reveal_splayed_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_splayed_innerBottom): 0.06 m; Inner Head Depth (gs_reveal_double_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_double_innerBottom): 0.06 m; Inner Sill Depth Side 1: 0 m; Inner Sill Depth Side 2: 0 m; Outer Jamb Depth: 0.08 m; Plaster Thickness Limit: 0.04 m; Distance of Skin from Closer: 0 m; Closer Width: 0.038 m; Closer Thickness: 0.1 m; Strip Thickness: 0.025 m; Profile Width: 0.15 m; Custom Thickness: 0.015 m; Skin Overhang to Frame Depth: 0 m; Left Opening Oversize: 0 m; Right Opening Oversize: 0 m; Upper Opening Oversize: 0 m; Lower Opening Oversize: 0 m; Opening Width in 3D: 0 m; Opening Width in 3D on Side 2: 0 m; Opening Width in 2D: 0 m; Opening Width in 2D on Side 2: 0 m; Opening Distance 1 Main Sash Side 1: 0 m; Opening Distance 2 Main Sash Side 1: 0 m; Opening Distance 1 Main Sash Side 2: 0 m; Opening Distance 2 Main Sash Side 2: 0 m; Opening Distance 1 Middle Transom: 0 m; Opening Distance 2 Middle Transom: 0 m; Opening Distance 1 Transom Side 1: 0 m; Opening Distance 2 Transom Side 1: 0 m; Opening Distance 1 Transom Side 2: 0 m; Opening Distance 2 Transom Side 2: 0 m; Opening Side Width 2: 0.1 m; Opening Side Width 1: 0.1 m; Opening Side Depth: 1.8 m; Opposite Side Width 2: 0.1 m; Opposite Side Width 1: 0.1 m; Opposite Side Depth: 1.2 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m; ID Offset X: 0 m; ID Offset Y: 0 m; Custom Text Offset X: 0 m; Custom Text Offset Y: 0 m; Leaf 1 Width Offset X: 0 m; Leaf 1 Width Offset Y: 0 m; Leaf 2 Width Offset X: 0 m; Leaf 2 Width Offset Y: 0 m
Name | Classification | Reveal Dimensions = Wallhole Dimensions = Nominal W x H Size | Unit Dimensions | Egress Dimensions | Leaf Dimensions | Nominal W x H x T Size | Wall Structure | Marker Text | Orientation = Door Orientation | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Layer | Colliding Zones | Parent ID | Surfaces (All) | Renovation Status | Wall Direction Type | Opening Direction | Parapet Wall Inset Value | 2D Detail Level | 3D Detail Level | Frame Style (gs_frame_style) | Frame Style (gs_frame_style_m) | Door Panel Style | Panes Number Vertically Side 2 = Panes Number Vertically Side 1 | Panes Number Horizontally Side 2 = Panes Number Horizontally Side 1 | Edit Handle | Opening Handle (gs_handle_type_m) | Opening Handle (gs_handle_type2_m) | Casing Outside | Cover Outer Wall Surface = Cover Inner Wall Surface | Uniform Casing Widths (gs_trim_outside_uniform) = Uniform Casing Widths (gs_trim_inside_uniform) | Casing Inside | Reveal Type (gs_reveal_type_new) | Reveal Type (gs_reveal_type_int) | Opening Angle in 2D (deg) = Opening Angle in 2D on Side 2 (deg) | Opening Angle in 3D (deg) = End Panel Opening Angle in 3D on Side 2 (deg) | Leaf Fill Pen = Leaf Fill Background Pen = Uncut Fill Pen = Uncut Fill Background Pen | Door Plan Symbol Fill Type = Uncut Fill Type | Uniform Door Surfaces | Frame Outside = Frame Inside = Leaf Outside = Leaf Inside = Leaf 2 = Leaf 3 = Grid Outside (gs_grill_mat) = Grid Inside (gs_grill_mat2) = Grid Outside (gs_leaf_grill_mat) = Grid Inside (gs_leaf_grill_mat2) = Solid Panel Outside = Solid Panel Inside | Leaf Glass | Interior Casing = Exterior Casing | Handle | Total Glazed Area (gs_list_glassarea) | Door Leaf Widths | Status | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | 201.AMB.EsEstructural | 402.AMB.DBSIResistenciaFoc | AUX_104.AMB.ClassificacioCodiCateg | AUX_107.NomTipus | W/D Opening Opening Volume (m3) = W/D Opening Nominal Volume (m3) | W/D Opening Surface Area (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | W/D Opening Nominal Surface Area (m2) = W/D Opening Surface Area on the Reveal Side (m2) = W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | W/D Opening Width on the Reveal Side (m) = W/D Opening Width on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Width on the Reveal Side (m) = Nominal W/D Opening Width on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Width (m) = 502.AMB.Amplada (m) = AC_Equantity_Double_Door_27, Width (m) = Wallhole Width (m) = Reveal Width (m) | Sill/Header Value (m) = W/D Nominal Sill Height (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) = Sill Height to Current Story (m) | W/D Sill Height on the Reveal Side (m) = W/D Sill Height on the Side Opposite to the Reveal Side (m) | W/D Nominal Head Height (m) | W/D Head Height on the Reveal Side (m) = W/D Head Height on the Side Opposite to the Reveal Side (m) | Wall Thickness (m) | ArchiCADQuantities, Frame Thickness (m) = AC_Equantity_Double_Door_27, Frame Thickness (m) = Real Frame Thickness (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Reveal to Wall Core (m) = Reveal Depth (gs_wido_sill) (m) = Reveal Depth (AC_wido_sill) (m) | Shoulder Height (m) | Tolerance Side 1 (m) = Tolerance Side 2 (m) = Tolerance Upper (m) | Unit Width (m) | Unit Height (m) | Egress Width (m) | Egress Height (m) | Nominal Leaf Width (m) | Nominal Leaf Height (m) | Frame Width (m) | Rebate Width (m) = Offset (gs_trim_offs_out) (m) | Leaf Rebate Depth in 3D (m) | Nominal Leaf Width Side 1 (m) | Leaf Thickness (m) | Leaf Frame Width Side (m) | Leaf Frame Width Lower (m) = Leaf Frame Width Upper (m) | Grid Width (m) | Grid Thickness (m) | Glass Thickness (m) | Sidelight Division Thickness (m) | Width Side 1 (gs_tw_right_out) (m) | Thickness in Wallhole (gs_trim_width_out) (m) | Nosing (gs_trim_jambext_nosing_out) (m) | Width Side 1 (gs_tw_right_in) (m) | Thickness in Wallhole (gs_trim_width_in) (m) | Offset (gs_trim_offs_in) (m) | Nosing (gs_trim_jambext_nosing_in) (m)
PI202 | 40.10.10.40 Fusteria interior (GuBIMclass CA); Door (ARCHICAD Classification) | 1.720,0×2.600,0 | 1.720,0×2.600,0 | 1.660,0×2.570,0 | 1.660,0×2.570,0 | 1.720,0×2.600,0×500,0 | Insulation - Fiber Hard | <Custom Text> | R | PI202 | 00_TABIQUE | Nau Lateral | T4 | Metal - Stainless Steel; Wood - Pine Grained Horizontal; Glass - Clear Fast | New | 1 | 0 | 3 | 2 | 8 | Simple Rebate | 3 | 46 | 4 | 3 | 1 | 0 | 19 | no | no | yes | yes | No Reveal - Edge | 1 | 90 | 0 | Transparent | Air Space | no | Wood - Pine Grained Horizontal | Glass - Clear Fast | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 2.40627 | 83 / 83 | NEW | 40.10.10.40 Fusteria interior | 40.10.10.40 | Fusteria interior | PI202_PortaIntTipusB | Porta de pi amb doble fulla de 72.5cm | Nau Lateral | Obra | No | R60 | 40 | PortaIntTipusB | 2.23604 | 17.8493 | 4.47208 | 1.72003 | 1.71425 | 0 | 4.31425 | 2.5 | 0.5 | 0.03 | 0.158783 | 11.0543 | 4.31425 | 13.6543 | 0 | 2.18276 | 0 | 1.72003 | 2.6 | 1.66003 | 2.57 | 1.66003 | 2.57 | 0.03 | 0 | 0.03 | 0.830016 | 0.03 | 0.15 | 0.15 | 0.012 | 0.025 | 0.06 | 0.03 | 0.05 | 0.03 | 0.03 | 0.04 | 0.03 | 0.012 | 0
PI201 | 40.10.10.40 Fusteria interior (GuBIMclass CA); Door (ARCHICAD Classification) | 1.720,0×2.600,0 | 1.720,0×2.600,0 | 1.660,0×2.570,0 | 1.684,0×2.582,0 | 1.720,0×2.600,0×80,0 | Insulation | <Custom Text> | L | PI201 | 00_TABIQUE | Nau Lateral | T1 | Metal - Stainless Steel; Wood - Pine Grained Horizontal; Glass - Clear Fast | New | 0 | 1 | 2 | 2 | 8 | Simple Rebate | 3 | 46 | 4 | 3 | 2 | 0 | 19 | no | yes | yes | no | No Reveal | 2 | 90 | 0 | Transparent | Air Space | no | Wood - Pine Grained Horizontal | Glass - Clear Fast | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 2.47376 | 84 / 84 | NEW | 40.10.10.40 Fusteria interior | 40.10.10.40 | Fusteria interior | PI201_PortaIntTipusB | Porta de pi amb doble fulla de 72.5cm | Nau Lateral | Obra | No | R60 | 40 | PortaIntTipusB | 0.357766 | 12.3164 | 4.47208 | 1.72003 | 1.71425 | 0 | 4.31425 | 2.5 | 0.08 | 0.14 | 0.100595 | 11.0543 | 4.31425 | 13.6543 | -0.03 | 2.18276 | 0 | 1.72003 | 2.6 | 1.66003 | 2.57 | 1.68403 | 2.582 | 0.03 | 0.012 | 0.04 | 0.842016 | 0.04 | 0.15 | 0.15 | 0.012 | 0.025 | 0.012 | 0.1 | 0.05 | 0.025 | 0.05 | 0.05 | 0.025 | 0.012 | 0.05
PE005 | 30.10.20.20 Portes de façanes (GuBIMclass CA) | 2.400,0×2.600,0 | 2.390,0×2.595,0 | 2.390,0×2.595,0 | 2.390,0×2.595,0 | 2.400,0×2.600,0×160,0 | Concrete 40-20 (2) | <Custom Text> | L | PE005 | 00_TABIQUE | Nau Santa Eulàlia | F1 | Metal - Stainless Steel; Wood - Pine Grained Horizontal; Glass - Clear Fast; Metal - Aluminium | New | 0 | 0 | 3 | 2 | 2 | Block | 1 | 46 | 4 | 3 | 1 | 18 | 0 | yes | no | no | no | No Reveal | 2 | 90 | 0 | Backgrounds - color 1 | Background | yes | Metal - Aluminium | Glass - Clear Fast | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 4.67103 | 1,20 / 1,20 | NEW | 30.10.20.20 Portes de façanes | 30.10.20.20 | Portes de façanes | PE005_PortaExtTipusZ | Porta doble baten | Nau Santa Eulalia | Obra | No | R60 | 30 | PortaExtTipusZ | 0.9984 | 16.4633 | 6.24 | 2.4 | 0.27 | 0 | 2.87 | 2.5 | 0.16 | 0.115 | 0.103757 | 9.61 | 2.87 | 12.21 | 0.08 | 1.893 | 0.005 | 2.39 | 2.595 | 2.39 | 2.595 | 2.39 | 2.595 | 0 | 0 | 0.083 | 1.195 | 0.065 | 0.09 | 0.147 | 0.012 | 0.025 | 0.026 | 0.1 | 0.06 | 0.005 | 0.03 | 0.05 | 0.005 | 0.005 | 0.03 | AC_Pset_Double_Door_27 - Opening Handle (gs_handle_type): Handle 8
DOO - 009 | 00.20 Preexistències (GuBIMclass CA) | 1.720,0×2.600,0 | 1.720,0×2.600,0 | 1.680,0×2.580,0 | 1.704,0×2.592,0 | 1.720,0×2.600,0×150,0 | Stone - Structural |  | L | DOO - 009 | 00_MURS PREEXISTENT |  | SW - 052 | Metal - Chrome 01 | Existing | 1 | 1 | 2 | 2 | 8 | Simple Rebate | 3 | 1 | 4 | 3 | 1 | 0 | 0 | no | yes | yes | no | No Reveal - Edge | 1 | 0 | 0 | Transparent | Air Space | yes | Metal - Chrome 01 | Glass - Clear Fast | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 0 | 85 / 85 | EXISTING | 00.20 Preexistències | 00.20 | Preexistències | DOO - 009_ |  | Nau Lateral | Preexistències |  |  | 00 |  | 0.670812 | 11.6022 | 4.47208 | 1.72003 | 1.71425 | 0 | 4.31425 | 2.5 | 0.15 | 0.14 | 0.192643 | 11.0543 | 4.31425 | 13.6543 | 0 | 2.18276 | 0 | 1.72003 | 2.6 | 1.68003 | 2.58 | 1.70403 | 2.592 | 0.02 | 0.012 | 0.04 | 0.852016 | 0.04 | 0.15 | 0.15 | 0.012 | 0.025 | 0.012 | 0.1 | 0.05 | 0.025 | 0.05 | 0.05 | 0.025 | 0.012 | 0.05
PE000 | 00.20 Preexistències (GuBIMclass CA) | 2.179,6×2.600,0 | 2.169,6×2.595,0 | 2.169,6×2.595,0 | 2.169,6×2.595,0 | 2.179,6×2.600,0×460,0 | Stone - Structural |  | R | PE000 | 00_MURS PREEXISTENT |  | SW - 052 | Metal - Nickel; Air | Existing | 0 | 1 | 2 | 3 | 2 | Block | 1 | 47 | 1 | 8 | 1 | 20 | 0 | no | yes | yes | no | No Reveal | 2 | 180 | 180 | Backgrounds - color 1 | Background | yes | Metal - Nickel | Air | Metal - Aluminium | Metal - Nickel | 4.84074 | 1,08 / 1,08 | EXISTING | 00.20 Preexistències | 00.20 | Preexistències | PE000_ |  | Nau Santa Eulalia | Preexistències |  |  | 00 |  | 2.60675 | 16.143 | 5.66686 | 2.17956 | 0.27 | 4.44089e-16 | 2.87 | 2.6 | 0.46 | 0.115 | 0.031904 | 9.61 | 2.865 | 12.205 | -0.1 | 2.058 | 0.005 | 2.16956 | 2.595 | 2.16956 | 2.595 | 2.16956 | 2.595 | 0 | 0 | 0.083 | 1.08478 | 0.065 | 0.03 | 0.03 | 0.01 | 0.01 | 0.026 | 0.1 | 0.06 | 0 | 0 | 0.05 | 0.025 | 0.012 | 0.05 | AC_Pset_Double_Door_27 - Opening Handle (gs_handle_type): Handle 10
PE003 | 30.10.20.20 Portes de façanes (GuBIMclass CA) | 2.400,0×2.600,0 | 2.390,0×2.595,0 | 2.390,0×2.595,0 | 2.390,0×2.595,0 | 2.400,0×2.600,0×160,0 | Concrete 40-20 (2) | <Custom Text> | R | PE003 | 00_TABIQUE | Nau Santa Eulàlia | F1 | Metal - Stainless Steel; Wood - Pine Grained Horizontal; Glass - Clear Fast; Metal - Aluminium | New | 0 | 0 | 3 | 2 | 2 | Block | 1 | 46 | 4 | 3 | 1 | 18 | 0 | yes | no | no | no | No Reveal | 2 | 90 | 0 | Backgrounds - color 1 | Background | yes | Metal - Aluminium | Glass - Clear Fast | Wood - Pine Grained Horizontal | Metal - Stainless Steel | 4.67103 | 1,20 / 1,20 | NEW | 30.10.20.20 Portes de façanes | 30.10.20.20 | Portes de façanes | PE003_PortaExtTipusZ | Porta doble baten | Nau Santa Eulalia | Obra | No | R60 | 30 | PortaExtTipusZ | 0.9984 | 16.4633 | 6.24 | 2.4 | 0.27 | 0 | 2.87 | 2.5 | 0.16 | 0.115 | 0.103757 | 9.61 | 2.87 | 12.21 | 0.08 | 1.893 | 0.005 | 2.39 | 2.595 | 2.39 | 2.595 | 2.39 | 2.595 | 0 | 0 | 0.083 | 1.195 | 0.065 | 0.09 | 0.147 | 0.012 | 0.025 | 0.026 | 0.1 | 0.06 | 0.005 | 0.03 | 0.05 | 0.005 | 0.005 | 0.03 | AC_Pset_Double_Door_27 - Opening Handle (gs_handle_type): Handle 8

# IfcBuildingElementProxy: Downspout Complex 27 (5)
In: planta baixa
Classification: 50.20.20.10 Canalitzacions d'aigües pluvials (GuBIMclass CA)
ArchiCADProperties - Surface: Roof Tiles - Dutch; Layer: 00_BAJADA ALL; Library Part Name: Downspout Complex 27; Building Material / Composite / Profile / Fill: Common Brick; Fill Type: Common Brick; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Surfaces (All): Roof Tiles - Dutch; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Downspout_Complex_27 - Show 2D Hotspots in 3D: no; Wall Angle: 0 deg; Downspout Profile: Round; Profile: 1; Elbow: no; Upper Angle: 0 deg; Lower Angle: 45 deg; Downspout Angle: 0 deg; Downspout Hanger: yes; Hanger Positioning: 2; Downspout Offset: yes; Upper Part Angle: 0 deg; Upper End Angle (gs_gutter_u_end_ang): 0 deg; Upper End Angle (up_end_ang_temp): 45 deg; Lower Part Angle: 0 deg; Lower End Angle (gs_gutter_l_end_ang): 0 deg; Lower End Angle (low_end_ang_temp): 45 deg; Head Leader (gs_head_leader): no; Head Leader Type (gs_gutter_hl_type): Type 1; Head Leader Type (gs_gutter_hl_type_m): 1; Head Leader Guard: no; 3D Detail Level: 3; Resolution: 30; Shadow: yes; Floor Plan Display (floorPlanDisplayType): Projected with Overhead; Floor Plan Display (iFloorPlanDisplayType): 2; Cut Pen: Objects - Cut Structural; Contour Pen: 2D Elements - Cut Structural; Line Type: 1; Overhead Line Type: 21; Fill Type: Air Space; Fill Pen: Transparent; Fill Background Pen: Transparent; Downspout (gs_gutter_ds_mat): Metal - Chrome 01; Bracket: Metal - Chrome 01; Head Leader (gs_gutter_hl_mat): Metal - Zinc; Guard: Metal - Stainless Steel; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 50.20.20.10 Canalitzacions d'aigües pluvials; 104.AMB.ClassificacioCodi: 50.20.20.10; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües pluvials; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 50
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Length (A): 0.15 m; Area: 0.0225 m2; Volume (Net): 0.000178331 m3; Width: 0.15 m; Top Surface Area (Net): 0.0225 m2
AC_Equantity_Downspout_Complex_27 - Dimension 1: 0.15 m; Dimension 2: 0.15 m; Bottom Level: 0 m; Profile Width (gs_gutter_aa): 0.05 m; Profile Width (gs_gutter_aa2): 0.1 m; Profile Depth (gs_gutter_bb): 0.05 m; Profile Depth (gs_gutter_bb2): 0.1 m; Profile Radius: 0.075 m; Profile Diameter: 0.15 m; Upper Part Length: 0.1 m; Lower Part Length: 0.15 m; Lower Part Offset: 0.053033 m; Offset of Hangers: 0.1 m; Distance Between Downspout Axis and Wall: 0.075 m; Upper Part Vert. Length: 0.2 m; Middle Part Vert. Length (gs_gutter_os_m_lgth): 0.4 m; Middle Part Vert. Length (gs_gutter_os_m_lgth_temp): 0.4 m; Head Leader Height: 0.22 m; Head Leader Width (HL_Width): 0.35 m; Head Leader Width (HL_Width2): 0.175 m; Head Leader Frame: 0.1 m; Head Leader Depth: 0.25 m
5 AMB.Geometria - 502.AMB.Amplada: 0.15 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000178331 m3; Component, Component Volume (Gross): 0.000178331 m3
Name | Rotation Angle (deg) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Colliding Zones | Page | Middle Part Angle (deg) | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_107.NomTipus | ArchiCADQuantities, Height (m) = AC_Equantity_Downspout_Complex_27, Height (m) = Top Level (m) = 503.AMB.Altura (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Surface Area (m2) = Bottom Surface Area (Net) (m2) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Survey Coordinate X (m) | Survey Coordinate Y (m) | Downspout Length (m) | Distance between Hangers (m) | Downspout Offset Length (m) | Horizontal Offset (m) | Lower Part Vert. Length (m)
Cu1 | 197.066 | Cu1 | Espai públic; Nau Santa Eulàlia | 4 | 51.3402 | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | CobertaR60 | 4.3368 | 0.267772 | 9.60777 | 2.36077 | 4.60458 | 13.9446 | 426570 | 4579794 | 3.4 | 0.5 | 0.936805 | 0.5 | 0.336805
Cu1 | 197.066 | Cu1 | Espai públic; Nau Santa Eulàlia | 4 | 51.3402 | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | CobertaR60 | 4.2 | 0.267772 | 9.60777 | 2.29642 | 4.46777 | 13.8078 | 426585 | 4579799 | 3.4 | 0.5 | 0.8 | 0.5 | 0.2
Cu1 | 197.066 | Cu1 | Espai públic; Nau Santa Eulàlia | 4 | 51.3402 | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | CobertaR60 | 4.2 | 0.291664 | 9.63166 | 2.29642 | 4.49166 | 13.8317 | 426539 | 4579785 | 3.4 | 0.5 | 0.8 | 0.5 | 0.2
Cu1 | 197.066 | Cu1 | Espai públic; Nau Santa Eulàlia | 4 | 51.3402 | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | CobertaR60 | 4.2 | 0.267772 | 9.60777 | 2.29642 | 4.46777 | 13.8078 | 426556 | 4579790 | 3.4 | 0.5 | 0.8 | 0.5 | 0.2
Cu5 | 103.328 | Cu5 | Espai públic; Nau Lateral | 2 | 50.1944 | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Coberta R60 | 6.05 | 1.35239 | 10.6924 | 3.15933 | 7.40239 | 16.7424 | 426536 | 4579805 | 5.25 | 0.8 | 0.8 | 0.48 | 0.2

# IfcBuildingElementProxy: F4_Enva 100, F4
In: planta baixa
Classification: Wall (ARCHICAD Classification); 40.10.10.10 Envans (GuBIMclass CA); Material: Brick
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 40.10.10.10 Envans; 104.AMB.ClassificacioCodi: 40.10.10.10; 105.AMB.ClassificacioDescripcio: Envans; 107.AMB.NomTipus: F4_Enva_100_Mao; 109.AMB.CodiTipus: F4; 111.AMB.DescripcioTipus: Envà de Maó; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40; AUX_107.NomTipus: Enva_100_Mao
Pset_BuildingElementProxyCommon - Status: NEW
Component Properties - Brick, Embodied Carbon: 270.266 (kgCO₂); Brick, Embodied Energy: 3378.33 MJ; Brick, Component Type: Core
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 2.7 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 2.7 m; Minimum Height of the Wall: 0 m; Maximum Height of the Wall Skin on the Outside Face: 2.7 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0.1 m; Wall Component Thickness on the Outside Face: 0.1 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Wall Component Volume on the Inside Face (Net): 0.750739 m3; Wall Component Volume on the Outside Face (Net): 0.750739 m3; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Average length of the Wall: 2.78084 m; Surface Area of the Wall Inside Face (Net): 7.50749 m2; Surface Area of the Wall Outside Face (Net): 7.50729 m2; Analytic Volume of the Openings: 0 m3; Length of Reference Line: 2.78084 m; Length of the Wall Inside Face (Conditional): 2.78084 m; Surface Area of the Wall Inside Face (Conditional): 7.50749 m2; Length of the Wall Outside Face (Conditional): 2.78084 m; Surface Area of the Wall Outside Face (Conditional): 7.50729 m2; Volume of the Wall Inside Face Component (Conditional): 0.750739 m3; Volume of the Wall Outside Face Component (Conditional): 0.750739 m3; Surface Area of the Wall Inside Face (Gross): 7.50826 m2; Surface Area of the Wall Outside Face (Gross): 7.50826 m2; End Thickness of the Wall: 0.1 m; Length of the Wall at the Center: 2.78084 m; Length of the Wall on the Inside Face: 2.78084 m; Length of the Wall on the Outside Face: 2.78084 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 0.278052 m2; Height: 2.7 m; Volume (Net): 0.750739 m3; Width: 0.1 m; Elevation to Project Zero: 1 m; Elevation to 1st Reference Level: 1 m; Elevation to 2nd Reference Level: 1 m; Elevation to Sea Level: 10.34 m; Elevation to Linked/Home Story: 1 m; Home Offset: 1 m; Top Offset: 0 m; Surface Area: 7.50729 m2; 3D Length: 2.78055 m; Thickness: 0.1 m; Volume (Conditional): 0.750739 m3; Volume (Gross): 0.750826 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 5.76167 m; Top Elevation To First Reference Level: 3.7 m; Top Elevation To Home Story: 3.7 m; Top Elevation To Project Zero: 3.7 m; Top Elevation To Sea Level: 13.04 m; Top Elevation To Second Reference Level: 3.7 m; Bottom Elevation To First Reference Level: 1 m; Bottom Elevation To Home Story: 1 m; Bottom Elevation To Project Zero: 1 m; Bottom Elevation To Sea Level: 10.34 m; Bottom Elevation To Second Reference Level: 1 m; Top Surface Area (Net): 0.278052 m2; Edge Surface Area (Net): 0.826103 m2; Bottom Surface Area (Net): 7.50729 m2
5 AMB.Geometria - 501.AMB.Longitud: 2.78084 m; 502.AMB.Amplada: 0.1 m; 503.AMB.Altura: 2.7 m; 504.AMB.Gruix: 0.1 m; 506.AMB.Profunditat: 0 m
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Inside Face; Inside Face Surface: Brick - Aged Natural; Outside Face Surface: Tiles - Terracota Rojo 10x20; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F4; Hotlink and Element ID: F4; Layer: 00_TABIQUE; Building Material / Composite / Profile / Fill: F4_Enva; Composite Structure: F4_Enva; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Composite; Parent ID: F4; Building Materials (All): Brick; Surfaces (All): Brick - Aged Natural; Tiles - Terracota Rojo 10x20; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Tiles - Terracota Rojo 10x20; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Brick, Mass: 1126.11 kg; Brick, Projected Component Area (Net): 7.50749 m2; Brick, Projected Component Area (Gross): 7.50749 m2; Brick, Component Thickness: 0.1 m; Brick, Rectangular Component Height: 2.7 m; Brick, Rectangular Component Width: 0.1 m; Brick, Component Cross Section Area: 0.27 m2; Brick, Component Volume (Net): 0.750739 m3; Brick, Component Volume (Gross): 0.750739 m3

# IfcBuildingElementProxy: Fire Hose Cabinet 27 (7)
In: planta baixa
Classification: 60.20.30 Mobiliari mòbil (GuBIMclass CA)
ArchiCADProperties - Surface: Roof Tiles - Dutch; Layer: 00_INCENDIOS; Library Part Name: Fire Hose Cabinet 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Fire_Hose_Cabinet_27 - 3D Detail Level: 3; Show Tools in Cabinet: yes; Placement Style: 1; Resolution: 24; Shadow: yes; Show 2D Hotspots in 3D: no; Contour Pen: Mechanical - General; Fill Type: Background; Fill Pen: Backgrounds - color 1; Fill Background Pen: Backgrounds - color 1; Display Text: no; Text: Fire Cabinet; Text Pen: Annotation Text - bold; Font Type: Arial; Font Size (mm): 12; Font Size (point): 34.0157; Font Style Bold: no; Font Style Italic: no; Font Style Underline: no; Text Orientation on Symbol (typeTextRotation): Readable; Text Orientation on Symbol (typeTextRotation_m): 2; Cabinet: Metal - Aluminium; Glass: Glass - Clear Fast; Metal: Metal - Stainless Steel; Rack: Paint - Vermilion; Hose: Plastic - Laminate; Squirt: Metal - Stainless Steel; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 60.20.30 Mobiliari mòbil; 104.AMB.ClassificacioCodi: 60.20.30; 105.AMB.ClassificacioDescripcio: Mobiliari mòbil; 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 60
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Width: 0.28 m
AC_Equantity_Fire_Hose_Cabinet_27 - Dimension 2: 0.28 m; Bottom Level: 1 m; Top Level: 0 m; Text Position X: 0 m; Text Position Y: 0 m
