Properties of the parts of a building model (IFC2X3), part 16 of 99

# IfcBuildingElementProxy: RHS100x100 100 x 100 (18)
Name | In | Classification | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Layer | Home Story Name = 115.AMB.Nivell | Home Story Number | Element Type | Slant Angle (deg) | Steel - Structural, Embodied Carbon | Steel - Structural, Embodied Energy (MJ) | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | Area (m2) | Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) = Steel - Structural, Component Volume (Net) (m3) = Steel - Structural, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) | Elevation to Sea Level (m) | Elevation to Linked/Home Story (m) = Home Offset (m) | Surface Area (m2) | 3D Length (m) | Volume (Gross) (m3) | Top Elevation To First Reference Level (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Home Story (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Home Story (m) | Bottom Elevation To Sea Level (m) | Cross Section Height at Top/End (cut) (m) = Cross Section Height at Bottom/Start (cut) (m) | Cross Section Area at Bottom/Start (m2) | Cross Section Area at Top/End (m2) | Top Surface Area (Net) (m2) | Bottom Surface Area (Net) (m2) | Steel - Structural, Mass (kg) | Beam Cross Section | Beam Slant Angle (deg) | Number of Openings = Hole Number = Holes Edge Surface Area (m2) = Holes Surface Area (m2) = Holes Volume (m3) = Offset (m) | Surface Area of Both Beam Ends (m2) | Surface Area of the Beam Left Side (Net) (m2) | Length Left (m) | Length Right (m) | Surface Area of the Beam Right Side (Net) (m2) | Volume (Conditional) (m3)
CRE - 008 | planta baixa | 20.20.10.10 Pilars (GuBIMclass CA) | CRE - 008 | 00_ACERO PILARES | planta baixa | 0 | Column | 90 | 56.9523 (kgCO₂) | 861.146 | 20.20.10.10 Pilars | 20.20.10.10 | Pilars | CRE - 008_ | 0.0019 | 2.31502 | 0.00439854 | 3.97822 | 13.3182 | 3.97822 | 1.75942 | 2.31502 | 0.00439854 | 6.29324 | 6.29324 | 15.6332 | 3.97822 | 3.97822 | 13.3182 | 0.1 | 0.0019 | 0.0019 | 0.0019 | 1.75942 | 34.3086 | ArchiCADProperties - Column Cross Section: Profiled; Column Slant Angle: 90 deg; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Colliding Zones: Nau Annexa; ArchiCADQuantities - Core Height / Diameter: 0.1 m; Volume of the Column Core (Net): 0.00439854 m3; Core Width: 0.1 m; Surface Area of the Column Core (Gross, without Top/Bottom): 1.75942 m2; Surface Area of the Column Core Top (Gross): 0.0019 m2; Surface Area of the Column Core Bottom (Gross): 0.0019 m2; Volume of the Column Core (Gross): 0.00439854 m3; Surface Area of the Column Veneer (Gross, without Top/Bottom): 0 m2; Surface Area of the Column Veneer Top (Gross): 0 m2; Surface Area of the Column Veneer Bottom (Gross): 0 m2; Volume of the Column Veneer (Gross): 0 m3; Maximum Height of the Column: 2.31502 m; Minimum Height of the Column: 2.31502 m; Surface Area of the Column Core Bottom (Net): 0.0019 m2; Surface Area of the Column Core (Net, without Top/Bottom): 1.75942 m2; Surface Area of the Column Core Top (Net): 0.0019 m2; Surface Area of the Column Veneer Bottom (Net): 0 m2; Surface Area of the Column Veneer (Net): 0 m2; Surface Area of the Column Veneer Top (Net): 0 m2; Perimeter of Column Profile (bottom): 0.4 m; Volume of the Column Veneer (Net): 0 m3; Top Offset: 1.44108 m; Top Surface Area (Gross): 0.0019 m2
Cu3 | planta coberta | 20.20.20.20 Jàsseres (GuBIMclass CA) | Cu3 | 00_ACERO VIGAS | planta coberta | 1 | Beam | 0 | 63.8336 (kgCO₂) | 965.194 | 20.20.20.20 Jàsseres | 20.20.20.20 | Jàsseres | Cu3_Coberta inclinada | 0.263724 | 0.1 | 0.00492999 | 4.84616 | 14.1862 | 0.346162 | 1.97776 | 2.76084 | 0.00528359 | 4.89616 | 0.396162 | 14.2362 | 4.79616 | 0.296162 | 14.1362 | 0.1 | 0 | 0 | 0.490359 | 0.500974 | 38.454 | Profiled | 0 | 0 | 0 | 0.490359 | 2.58084 | 2.58084 | 0.490359 | 0.00492999 | 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea, aïllament i acabat en contraxapat de pi; GENERAL PROPERTIES - AUX_107.NomTipus: Coberta inclinada
Cu3 | planta coberta | 20.20.20.40 Biguetes (GuBIMclass CA) | Cu3 | 00_ACERO VIGAS | planta coberta | 1 | Beam | -36.5 | 59.4519 (kgCO₂) | 898.942 | 20.20.20.40 Biguetes | 20.20.20.40 | Biguetes | Cu3_Coberta inclinada | 0.201116 | 0.1 | 0.00459159 | 6.32214 | 15.6621 | 1.82214 | 1.84832 | 2.56966 | 0.00475358 | 6.38434 | 1.88434 | 15.7243 | 4.77546 | 0.275461 | 14.1155 | 0.1244 | 0.000929782 | 0 | 0.473857 | 0.465525 | 35.8144 | Profiled | -36.5 | 0 | 0.000929782 | 0.448898 | 2.50188 | 2.50188 | 0.448741 | 0.00459159 | 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea, aïllament i acabat en contraxapat de pi; GENERAL PROPERTIES - AUX_107.NomTipus: Coberta inclinada
Cu3 | planta coberta | 20.20.20.40 Biguetes (GuBIMclass CA) | Cu3 | 00_ACERO VIGAS | planta coberta | 1 | Beam | -36.5 | 59.4307 (kgCO₂) | 898.62 | 20.20.20.40 Biguetes | 20.20.20.40 | Biguetes | Cu3_Coberta inclinada | 0.201116 | 0.1 | 0.00458995 | 6.32214 | 15.6621 | 1.82214 | 1.84791 | 2.56966 | 0.00475358 | 6.38434 | 1.88434 | 15.7243 | 4.77546 | 0.275461 | 14.1155 | 0.1244 | 0.000929782 | 0 | 0.473857 | 0.465401 | 35.8016 | Profiled | -36.5 | 0 | 0.000929782 | 0.448208 | 2.50188 | 2.50188 | 0.448898 | 0.00458995 | 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea, aïllament i acabat en contraxapat de pi; GENERAL PROPERTIES - AUX_107.NomTipus: Coberta inclinada
Cu3 | planta coberta | 20.20.20.20 Jàsseres (GuBIMclass CA) | Cu3 | 00_ACERO VIGAS | planta coberta | 1 | Beam | 0 | 63.9634 (kgCO₂) | 967.158 | 20.20.20.20 Jàsseres | 20.20.20.20 | Jàsseres | Cu3_Coberta inclinada | 0.261959 | 0.1 | 0.00494002 | 4.84616 | 14.1862 | 0.346162 | 1.98457 | 2.63084 | 0.00501759 | 4.89616 | 0.396162 | 14.2362 | 4.79616 | 0.296162 | 14.1362 | 0.1 | 0.000603679 | 0.000853679 | 0.497939 | 0.497268 | 38.5322 | Profiled | 0 | 0 | 0.00145736 | 0.490359 | 2.64084 | 2.64084 | 0.490359 | 0.00494002 | 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea, aïllament i acabat en contraxapat de pi; GENERAL PROPERTIES - AUX_107.NomTipus: Coberta inclinada
Cu3 | planta coberta | 20.20.20.10 Forjats (GuBIMclass CA) | Cu3 | 00_ACERO VIGAS | planta coberta | 1 | Beam | 0 | 66.7699 (kgCO₂) | 1009.59 | 20.20.20.10 Forjats | 20.20.20.10 | Forjats | Cu3_Coberta inclinada | 0.274964 | 0.1 | 0.00515677 | 6.29734 | 15.6373 | 1.79734 | 2.07265 | 2.77584 | 0.00518859 | 6.34734 | 1.84734 | 15.6873 | 6.24734 | 1.74734 | 15.5873 | 0.1 | 0.001875 | 0.00164556 | 0.521507 | 0.511412 | 40.2228 | Profiled | 0 | 0 | 0.00352056 | 0.51676 | 2.68084 | 2.58084 | 0.51265 | 0.00515677 | 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea, aïllament i acabat en contraxapat de pi; GENERAL PROPERTIES - AUX_107.NomTipus: Coberta inclinada
Cu3 | planta coberta | 20.20.20.20 Jàsseres (GuBIMclass CA) | Cu3 | 00_ACERO VIGAS | planta coberta | 1 | Beam | 0 | 93.0701 (kgCO₂) | 1407.26 | 20.20.20.20 Jàsseres | 20.20.20.20 | Jàsseres | Cu3_Coberta inclinada | 0.388105 | 0.1 | 0.00718799 | 4.84616 | 14.1862 | 0.346162 | 2.89669 | 3.89869 | 0.00744551 | 4.89616 | 0.396162 | 14.2362 | 4.79616 | 0.296162 | 14.1362 | 0.1 | 0.000493182 | 0.0009 | 0.734598 | 0.738437 | 56.0663 | Profiled | 0 | 0 | 0.00139318 | 0.70102 | 3.66205e-15 | 3.66205e-15 | 0.70102 | 0.00718799 | 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea, aïllament i acabat en contraxapat de pi; GENERAL PROPERTIES - AUX_107.NomTipus: Coberta inclinada
BMR - 006 | planta coberta | 20.20.20.20 Jàsseres (GuBIMclass CA) | BMR - 006 | 00_ACERO VIGAS | planta coberta | 1 | Beam | 0 | 93.8617 (kgCO₂) | 1419.23 | 20.20.20.20 Jàsseres | 20.20.20.20 | Jàsseres | BMR - 006_ | 0.391805 | 0.1 | 0.00724913 | 3.97822 | 13.3182 | -0.521783 | 2.91858 | 3.92869 | 0.00748351 | 4.02822 | -0.471783 | 13.3682 | 3.92822 | -0.571783 | 13.2682 | 0.1 | 0.0009 | 0.0009 | 0.742587 | 0.742587 | 56.5432 | Profiled | 0 | 0 | 0.0018 | 0.707239 | 3.93869 | 3.93869 | 0.707239 | 0.00724913 | ArchiCADProperties - Colliding Zones: Nau Annexa
BMR - 006 | planta coberta | 20.20.20.20 Jàsseres (GuBIMclass CA) | BMR - 006 | 00_ACERO VIGAS | planta coberta | 1 | Beam | 0 | 64.3074 (kgCO₂) | 972.359 | 20.20.20.20 Jàsseres | 20.20.20.20 | Jàsseres | BMR - 006_ | 0.264384 | 0.1 | 0.00496659 | 3.01371 | 12.3537 | -1.48629 | 1.99544 | 2.65084 | 0.00505559 | 3.06371 | -1.43629 | 12.4037 | 2.96371 | -1.53629 | 12.3037 | 0.1 | 0.0009 | 0.0009 | 0.502959 | 0.502959 | 38.7394 | Profiled | 0 | 0 | 0.0018 | 0.490359 | 2.66084 | 2.66084 | 0.490359 | 0.00496659 | ArchiCADProperties - Colliding Zones: Nau Annexa
Cu3 | planta coberta | 20.20.20.40 Biguetes (GuBIMclass CA) | Cu3 | 00_ACERO VIGAS | planta coberta | 1 | Beam | -36.5 | 59.69 (kgCO₂) | 902.542 | 20.20.20.40 Biguetes | 20.20.20.40 | Biguetes | Cu3_Coberta inclinada | 0.202646 | 0.1 | 0.00460998 | 6.32214 | 15.6621 | 1.82214 | 1.85499 | 2.58784 | 0.00472555 | 6.39516 | 1.89516 | 15.7352 | 4.77546 | 0.275461 | 14.1155 | 0.1244 | 0.00305759 | 0 | 0.465299 | 0.473968 | 35.9578 | Profiled | -36.5 | 0 | 0.00305759 | 0.462267 | 2.56408 | 2.43968 | 0.442708 | 0.00460998 | 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea, aïllament i acabat en contraxapat de pi; GENERAL PROPERTIES - AUX_107.NomTipus: Coberta inclinada
Cu3 | planta coberta | 20.20.20.40 Biguetes (GuBIMclass CA) | Cu3 | 00_ACERO VIGAS | planta coberta | 1 | Beam | -36.5 | 59.8117 (kgCO₂) | 904.382 | 20.20.20.40 Biguetes | 20.20.20.40 | Biguetes | Cu3_Coberta inclinada | 0.200592 | 0.1 | 0.00461938 | 6.31826 | 15.6583 | 1.81826 | 1.85778 | 2.56314 | 0.0047412 | 6.38046 | 1.88046 | 15.7205 | 4.77546 | 0.275461 | 14.1155 | 0.1244 | 0.00199187 | 0 | 0.47356 | 0.46896 | 36.0312 | Profiled | -36.5 | 0 | 0.00199187 | 0.452755 | 2.49537 | 2.49537 | 0.452755 | 0.00461938 | 1 AMB.Identificacio - 111.AMB.DescripcioTipus: Coberta amb teules Verea, aïllament i acabat en contraxapat de pi; GENERAL PROPERTIES - AUX_107.NomTipus: Coberta inclinada

# IfcBuildingElementProxy: Railing Type (2)
In: planta baixa
Classification: Railing (ARCHICAD Classification); 70.20.10 Tancaments de parcel·la (GuBIMclass CA)
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Element ID: TA1; Hotlink and Element ID: TA1; Layer: 00_PUERTA EXT METALICA; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Railing; Parent ID: TA1; Building Materials (All): Steel; Steel - Stainless; Surfaces (All): Metal - Nickel; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
5 AMB.Geometria - 503.AMB.Altura: 2.65 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Number of Balusters: 10; Number of Handrails: 0; Number of Inner Posts: 0; Number of Panels: 0; Number of Posts: 2; Number of Rails: 1; Number of Toprails: 1; Reference Line Horizontal Length: 1.66875 m; Area: 0.168875 m2; Height: 2.65 m; Volume (Net): 0.0691943 m3; Elevation to Project Zero: 0.00165359 m; Elevation to 1st Reference Level: 0.00165359 m; Elevation to 2nd Reference Level: 0.00165359 m; Elevation to Sea Level: 9.34165 m; Elevation to Linked/Home Story: 0.00165359 m; Home Offset: 0.00165359 m; 3D Length: 1.66875 m; Top Elevation To First Reference Level: 2.83165 m; Top Elevation To Home Story: 2.83165 m; Top Elevation To Project Zero: 2.83165 m; Top Elevation To Sea Level: 12.1717 m; Top Elevation To Second Reference Level: 2.83165 m; Bottom Elevation To First Reference Level: 0.00183192 m; Bottom Elevation To Home Story: 0.00183192 m; Bottom Elevation To Project Zero: 0.00183192 m; Bottom Elevation To Sea Level: 9.34183 m; Bottom Elevation To Second Reference Level: 0.00183192 m; Top Surface Area (Net): 0.168875 m2
Pset_BuildingElementProxyCommon - Status: NEW
1 AMB.Identificacio - 103.AMB.Classificacio: 70.20.10 Tancaments de parcel·la; 104.AMB.ClassificacioCodi: 70.20.10; 105.AMB.ClassificacioDescripcio: Tancaments de parcel·la; 107.AMB.NomTipus: TA1_TancatMetall.lica; 109.AMB.CodiTipus: TA1; 111.AMB.DescripcioTipus: Tancat metàl·llica practicable de 1,56 m de pas; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 70; AUX_107.NomTipus: TancatMetall.lica

# IfcBuildingElementProxy: Rhino_Object_10, Object_10
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_10; Hotlink and Element ID: Object_10; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_10; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_10; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_10 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Background; Fill Pen: Window Background; Fill Background Pen: Transparent; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 1; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 5; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_10_; 109.AMB.CodiTipus: Object_10; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_10 - Dimension 1: 21.684 m; Dimension 2: 1.93155 m; Height: 0.919907 m; Bottom Level: -1.88359e-07 m; Top Level: 0.919906 m
ArchiCADQuantities - Length (A): 21.684 m; Area: 41.8837 m2; Height: 0.919907 m; Volume (Net): 7.96217 m3; Width: 1.93155 m; Elevation to Project Zero: 5.86632 m; Elevation to 1st Reference Level: 5.86632 m; Elevation to 2nd Reference Level: 5.86632 m; Elevation to Sea Level: 15.2063 m; Elevation to Linked/Home Story: 5.86632 m; Home Offset: 5.86632 m; Surface Area: 62.8659 m2; Top Elevation To First Reference Level: 6.78623 m; Top Elevation To Home Story: 6.78623 m; Top Elevation To Project Zero: 6.78623 m; Top Elevation To Sea Level: 16.1262 m; Top Elevation To Second Reference Level: 6.78623 m; Bottom Elevation To First Reference Level: 5.86632 m; Bottom Elevation To Home Story: 5.86632 m; Bottom Elevation To Project Zero: 5.86632 m; Bottom Elevation To Sea Level: 15.2063 m; Bottom Elevation To Second Reference Level: 5.86632 m; Survey Coordinate X: 426569 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 15.2063 m; Top Surface Area (Net): 41.8837 m2; Bottom Surface Area (Net): 62.8659 m2
5 AMB.Geometria - 502.AMB.Amplada: 1.93155 m; 503.AMB.Altura: 0.919907 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 7.96217 m3; Component, Component Volume (Gross): 7.96217 m3

# IfcBuildingElementProxy: Rhino_Object_100, Object_100
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_100; Hotlink and Element ID: Object_100; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_100; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_100; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_100 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_100_; 109.AMB.CodiTipus: Object_100; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_100 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1004, Object_1004
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.5069 deg; Surface: Brick - Aged Natural; Element ID: Object_1004; Hotlink and Element ID: Object_1004; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1004; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1004; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1004 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1004_; 109.AMB.CodiTipus: Object_1004; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.918164 m; Area: 25.1086 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3465 m; Elevation to Project Zero: 5.90434 m; Elevation to 1st Reference Level: 5.90434 m; Elevation to 2nd Reference Level: 5.90434 m; Elevation to Sea Level: 15.2443 m; Elevation to Linked/Home Story: 5.90434 m; Home Offset: 5.90434 m; Surface Area: 0.443443 m2; Top Elevation To First Reference Level: 6.01088 m; Top Elevation To Home Story: 6.01088 m; Top Elevation To Project Zero: 6.01088 m; Top Elevation To Sea Level: 15.3509 m; Top Elevation To Second Reference Level: 6.01088 m; Bottom Elevation To First Reference Level: 5.90434 m; Bottom Elevation To Home Story: 5.90434 m; Bottom Elevation To Project Zero: 5.90434 m; Bottom Elevation To Sea Level: 15.2443 m; Bottom Elevation To Second Reference Level: 5.90434 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 15.2443 m; Top Surface Area (Net): 25.1086 m2; Bottom Surface Area (Net): 0.443443 m2
AC_Equantity_Rhino_Object_1004 - Dimension 1: 0.918164 m; Dimension 2: 27.3465 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3465 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1005, Object_1005
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.5069 deg; Surface: Brick - Aged Natural; Element ID: Object_1005; Hotlink and Element ID: Object_1005; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1005; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1005; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1005 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1005_; 109.AMB.CodiTipus: Object_1005; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.918164 m; Area: 25.1086 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3465 m; Elevation to Project Zero: 5.42103 m; Elevation to 1st Reference Level: 5.42103 m; Elevation to 2nd Reference Level: 5.42103 m; Elevation to Sea Level: 14.761 m; Elevation to Linked/Home Story: 5.42103 m; Home Offset: 5.42103 m; Surface Area: 0.454836 m2; Top Elevation To First Reference Level: 5.52757 m; Top Elevation To Home Story: 5.52757 m; Top Elevation To Project Zero: 5.52757 m; Top Elevation To Sea Level: 14.8676 m; Top Elevation To Second Reference Level: 5.52757 m; Bottom Elevation To First Reference Level: 5.42103 m; Bottom Elevation To Home Story: 5.42103 m; Bottom Elevation To Project Zero: 5.42103 m; Bottom Elevation To Sea Level: 14.761 m; Bottom Elevation To Second Reference Level: 5.42103 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579796 m; Survey Coordinate Z: 14.761 m; Top Surface Area (Net): 25.1086 m2; Bottom Surface Area (Net): 0.454836 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 27.3465 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3
AC_Equantity_Rhino_Object_1005 - Dimension 1: 0.918164 m; Dimension 2: 27.3465 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m

# IfcBuildingElementProxy: Rhino_Object_1006, Object_1006
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.5069 deg; Surface: Brick - Aged Natural; Element ID: Object_1006; Hotlink and Element ID: Object_1006; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1006; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1006; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1006 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1006_; 109.AMB.CodiTipus: Object_1006; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.918164 m; Area: 25.1086 m2; Height: 0.133178 m; Volume (Net): 0 m3; Width: 27.3465 m; Elevation to Project Zero: 4.99431 m; Elevation to 1st Reference Level: 4.99431 m; Elevation to 2nd Reference Level: 4.99431 m; Elevation to Sea Level: 14.3343 m; Elevation to Linked/Home Story: 4.99431 m; Home Offset: 4.99431 m; Surface Area: 0.426456 m2; Top Elevation To First Reference Level: 5.10085 m; Top Elevation To Home Story: 5.10085 m; Top Elevation To Project Zero: 5.10085 m; Top Elevation To Sea Level: 14.4409 m; Top Elevation To Second Reference Level: 5.10085 m; Bottom Elevation To First Reference Level: 4.99431 m; Bottom Elevation To Home Story: 4.99431 m; Bottom Elevation To Project Zero: 4.99431 m; Bottom Elevation To Sea Level: 14.3343 m; Bottom Elevation To Second Reference Level: 4.99431 m; Survey Coordinate X: 426589 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 14.3343 m; Top Surface Area (Net): 25.1086 m2; Bottom Surface Area (Net): 0.426456 m2
AC_Equantity_Rhino_Object_1006 - Dimension 1: 0.918164 m; Dimension 2: 27.3465 m; Height: 0.133178 m; Bottom Level: -0.0133179 m; Top Level: 0.119861 m
5 AMB.Geometria - 502.AMB.Amplada: 27.3465 m; 503.AMB.Altura: 0.133178 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0 m3; Component, Component Volume (Gross): 0 m3

# IfcBuildingElementProxy: Rhino_Object_1007, Object_1007
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.5069 deg; Surface: Brick - Aged Natural; Element ID: Object_1007; Hotlink and Element ID: Object_1007; Layer: 00_ORNAMENTOS CORNISAS; Library Part Name: Rhino_Object_1007; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1007; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1007 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 1; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 5; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1007_; 109.AMB.CodiTipus: Object_1007; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.694078 m; Area: 4.03475 m2; Height: 1.38308 m; Volume (Net): 1.04202 m3; Width: 5.81311 m; Elevation to Project Zero: 5.25682 m; Elevation to 1st Reference Level: 5.25682 m; Elevation to 2nd Reference Level: 5.25682 m; Elevation to Sea Level: 14.5968 m; Elevation to Linked/Home Story: 5.25682 m; Home Offset: 5.25682 m; Surface Area: 11.729 m2; Top Elevation To First Reference Level: 6.6399 m; Top Elevation To Home Story: 6.6399 m; Top Elevation To Project Zero: 6.6399 m; Top Elevation To Sea Level: 15.9799 m; Top Elevation To Second Reference Level: 6.6399 m; Bottom Elevation To First Reference Level: 5.25682 m; Bottom Elevation To Home Story: 5.25682 m; Bottom Elevation To Project Zero: 5.25682 m; Bottom Elevation To Sea Level: 14.5968 m; Bottom Elevation To Second Reference Level: 5.25682 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 14.5968 m; Top Surface Area (Net): 4.03475 m2; Bottom Surface Area (Net): 11.729 m2
AC_Equantity_Rhino_Object_1007 - Dimension 1: 0.694078 m; Dimension 2: 5.81311 m; Height: 1.38308 m; Bottom Level: -3.9712e-07 m; Top Level: 1.38308 m
5 AMB.Geometria - 502.AMB.Amplada: 5.81311 m; 503.AMB.Altura: 1.38308 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 1.04202 m3; Component, Component Volume (Gross): 1.04202 m3

# IfcBuildingElementProxy: Rhino_Object_1009, Object_1009
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADQuantities - Length (A): 0.0976616 m; Area: 0.148528 m2; Height: 0.156183 m; Volume (Net): 0.011856 m3; Width: 1.52084 m; Elevation to Project Zero: 6.01088 m; Elevation to 1st Reference Level: 6.01088 m; Elevation to 2nd Reference Level: 6.01088 m; Elevation to Sea Level: 15.3509 m; Elevation to Linked/Home Story: 6.01088 m; Home Offset: 6.01088 m; Surface Area: 0.64184 m2; Top Elevation To First Reference Level: 6.16706 m; Top Elevation To Home Story: 6.16706 m; Top Elevation To Project Zero: 6.16706 m; Top Elevation To Sea Level: 15.5071 m; Top Elevation To Second Reference Level: 6.16706 m; Bottom Elevation To First Reference Level: 6.01088 m; Bottom Elevation To Home Story: 6.01088 m; Bottom Elevation To Project Zero: 6.01088 m; Bottom Elevation To Sea Level: 15.3509 m; Bottom Elevation To Second Reference Level: 6.01088 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579794 m; Survey Coordinate Z: 15.3509 m; Top Surface Area (Net): 0.148528 m2; Bottom Surface Area (Net): 0.64184 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1009_; 109.AMB.CodiTipus: Object_1009; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 15.5069 deg; Surface: Brick - Aged Natural; Element ID: Object_1009; Hotlink and Element ID: Object_1009; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1009; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1009; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1009 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
5 AMB.Geometria - 502.AMB.Amplada: 1.52084 m; 503.AMB.Altura: 0.156183 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.011856 m3; Component, Component Volume (Gross): 0.011856 m3
AC_Equantity_Rhino_Object_1009 - Dimension 1: 0.0976616 m; Dimension 2: 1.52084 m; Height: 0.156183 m; Bottom Level: -1.06581e-14 m; Top Level: 0.156183 m

# IfcBuildingElementProxy: Rhino_Object_101, Object_101
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_101; Hotlink and Element ID: Object_101; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_101; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_101; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_101 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_101_; 109.AMB.CodiTipus: Object_101; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426580 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_101 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1011, Object_1011
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.5069 deg; Surface: Brick - Aged Natural; Element ID: Object_1011; Hotlink and Element ID: Object_1011; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1011; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1011; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1011 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1011_; 109.AMB.CodiTipus: Object_1011; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0545585 m; Area: 0.00805195 m2; Height: 0.352018 m; Volume (Net): 0.00257039 m3; Width: 0.147584 m; Elevation to Project Zero: 4.90483 m; Elevation to 1st Reference Level: 4.90483 m; Elevation to 2nd Reference Level: 4.90483 m; Elevation to Sea Level: 14.2448 m; Elevation to Linked/Home Story: 4.90483 m; Home Offset: 4.90483 m; Surface Area: 0.15262 m2; Top Elevation To First Reference Level: 5.25685 m; Top Elevation To Home Story: 5.25685 m; Top Elevation To Project Zero: 5.25685 m; Top Elevation To Sea Level: 14.5969 m; Top Elevation To Second Reference Level: 5.25685 m; Bottom Elevation To First Reference Level: 4.90483 m; Bottom Elevation To Home Story: 4.90483 m; Bottom Elevation To Project Zero: 4.90483 m; Bottom Elevation To Sea Level: 14.2448 m; Bottom Elevation To Second Reference Level: 4.90483 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579797 m; Survey Coordinate Z: 14.2448 m; Top Surface Area (Net): 0.00805195 m2; Bottom Surface Area (Net): 0.15262 m2
AC_Equantity_Rhino_Object_1011 - Dimension 1: 0.0545585 m; Dimension 2: 0.147584 m; Height: 0.352018 m; Bottom Level: -8.88178e-16 m; Top Level: 0.352018 m
5 AMB.Geometria - 502.AMB.Amplada: 0.147584 m; 503.AMB.Altura: 0.352018 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00257039 m3; Component, Component Volume (Gross): 0.00257039 m3

# IfcBuildingElementProxy: Rhino_Object_1012, Object_1012
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 15.5069 deg; Surface: Brick - Aged Natural; Element ID: Object_1012; Hotlink and Element ID: Object_1012; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1012; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1012; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1012 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1012_; 109.AMB.CodiTipus: Object_1012; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.100076 m; Area: 0.159897 m2; Height: 0.156192 m; Volume (Net): 0.0124562 m3; Width: 1.59776 m; Elevation to Project Zero: 5.52757 m; Elevation to 1st Reference Level: 5.52757 m; Elevation to 2nd Reference Level: 5.52757 m; Elevation to Sea Level: 14.8676 m; Elevation to Linked/Home Story: 5.52757 m; Home Offset: 5.52757 m; Surface Area: 0.673545 m2; Top Elevation To First Reference Level: 5.68376 m; Top Elevation To Home Story: 5.68376 m; Top Elevation To Project Zero: 5.68376 m; Top Elevation To Sea Level: 15.0238 m; Top Elevation To Second Reference Level: 5.68376 m; Bottom Elevation To First Reference Level: 5.52757 m; Bottom Elevation To Home Story: 5.52757 m; Bottom Elevation To Project Zero: 5.52757 m; Bottom Elevation To Sea Level: 14.8676 m; Bottom Elevation To Second Reference Level: 5.52757 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579796 m; Survey Coordinate Z: 14.8676 m; Top Surface Area (Net): 0.159897 m2; Bottom Surface Area (Net): 0.673545 m2
AC_Equantity_Rhino_Object_1012 - Dimension 1: 0.100076 m; Dimension 2: 1.59776 m; Height: 0.156192 m; Bottom Level: -1.15463e-14 m; Top Level: 0.156192 m
5 AMB.Geometria - 502.AMB.Amplada: 1.59776 m; 503.AMB.Altura: 0.156192 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0124562 m3; Component, Component Volume (Gross): 0.0124562 m3

# IfcBuildingElementProxy: Rhino_Object_1013, Object_1013
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1013 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1013_; 109.AMB.CodiTipus: Object_1013; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 15.5069 deg; Surface: Brick - Aged Natural; Element ID: Object_1013; Hotlink and Element ID: Object_1013; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1013; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1013; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
ArchiCADQuantities - Length (A): 0.104824 m; Area: 0.18334 m2; Height: 0.15621 m; Volume (Net): 0.0132518 m3; Width: 1.74903 m; Elevation to Project Zero: 5.10085 m; Elevation to 1st Reference Level: 5.10085 m; Elevation to 2nd Reference Level: 5.10085 m; Elevation to Sea Level: 14.4409 m; Elevation to Linked/Home Story: 5.10085 m; Home Offset: 5.10085 m; Surface Area: 0.720502 m2; Top Elevation To First Reference Level: 5.25706 m; Top Elevation To Home Story: 5.25706 m; Top Elevation To Project Zero: 5.25706 m; Top Elevation To Sea Level: 14.5971 m; Top Elevation To Second Reference Level: 5.25706 m; Bottom Elevation To First Reference Level: 5.10085 m; Bottom Elevation To Home Story: 5.10085 m; Bottom Elevation To Project Zero: 5.10085 m; Bottom Elevation To Sea Level: 14.4409 m; Bottom Elevation To Second Reference Level: 5.10085 m; Survey Coordinate X: 426590 m; Survey Coordinate Y: 4579798 m; Survey Coordinate Z: 14.4409 m; Top Surface Area (Net): 0.18334 m2; Bottom Surface Area (Net): 0.720502 m2
AC_Equantity_Rhino_Object_1013 - Dimension 1: 0.104824 m; Dimension 2: 1.74903 m; Height: 0.15621 m; Bottom Level: -1.24345e-14 m; Top Level: 0.15621 m
5 AMB.Geometria - 502.AMB.Amplada: 1.74903 m; 503.AMB.Altura: 0.15621 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0132518 m3; Component, Component Volume (Gross): 0.0132518 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1015, Object_1015
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 12.6171 deg; Surface: Brick - Aged Natural; Element ID: Object_1015; Hotlink and Element ID: Object_1015; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1015; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1015; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1015 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1015_; 109.AMB.CodiTipus: Object_1015; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.11677 m; Area: 0.0152662 m2; Height: 0.06 m; Volume (Net): 0.000441053 m3; Width: 0.130737 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0355942 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426588 m; Survey Coordinate Y: 4579800 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0152662 m2; Bottom Surface Area (Net): 0.0355942 m2
AC_Equantity_Rhino_Object_1015 - Dimension 1: 0.11677 m; Dimension 2: 0.130737 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.130737 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000441053 m3; Component, Component Volume (Gross): 0.000441053 m3

# IfcBuildingElementProxy: Rhino_Object_1016, Object_1016
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
