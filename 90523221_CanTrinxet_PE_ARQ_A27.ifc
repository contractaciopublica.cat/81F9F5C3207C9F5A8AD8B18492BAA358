Properties of the parts of a building model (IFC2X3), part 12 of 99

# IfcBuildingElementProxy: Gypsum Plasterboard 30 (373)
Name | Reference Line Location | Inside Face Surface = Edge Surface | Outside Face Surface | Element ID = Hotlink and Element ID = Parent ID | Colliding Zones | Surfaces (All) | Number of Openings | 107.AMB.NomTipus | 109.AMB.CodiTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_107.NomTipus | Gypsum Plasterboard, Embodied Carbon | Gypsum Plasterboard, Embodied Energy (MJ) | Number of Windows | Maximum Height of the Wall (m) | Minimum Height of the Wall (m) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Surface Area of the Wall Inside Face (Conditional) (m2) | Length of the Wall Outside Face (Conditional) (m) | Surface Area of the Wall Outside Face (Conditional) (m2) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = Gypsum Plasterboard, Rectangular Component Height (m) | Volume (Net) (m3) = Gypsum Plasterboard, Component Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | 3D Length (m) | Volume (Conditional) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | 503.AMB.Altura (m) | Gypsum Plasterboard, Mass (kg) | Gypsum Plasterboard, Projected Component Area (Net) (m2) | Gypsum Plasterboard, Projected Component Area (Gross) (m2) | Gypsum Plasterboard, Component Cross Section Area (m2) | Gypsum Plasterboard, Component Volume (Gross) (m3)
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 19.2221 (kgCO₂) | 332.69 | 0 | 2.21938 | 2.21938 | 0.617537 | 0.617537 | 0.859 | 1.82546 | 1.82546 | 0.0185261 | 0.859 | 0 | 2.443 | 0 | 2.443 | 2.443 | 2.443 | 0.859 | 0.859 | 0 | 2.844 | 0.0547638 | 4.31625 | 13.6563 | 0.859 | 0.0732899 | 0.0732899 | 1.778 | 7.16025 | 16.5003 | 4.94087 | 14.2809 | 0.154712 | 2.844 | 49.2874 | 1.82546 | 2.443 | 0.08532 | 0.0732899 | ArchiCADProperties - ID of Connected Openings: OP - 003
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 17.2557 (kgCO₂) | 298.656 | 0 | 0.952742 | 0.952742 | 0 | 0 | 1.72 | 1.63872 | 1.63872 | 0 | 1.72 | 1.72 | 1.63872 | 1.72 | 1.63872 | 1.63872 | 1.63872 | 1.72 | 1.72 | 0.0516 | 0.952742 | 0.0491615 | 1.71425 | 11.0543 | 1.72 | 0.0491615 | 0.0491615 | 3.5 | 2.66699 | 12.007 | 1.71425 | 11.0543 | 0.160364 | 0.952742 | 44.2453 | 1.63872 | 1.63872 | 0.0285822 | 0.0491615
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 17.2557 (kgCO₂) | 298.656 | 0 | 0.952742 | 0.952742 | 0 | 0 | 1.72 | 1.63872 | 1.63872 | 0 | 1.72 | 1.72 | 1.63872 | 1.72 | 1.63872 | 1.63872 | 1.63872 | 1.72 | 1.72 | 0.0516 | 0.952742 | 0.0491615 | 1.71425 | 11.0543 | 1.72 | 0.0491615 | 0.0491615 | 3.5 | 2.66699 | 12.007 | 1.71425 | 11.0543 | 0.160364 | 0.952742 | 44.2453 | 1.63872 | 1.63872 | 0.0285822 | 0.0491615
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 38.4224 (kgCO₂) | 665.003 | 0 | 2.844 | 2.844 | 0 | 0 | 1.283 | 3.64885 | 3.64885 | 0 | 1.283 | 1.283 | 3.64885 | 1.283 | 3.64885 | 3.64885 | 3.64885 | 1.283 | 1.283 | 0.03849 | 2.844 | 0.109466 | 4.31625 | 13.6563 | 1.283 | 0.109466 | 0.109466 | 2.626 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.24762 | 2.844 | 98.519 | 3.64885 | 3.64885 | 0.08532 | 0.109466
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 10.0298 (kgCO₂) | 173.593 | 0 | 2.844 | 2.844 | 0 | 0 | 0.334915 | 0.952497 | 0.952497 | 0 | 0.334915 | 0.334915 | 0.952497 | 0.334915 | 0.952497 | 0.952497 | 0.952497 | 0.334915 | 0.334915 | 0.0100474 | 2.844 | 0.0285749 | 4.31625 | 13.6563 | 0.334915 | 0.0285749 | 0.0285749 | 0.729829 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.190735 | 2.844 | 25.7174 | 0.952497 | 0.952497 | 0.08532 | 0.0285749
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 10.4585 (kgCO₂) | 181.012 | 0 | 1.92512 | 0 | 0.54428 | 0.54428 | 0.859 | 0.993212 | 0.993205 | 0.0163284 | 0.859 | 0.859 | 1.53749 | 0.859 | 1.53748 | 1.75744 | 1.75744 | 0.859 | 0.859 | 0.0221942 | 2.844 | 0.0297963 | 7.16228 | 16.5023 | 0.859 | 0.0461247 | 0.0527232 | 1.778 | 9.0874 | 18.4274 | 7.16228 | 16.5023 | 0.0940484 | 2.844 | 26.8166 | 0.993205 | 1.75744 | 0.08532 | 0.0527232 | ArchiCADProperties - ID of Connected Openings: OP - 003
F5 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F5 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 35.099 (kgCO₂) | 607.482 | 0 | 2.598 | 2.598 | 0 | 0 | 1.283 | 3.33323 | 3.33323 | 0 | 1.283 | 1.283 | 3.33323 | 1.283 | 3.33323 | 3.33323 | 3.33323 | 1.283 | 1.283 | 0.03849 | 2.598 | 0.099997 | 1.71425 | 11.0543 | 1.283 | 0.099997 | 0.099997 | 2.626 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.23286 | 2.598 | 89.9973 | 3.33323 | 3.33323 | 0.07794 | 0.099997
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 6.97773 (kgCO₂) | 120.768 | 0 | 2.03131 | 1.92583 | 0 | 0 | 0.334915 | 0.662653 | 0.662651 | 0 | 0.334915 | 0.334915 | 0.662653 | 0.334915 | 0.662651 | 0.74841 | 0.748407 | 0.334915 | 0.334915 | 0.0100474 | 2.81803 | 0.0198796 | 7.16228 | 16.5023 | 0.334915 | 0.0198796 | 0.0224522 | 0.729829 | 9.19359 | 18.5336 | 7.16228 | 16.5023 | 0.128762 | 2.81803 | 17.8916 | 0.662651 | 0.748407 | 0.0845408 | 0.0224522 | ArchiCADProperties - ID of Connected Openings: OP - 003
2 x Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 16.7151 (kgCO₂) | 289.3 | 0 | 2.598 | 2.598 | 0 | 0 | 0.611 | 1.58738 | 1.58738 | 0 | 0.611 | 0.611 | 1.58738 | 0.611 | 1.58738 | 1.58738 | 1.58738 | 0.611 | 0.611 | 0.01833 | 2.598 | 0.0476213 | 1.71425 | 11.0543 | 0.611 | 0.0476213 | 0.0476213 | 1.282 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.19254 | 2.598 | 42.8592 | 1.58738 | 1.58738 | 0.07794 | 0.0476213
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 5.28787 (kgCO₂) | 91.5209 | 0 | 0.753355 | 0.742901 | 0.082864 | 0.082864 | 0.782 | 0.505866 | 0.498478 | 0.00248592 | 0.782 | 0 | 0.58873 | 0 | 0.581342 | 0.782591 | 0.782591 | 0.782 | 0.782 | 0 | 1.00076 | 0.0150652 | 6.16152 | 15.5015 | 0.782 | 0.0175511 | 0.0234777 | 1.624 | 6.91488 | 16.2549 | 6.16152 | 15.5015 | 0.0403139 | 1.00076 | 13.5586 | 0.505866 | 0.782591 | 0.0300227 | 0.0234777 | ArchiCADProperties - ID of Connected Openings: OP - 003
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 18.2629 (kgCO₂) | 316.088 | 0 | 2.09295 | 2.08236 | 0.585937 | 0.585937 | 0.892 | 1.73858 | 1.73015 | 0.0175781 | 0.892 | 0 | 2.32451 | 0 | 2.31609 | 2.54044 | 2.54044 | 0.892 | 0.892 | 0 | 2.84803 | 0.0520309 | 4.31425 | 13.6543 | 0.892 | 0.069609 | 0.0762132 | 1.844 | 6.92079 | 16.2608 | 4.82783 | 14.1678 | 0.118872 | 2.84803 | 46.8278 | 1.73858 | 2.54044 | 0.0854408 | 0.0762132 | ArchiCADProperties - ID of Connected Openings: OP - 003
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 18.2537 (kgCO₂) | 315.929 | 0 | 2.09183 | 2.08124 | 0.585781 | 0.585781 | 0.892 | 1.73771 | 1.72928 | 0.0175734 | 0.892 | 0 | 2.32349 | 0 | 2.31506 | 2.54044 | 2.54044 | 0.892 | 0.892 | 0 | 2.84803 | 0.0520048 | 4.31425 | 13.6543 | 0.892 | 0.0695782 | 0.0762132 | 1.844 | 6.91963 | 16.2596 | 4.8278 | 14.1678 | 0.118809 | 2.84803 | 46.8043 | 1.73771 | 2.54044 | 0.0854408 | 0.0762132 | ArchiCADProperties - ID of Connected Openings: OP - 003
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 38.4224 (kgCO₂) | 665.003 | 0 | 2.844 | 2.844 | 0 | 0 | 1.283 | 3.64885 | 3.64885 | 0 | 1.283 | 1.283 | 3.64885 | 1.283 | 3.64885 | 3.64885 | 3.64885 | 1.283 | 1.283 | 0.03849 | 2.844 | 0.109466 | 4.31625 | 13.6563 | 1.283 | 0.109466 | 0.109466 | 2.626 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.24762 | 2.844 | 98.519 | 3.64885 | 3.64885 | 0.08532 | 0.109466
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 5.28396 (kgCO₂) | 91.4532 | 0 | 0.751732 | 0.741277 | 0.0824461 | 0.0824461 | 0.782 | 0.505495 | 0.498107 | 0.00247338 | 0.782 | 0 | 0.587941 | 0 | 0.580553 | 0.782591 | 0.782591 | 0.782 | 0.782 | 0 | 1.00076 | 0.015054 | 6.16152 | 15.5015 | 0.782 | 0.0175274 | 0.0234777 | 1.624 | 6.91387 | 16.2539 | 6.16214 | 15.5021 | 0.0402211 | 1.00076 | 13.5486 | 0.505495 | 0.782591 | 0.0300227 | 0.0234777 | ArchiCADProperties - ID of Connected Openings: OP - 003
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 5.91619 (kgCO₂) | 102.396 | 0 | 0.398128 | 0.398128 | 0 | 0 | 1.41121 | 0.561841 | 0.561841 | 0 | 1.41121 | 1.41121 | 0.561841 | 1.41121 | 0.561841 | 0.897527 | 0.897527 | 1.41121 | 1.41121 | 0.0423362 | 0.636 | 0.0168552 | 4.31625 | 13.6563 | 1.41121 | 0.0168552 | 0.0269258 | 2.88241 | 4.71438 | 14.0544 | 4.31625 | 13.6563 | 0.0662239 | 0.636 | 15.1697 | 0.561841 | 0.80721 | 0.01908 | 0.0242163
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 38.2266 (kgCO₂) | 661.614 | 0 | 2.60423 | 2.59298 | 0 | 0 | 1.397 | 3.63685 | 3.62365 | 0 | 1.397 | 1.397 | 3.63685 | 1.397 | 3.62365 | 3.9787 | 3.9787 | 1.397 | 1.397 | 0.04191 | 2.84803 | 0.108908 | 4.31425 | 13.6543 | 1.397 | 0.108908 | 0.119361 | 2.854 | 6.91848 | 16.2585 | 4.31425 | 13.6543 | 0.197826 | 2.84803 | 98.0168 | 3.63685 | 3.9787 | 0.0854408 | 0.119361
2 x T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 5.79421 (kgCO₂) | 100.284 | 0 | 0.398128 | 0.398128 | 0 | 0 | 1.38211 | 0.550258 | 0.550258 | 0 | 1.38211 | 1.38211 | 0.550258 | 1.38211 | 0.550258 | 0.879022 | 0.879022 | 1.38211 | 1.38211 | 0.0414633 | 0.636 | 0.0165077 | 4.31625 | 13.6563 | 1.38211 | 0.0165077 | 0.0263707 | 2.82422 | 4.71438 | 14.0544 | 4.31625 | 13.6563 | 0.065351 | 0.636 | 14.857 | 0.550258 | 0.790567 | 0.01908 | 0.023717
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 5.78031 (kgCO₂) | 100.044 | 0 | 0.398128 | 0 | 0 | 0 | 1.40879 | 0.548937 | 0.548937 | 0 | 1.40879 | 1.40879 | 0.548937 | 1.40879 | 0.548937 | 0.895993 | 0.895993 | 1.40879 | 1.40879 | 0.0413638 | 0.636 | 0.0164681 | 4.31625 | 13.6563 | 1.37879 | 0.0164681 | 0.0268798 | 2.87759 | 4.71438 | 14.0544 | 4.31625 | 13.6563 | 0.0533077 | 0.636 | 14.8213 | 0.548937 | 0.78867 | 0.01908 | 0.0236601
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral; Sala de reunions | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 7.27079 (kgCO₂) | 125.841 | 0 | 0.398128 | 0 | 0 | 0 | 1.76432 | 0.690483 | 0.690483 | 0 | 1.76432 | 1.76432 | 0.690483 | 1.76432 | 0.690483 | 1.12211 | 1.12211 | 1.76432 | 1.76432 | 0.0520297 | 0.636 | 0.0207145 | 4.31625 | 13.6563 | 1.73432 | 0.0207145 | 0.0336633 | 3.58865 | 4.71438 | 14.0544 | 4.31625 | 13.6563 | 0.0639735 | 0.636 | 18.6431 | 0.690483 | 0.992033 | 0.01908 | 0.029761
Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 16.6877 (kgCO₂) | 288.826 | 0 | 2.598 | 2.598 | 0 | 0 | 0.61 | 1.58478 | 1.58478 | 0 | 0.61 | 0.61 | 1.58478 | 0.61 | 1.58478 | 1.58478 | 1.58478 | 0.61 | 0.61 | 0.0183 | 2.598 | 0.0475434 | 1.71425 | 11.0543 | 0.61 | 0.0475434 | 0.0475434 | 1.28 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.19248 | 2.598 | 42.7891 | 1.58478 | 1.58478 | 0.07794 | 0.0475434
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 5.44586 (kgCO₂) | 94.2552 | 0 | 0.398128 | 0 | 0 | 0 | 1.22902 | 0.517175 | 0.517175 | 0 | 1.22902 | 1.22902 | 0.517175 | 1.22902 | 0.517175 | 0.845254 | 0.845254 | 1.22902 | 1.22902 | 0.0389705 | 0.636 | 0.0155153 | 4.31625 | 13.6563 | 1.29902 | 0.0155153 | 0.0253576 | 2.51803 | 4.71438 | 14.0544 | 4.31625 | 13.6563 | 0.0509143 | 0.636 | 13.9637 | 0.517175 | 0.743037 | 0.01908 | 0.0222911
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral; Sala de reunions | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 5.13669 (kgCO₂) | 88.9042 | 0 | 0.398128 | 0.398128 | 0 | 0 | 1.22527 | 0.487814 | 0.487814 | 0 | 1.22527 | 1.22527 | 0.487814 | 1.22527 | 0.487814 | 0.779271 | 0.779271 | 1.22527 | 1.22527 | 0.0367581 | 0.636 | 0.0146344 | 4.31625 | 13.6563 | 1.22527 | 0.0146344 | 0.0233781 | 2.51054 | 4.71438 | 14.0544 | 4.31625 | 13.6563 | 0.0606458 | 0.636 | 13.171 | 0.487814 | 0.700854 | 0.01908 | 0.0210256
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 5.91113 (kgCO₂) | 102.308 | 0 | 0.398128 | 0.398128 | 0 | 0 | 1.41 | 0.561361 | 0.561361 | 0 | 1.41 | 1.41 | 0.561361 | 1.41 | 0.561361 | 0.89676 | 0.89676 | 1.41 | 1.41 | 0.0423 | 0.636 | 0.0168408 | 4.31625 | 13.6563 | 1.41 | 0.0168408 | 0.0269028 | 2.88 | 4.71438 | 14.0544 | 4.31625 | 13.6563 | 0.0661877 | 0.636 | 15.1568 | 0.561361 | 0.80652 | 0.01908 | 0.0241956
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 36.9774 (kgCO₂) | 639.993 | 0 | 2.6 | 0 | 0 | 0 | 1.35062 | 3.51456 | 3.50869 | 0 | 1.37958 | 1.35175 | 3.51456 | 1.3495 | 3.50869 | 3.59278 | 3.58691 | 1.35175 | 1.3495 | 0.0405187 | 2.6 | 0.105349 | 0.27 | 9.61 | 1.35175 | 0.105349 | 0.107695 | 2.76133 | 2.87 | 12.21 | 0.27 | 9.61 | 0.159037 | 2.44 | 94.8138 | 3.51456 | 3.51456 | 0.078 | 0.105349
2 x T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Extradossat_170 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_170 | 12.2802 (kgCO₂) | 212.541 | 0 | 0.867714 | 0.867714 | 0 | 0 | 1.344 | 1.16621 | 1.16621 | 0 | 1.344 | 1.344 | 1.16621 | 1.344 | 1.16621 | 1.16621 | 1.16621 | 1.344 | 1.344 | 0.04032 | 0.867714 | 0.0349862 | 2.872 | 12.212 | 1.344 | 0.0349862 | 0.0349862 | 2.748 | 3.73971 | 13.0797 | 2.872 | 12.212 | 0.132703 | 2.44 | 31.4876 | 1.16621 | 1.16621 | 0.0260314 | 0.0349862
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 13.5795 (kgCO₂) | 235.03 | 0 | 2.6 | 2.6 | 0 | 0 | 0.496 | 1.2896 | 1.2896 | 0 | 0.496 | 0.496 | 1.2896 | 0.496 | 1.2896 | 1.2896 | 1.2896 | 0.496 | 0.496 | 0.01488 | 2.6 | 0.038688 | 0.27 | 9.61 | 0.496 | 0.038688 | 0.038688 | 1.052 | 2.87 | 12.21 | 0.27 | 9.61 | 0.18576 | 2.44 | 34.8192 | 1.2896 | 1.2896 | 0.078 | 0.038688
F5 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F5 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 9.16224 (kgCO₂) | 158.577 | 0 | 2.598 | 2.598 | 0 | 0 | 0.334915 | 0.870108 | 0.870108 | 0 | 0.334915 | 0.334915 | 0.870108 | 0.334915 | 0.870108 | 0.870108 | 0.870108 | 0.334915 | 0.334915 | 0.0100474 | 2.598 | 0.0261032 | 1.71425 | 11.0543 | 0.334915 | 0.0261032 | 0.0261032 | 0.729829 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.175975 | 2.598 | 23.4929 | 0.870108 | 0.870108 | 0.07794 | 0.0261032
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 37.0743 (kgCO₂) | 641.671 | 0 | 2.6 | 0 | 0 | 0 | 1.35416 | 3.52324 | 3.51841 | 0 | 1.38329 | 1.35509 | 3.52324 | 1.35324 | 3.51841 | 3.60139 | 3.59656 | 1.35509 | 1.35324 | 0.0406249 | 2.6 | 0.105625 | 0.27 | 9.61 | 1.35509 | 0.105625 | 0.107969 | 2.76839 | 2.87 | 12.21 | 0.27 | 9.61 | 0.15925 | 2.44 | 95.0623 | 3.52324 | 3.52324 | 0.078 | 0.105625
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 24.1602 (kgCO₂) | 418.158 | 0 | 2.59808 | 0 | 0 | 0 | 0.913061 | 2.29442 | 2.37204 | 0 | 0.913 | 0.913123 | 2.29442 | 0.913 | 2.37204 | 2.58021 | 2.57989 | 0.913123 | 0.913 | 0.0264937 | 2.59808 | 0.0688326 | 4.31625 | 13.6563 | 0.913 | 0.0688326 | 0.0774015 | 1.88612 | 6.91433 | 16.2543 | 4.31625 | 13.6563 | 0.13093 | 2.59808 | 61.9493 | 2.37204 | 2.37204 | 0.0779423 | 0.0688326
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 26.1867 (kgCO₂) | 453.231 | 0 | 2.598 | 2.598 | 0 | 0 | 0.957222 | 2.48686 | 2.48686 | 0 | 0.957222 | 0.957222 | 2.48686 | 0.957222 | 2.48686 | 2.48686 | 2.48686 | 0.957222 | 0.957222 | 0.0287167 | 2.598 | 0.0746059 | 1.71425 | 11.0543 | 0.957222 | 0.0746059 | 0.0746059 | 1.97444 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.213313 | 2.598 | 67.1453 | 2.48686 | 2.48686 | 0.07794 | 0.0746059
2 x T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 33.6764 (kgCO₂) | 582.861 | 0 | 2.598 | 2.598 | 0 | 0 | 1.231 | 3.19814 | 3.19814 | 0 | 1.231 | 1.231 | 3.19814 | 1.231 | 3.19814 | 3.19814 | 3.19814 | 1.231 | 1.231 | 0.03693 | 2.598 | 0.0959441 | 1.71425 | 11.0543 | 1.231 | 0.0959441 | 0.0959441 | 2.522 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.22974 | 2.598 | 86.3497 | 3.19814 | 3.19814 | 0.07794 | 0.0959441
4 x T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 36.8652 (kgCO₂) | 638.051 | 0 | 2.844 | 2.844 | 0 | 0 | 1.231 | 3.50096 | 3.50096 | 0 | 1.231 | 1.231 | 3.50096 | 1.231 | 3.50096 | 3.50096 | 3.50096 | 1.231 | 1.231 | 0.03693 | 2.844 | 0.105029 | 4.31625 | 13.6563 | 1.231 | 0.105029 | 0.105029 | 2.522 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.2445 | 2.844 | 94.526 | 3.50096 | 3.50096 | 0.08532 | 0.105029
2 x T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_140 | 25.7247 (kgCO₂) | 445.236 | 0 | 2.844 | 2.844 | 0 | 0 | 0.859 | 2.443 | 2.443 | 0 | 0.859 | 0.859 | 2.443 | 0.859 | 2.443 | 2.443 | 2.443 | 0.859 | 0.859 | 0.02577 | 2.844 | 0.0732899 | 4.31625 | 13.6563 | 0.859 | 0.0732899 | 0.0732899 | 1.778 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.22218 | 2.844 | 65.9609 | 2.443 | 2.443 | 0.08532 | 0.0732899
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 |  | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 13.7591 (kgCO₂) | 238.138 | 0 | 1.25529 | 0.86763 | 0 | 0 | 1.231 | 1.30666 | 1.30666 | 0 | 1.231 | 1.231 | 1.30666 | 1.231 | 1.30666 | 1.62186 | 1.62186 | 1.231 | 1.231 | 0.03693 | 2.81803 | 0.0391997 | 7.16228 | 16.5023 | 1.231 | 0.0391997 | 0.0486558 | 2.522 | 8.41757 | 17.7576 | 7.16228 | 16.5023 | 0.100618 | 2.81803 | 35.2798 | 1.30666 | 1.62186 | 0.0845408 | 0.0486558
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 |  | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 23.8289 (kgCO₂) | 412.424 | 0 | 2.03214 | 1.64448 | 0 | 0 | 1.231 | 2.26295 | 2.26295 | 0 | 1.231 | 1.231 | 2.26295 | 1.231 | 2.26295 | 2.57816 | 2.57816 | 1.231 | 1.231 | 0.03693 | 2.81803 | 0.0678886 | 7.16228 | 16.5023 | 1.231 | 0.0678886 | 0.0773447 | 2.522 | 9.19442 | 18.5344 | 7.16228 | 16.5023 | 0.147228 | 2.81803 | 61.0998 | 2.26295 | 2.57816 | 0.0845408 | 0.0773447
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 |  | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 8.7242 (kgCO₂) | 150.996 | 0 | 0.866868 | 0.479207 | 0 | 0 | 1.231 | 0.828509 | 0.828509 | 0 | 1.231 | 1.231 | 0.828509 | 1.231 | 0.828509 | 1.14371 | 1.14371 | 1.231 | 1.231 | 0.03693 | 2.81803 | 0.0248553 | 7.16228 | 16.5023 | 1.231 | 0.0248553 | 0.0343113 | 2.522 | 8.02915 | 17.3691 | 7.16228 | 16.5023 | 0.0773122 | 2.81803 | 22.3697 | 0.828509 | 1.14371 | 0.0845408 | 0.0343113
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 |  | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 18.794 (kgCO₂) | 325.281 | 0 | 1.64371 | 1.25605 | 0 | 0 | 1.231 | 1.78481 | 1.78481 | 0 | 1.231 | 1.231 | 1.78481 | 1.231 | 1.78481 | 2.10001 | 2.10001 | 1.231 | 1.231 | 0.03693 | 2.81803 | 0.0535442 | 7.16228 | 16.5023 | 1.231 | 0.0535442 | 0.0630003 | 2.522 | 8.80599 | 18.146 | 7.16228 | 16.5023 | 0.123923 | 2.81803 | 48.1898 | 1.78481 | 2.10001 | 0.0845408 | 0.0630003
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 |  | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_140 | 3.10415 (kgCO₂) | 53.7256 | 0 | 0.478435 | 0.207923 | 0 | 0 | 0.859 | 0.294791 | 0.294791 | 0 | 0.859 | 0.859 | 0.294791 | 0.859 | 0.294791 | 0.514741 | 0.514741 | 0.859 | 0.859 | 0.02577 | 2.81803 | 0.00884372 | 7.16228 | 16.5023 | 0.859 | 0.00884372 | 0.0154422 | 1.778 | 7.64072 | 16.9807 | 7.16228 | 16.5023 | 0.0463607 | 2.81803 | 7.95935 | 0.294791 | 0.514741 | 0.0845408 | 0.0154422
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 |  | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_140 | 0.718414 (kgCO₂) | 12.4341 | 0 | 0.207293 | 0 | 0 | 0 | 0.859 | 0.0682255 | 0.0682255 | 0 | 0.859 | 0.859 | 0.0682255 | 0.859 | 0.0682255 | 0.28183 | 0.28183 | 0.859 | 0.859 | 0.0197475 | 2.81803 | 0.00204676 | 7.16228 | 16.5023 | 0.658251 | 0.00204676 | 0.00845491 | 1.778 | 7.36957 | 16.7096 | 7.16228 | 16.5023 | 0.0259663 | 2.81803 | 1.84209 | 0.0682255 | 0.28183 | 0.0845408 | 0.00845491
Tr2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | Tr2 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 16.7769 (kgCO₂) | 290.37 | 0 | 2.598 | 2.598 | 0 | 0 | 0.613261 | 1.59325 | 1.59325 | 0 | 0.613261 | 0.613261 | 1.59325 | 0.613261 | 1.59325 | 1.59325 | 1.59325 | 0.613261 | 0.613261 | 0.0183978 | 2.598 | 0.0477975 | 1.71425 | 11.0543 | 0.613261 | 0.0477975 | 0.0477975 | 1.28652 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.192676 | 2.598 | 43.0178 | 1.59325 | 1.59325 | 0.07794 | 0.0477975
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 13.2561 (kgCO₂) | 229.433 | 0 | 1.38294 | 0.237763 | 0.256221 | 0.256221 | 1.283 | 1.2589 | 1.25889 | 0.00768663 | 1.283 | 1.283 | 1.51512 | 1.283 | 1.51511 | 1.84363 | 1.84362 | 1.283 | 1.283 | 0.03849 | 2.81803 | 0.0377667 | 7.16228 | 16.5023 | 1.283 | 0.0454534 | 0.0553089 | 2.626 | 8.54522 | 17.8852 | 7.16228 | 16.5023 | 0.0871893 | 2.81803 | 33.9901 | 1.25889 | 1.84362 | 0.0845408 | 0.0553089 | ArchiCADProperties - ID of Connected Openings: OP - 003
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 27.3808 (kgCO₂) | 473.899 | 0 | 2.0313 | 2.02185 | 0 | 0 | 1.28308 | 2.59421 | 2.60633 | 0 | 1.28308 | 1.28308 | 2.59421 | 1.28308 | 2.60633 | 2.92275 | 2.93487 | 1.28308 | 1.28308 | 0.0384925 | 2.81803 | 0.0780081 | 7.16228 | 16.5023 | 1.28308 | 0.0780081 | 0.0878643 | 2.62617 | 9.19358 | 18.5336 | 7.16228 | 16.5023 | 0.160087 | 2.81803 | 70.2073 | 2.60633 | 2.93487 | 0.0845408 | 0.0878643
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 41.4742 (kgCO₂) | 717.823 | 0 | 2.844 | 2.844 | 0 | 0 | 1.38491 | 3.93867 | 3.93867 | 0 | 1.38491 | 1.38491 | 3.93867 | 1.38491 | 3.93867 | 3.93867 | 3.93867 | 1.38491 | 1.38491 | 0.0415472 | 2.844 | 0.11816 | 4.31625 | 13.6563 | 1.38491 | 0.11816 | 0.11816 | 2.82981 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.253734 | 2.844 | 106.344 | 3.93867 | 3.93867 | 0.08532 | 0.11816
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 36.7326 (kgCO₂) | 635.757 | 0 | 2.844 | 2.844 | 0 | 0 | 1.22657 | 3.48838 | 3.48838 | 0 | 1.22657 | 1.22657 | 3.48838 | 1.22657 | 3.48838 | 3.48838 | 3.48838 | 1.22657 | 1.22657 | 0.0367972 | 2.844 | 0.104651 | 4.31625 | 13.6563 | 1.22657 | 0.104651 | 0.104651 | 2.51315 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.244234 | 2.844 | 94.1862 | 3.48838 | 3.48838 | 0.08532 | 0.104651
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 36.6633 (kgCO₂) | 634.558 | 0 | 2.844 | 2.844 | 0 | 0 | 1.22426 | 3.4818 | 3.4818 | 0 | 1.22426 | 1.22426 | 3.4818 | 1.22426 | 3.4818 | 3.4818 | 3.4818 | 1.22426 | 1.22426 | 0.0367278 | 2.844 | 0.104454 | 4.31625 | 13.6563 | 1.22426 | 0.104454 | 0.104454 | 2.50852 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.244096 | 2.844 | 94.0085 | 3.4818 | 3.4818 | 0.08532 | 0.104454
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 37.8688 (kgCO₂) | 655.421 | 0 | 2.844 | 2.844 | 0 | 0 | 1.26451 | 3.59627 | 3.59627 | 0 | 1.26451 | 1.26451 | 3.59627 | 1.26451 | 3.59627 | 3.59627 | 3.59627 | 1.26451 | 1.26451 | 0.0379354 | 2.844 | 0.107888 | 4.31625 | 13.6563 | 1.26451 | 0.107888 | 0.107888 | 2.58903 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.246511 | 2.844 | 97.0994 | 3.59627 | 3.59627 | 0.08532 | 0.107888
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 38.425 (kgCO₂) | 665.047 | 0 | 2.844 | 2.844 | 0 | 0 | 1.28308 | 3.64909 | 3.64909 | 0 | 1.28308 | 1.28308 | 3.64909 | 1.28308 | 3.64909 | 3.64909 | 3.64909 | 1.28308 | 1.28308 | 0.0384925 | 2.844 | 0.109473 | 4.31625 | 13.6563 | 1.28308 | 0.109473 | 0.109473 | 2.62617 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.247625 | 2.844 | 98.5255 | 3.64909 | 3.64909 | 0.08532 | 0.109473
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 37.7037 (kgCO₂) | 652.564 | 0 | 2.844 | 2.844 | 0 | 0 | 1.259 | 3.5806 | 3.5806 | 0 | 1.259 | 1.259 | 3.5806 | 1.259 | 3.5806 | 3.5806 | 3.5806 | 1.259 | 1.259 | 0.03777 | 2.844 | 0.107418 | 4.31625 | 13.6563 | 1.259 | 0.107418 | 0.107418 | 2.578 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.24618 | 2.844 | 96.6761 | 3.5806 | 3.5806 | 0.08532 | 0.107418
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 26.1255 (kgCO₂) | 452.173 | 0 | 2.0313 | 2.02185 | 0 | 0 | 1.22426 | 2.47528 | 2.48684 | 0 | 1.22426 | 1.22426 | 2.47528 | 1.22426 | 2.48684 | 2.78875 | 2.80032 | 1.22426 | 1.22426 | 0.0367278 | 2.81803 | 0.0744318 | 7.16228 | 16.5023 | 1.22426 | 0.0744318 | 0.0838361 | 2.50852 | 9.19358 | 18.5336 | 7.16228 | 16.5023 | 0.158322 | 2.81803 | 66.9886 | 2.48684 | 2.80032 | 0.0845408 | 0.0838361
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 26.1749 (kgCO₂) | 453.027 | 0 | 2.0313 | 2.02185 | 0 | 0 | 1.22657 | 2.47995 | 2.49154 | 0 | 1.22657 | 1.22657 | 2.47995 | 1.22657 | 2.49154 | 2.79402 | 2.80561 | 1.22657 | 1.22657 | 0.0367972 | 2.81803 | 0.0745724 | 7.16228 | 16.5023 | 1.22657 | 0.0745724 | 0.0839945 | 2.51315 | 9.19358 | 18.5336 | 7.16228 | 16.5023 | 0.158392 | 2.81803 | 67.1152 | 2.49154 | 2.80561 | 0.0845408 | 0.0839945
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 29.5537 (kgCO₂) | 511.506 | 0 | 2.0313 | 2.02185 | 0 | 0 | 1.38491 | 2.80008 | 2.81316 | 0 | 1.38491 | 1.38491 | 2.80008 | 1.38491 | 2.81316 | 3.15469 | 3.16777 | 1.38491 | 1.38491 | 0.0415472 | 2.81803 | 0.0841985 | 7.16228 | 16.5023 | 1.38491 | 0.0841985 | 0.0948368 | 2.82981 | 9.19358 | 18.5336 | 7.16228 | 16.5023 | 0.163142 | 2.81803 | 75.7787 | 2.81316 | 3.16777 | 0.0845408 | 0.0948368
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 26.9845 (kgCO₂) | 467.04 | 0 | 2.0313 | 2.02185 | 0 | 0 | 1.26451 | 2.55666 | 2.56861 | 0 | 1.26451 | 1.26451 | 2.55666 | 1.26451 | 2.56861 | 2.88044 | 2.89239 | 1.26451 | 1.26451 | 0.0379354 | 2.81803 | 0.076879 | 7.16228 | 16.5023 | 1.26451 | 0.076879 | 0.0865925 | 2.58903 | 9.19358 | 18.5336 | 7.16228 | 16.5023 | 0.15953 | 2.81803 | 69.1911 | 2.56861 | 2.89239 | 0.0845408 | 0.0865925
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 26.8669 (kgCO₂) | 465.004 | 0 | 2.0313 | 2.02185 | 0 | 0 | 1.259 | 2.54551 | 2.55741 | 0 | 1.259 | 1.259 | 2.54551 | 1.259 | 2.55741 | 2.86789 | 2.87978 | 1.259 | 1.259 | 0.03777 | 2.81803 | 0.0765438 | 7.16228 | 16.5023 | 1.259 | 0.0765438 | 0.086215 | 2.578 | 9.19358 | 18.5336 | 7.16228 | 16.5023 | 0.159365 | 2.81803 | 68.8894 | 2.55741 | 2.87978 | 0.0845408 | 0.086215
F5 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F5 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 24.3588 (kgCO₂) | 421.595 | 0 | 2.598 | 2.598 | 0 | 0 | 0.890407 | 2.31328 | 2.31328 | 0 | 0.890407 | 0.890407 | 2.31328 | 0.890407 | 2.31328 | 2.31328 | 2.31328 | 0.890407 | 0.890407 | 0.0267122 | 2.598 | 0.0693983 | 1.71425 | 11.0543 | 0.890407 | 0.0693983 | 0.0693983 | 1.84081 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.209304 | 2.598 | 62.4585 | 2.31328 | 2.31328 | 0.07794 | 0.0693983
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 |  | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 0.0165116 (kgCO₂) | 0.285778 | 0 | 0.0314303 | 0 | 0 | 0 | 0.890407 | 0.00156846 | 0.00156765 | 0 | 0.890407 | 0.890407 | 0.00156846 | 0.890407 | 0.00156765 | 0.131142 | 0.131135 | 0.890407 | 0.890407 | 0.00299378 | 2.81803 | 0.0000470417 | 7.16228 | 16.5023 | 0.0998056 | 0.0000470417 | 0.00393415 | 1.84081 | 7.19371 | 16.5337 | 7.16228 | 16.5023 | 0.00393657 | 2.81803 | 0.0423375 | 0.00156806 | 0.131135 | 0.0845408 | 0.00393415
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 25.2977 (kgCO₂) | 437.845 | 0 | 2.12779 | 1.81733 | 0 | 0 | 1.21793 | 2.40245 | 2.40243 | 0 | 1.21793 | 1.21793 | 2.40245 | 1.21793 | 2.40243 | 2.40245 | 2.40243 | 1.21793 | 1.21793 | 0.0365378 | 2.6 | 0.0720732 | 2.872 | 12.212 | 1.21793 | 0.0720732 | 0.0720732 | 2.49586 | 4.99979 | 14.3398 | 2.872 | 12.212 | 0.192598 | 2.44 | 64.8659 | 2.40245 | 2.40245 | 0.078 | 0.0720732
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 38.603 (kgCO₂) | 668.128 | 0 | 2.6 | 2.6 | 0 | 0 | 1.41 | 3.666 | 3.666 | 0 | 1.41 | 1.41 | 3.666 | 1.41 | 3.666 | 3.666 | 3.666 | 1.41 | 1.41 | 0.0423 | 2.6 | 0.10998 | 1.71425 | 11.0543 | 1.41 | 0.10998 | 0.10998 | 2.88 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.2406 | 2.6 | 98.982 | 3.666 | 3.666 | 0.078 | 0.10998
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 38.0285 (kgCO₂) | 658.186 | 0 | 2.6 | 0 | 0 | 0 | 1.31902 | 3.61144 | 3.61144 | 0 | 1.31902 | 1.31902 | 3.61144 | 1.31902 | 3.61144 | 3.68944 | 3.68944 | 1.31902 | 1.31902 | 0.0416705 | 2.6 | 0.108343 | 1.71425 | 11.0543 | 1.38902 | 0.108343 | 0.110683 | 2.69803 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.161341 | 2.6 | 97.509 | 3.61144 | 3.61144 | 0.078 | 0.108343
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 35.5645 (kgCO₂) | 615.539 | 0 | 2.6 | 0 | 0 | 0 | 1.22902 | 3.37744 | 3.37744 | 0 | 1.22902 | 1.22902 | 3.37744 | 1.22902 | 3.37744 | 3.45544 | 3.45544 | 1.22902 | 1.22902 | 0.0389705 | 2.6 | 0.101323 | 1.71425 | 11.0543 | 1.29902 | 0.101323 | 0.103663 | 2.51803 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.155941 | 2.6 | 91.1909 | 3.37744 | 3.37744 | 0.078 | 0.101323
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 16.4935 (kgCO₂) | 285.464 | 0 | 1.90546 | 1.68292 | 0 | 0 | 0.873 | 1.56632 | 1.56634 | 0 | 0.873 | 0.873 | 1.56632 | 0.873 | 1.56634 | 1.56632 | 1.56634 | 0.873 | 0.873 | 0.02619 | 2.08767 | 0.0469899 | 2.87 | 12.21 | 0.873 | 0.0469899 | 0.0469899 | 1.806 | 4.77546 | 14.1155 | 2.87 | 12.21 | 0.160869 | 2.44 | 42.291 | 1.56634 | 1.56634 | 0.0626302 | 0.0469899
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 18.5965 (kgCO₂) | 321.862 | 0 | 2.128 | 1.90604 | 0 | 0 | 0.875321 | 1.76604 | 1.76605 | 0 | 0.875321 | 0.875321 | 1.76604 | 0.875321 | 1.76605 | 1.76604 | 1.76605 | 0.875321 | 0.875321 | 0.0262596 | 2.14706 | 0.0529814 | 2.87 | 12.21 | 0.875321 | 0.0529814 | 0.0529814 | 1.81064 | 4.998 | 14.338 | 2.87 | 12.21 | 0.174345 | 2.44 | 47.6833 | 1.76605 | 1.76605 | 0.0644117 | 0.0529814
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 14.4425 (kgCO₂) | 249.967 | 0 | 1.68236 | 1.45982 | 0 | 0 | 0.873 | 1.37155 | 1.37157 | 0 | 0.873 | 0.873 | 1.37155 | 0.873 | 1.37157 | 1.37155 | 1.37157 | 0.873 | 0.873 | 0.02619 | 2.08567 | 0.0411468 | 2.872 | 12.212 | 0.873 | 0.0411468 | 0.0411468 | 1.806 | 4.55436 | 13.8944 | 2.872 | 12.212 | 0.147483 | 2.44 | 37.0321 | 1.37157 | 1.37157 | 0.0625702 | 0.0411468
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 16.4666 (kgCO₂) | 284.999 | 0 | 1.90255 | 1.68 | 0 | 0 | 0.873 | 1.56379 | 1.56378 | 0 | 0.873 | 0.873 | 1.56379 | 0.873 | 1.56378 | 1.56379 | 1.56378 | 0.873 | 0.873 | 0.02619 | 2.08767 | 0.0469135 | 2.87 | 12.21 | 0.873 | 0.0469135 | 0.0469135 | 1.806 | 4.77255 | 14.1125 | 2.87 | 12.21 | 0.160694 | 2.44 | 42.2221 | 1.56379 | 1.56379 | 0.0626302 | 0.0469135
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 31.075 (kgCO₂) | 537.836 | 0 | 2.60008 | 2.60008 | 0 | 0 | 1.135 | 2.95109 | 2.95109 | 0 | 1.135 | 1.135 | 2.95109 | 1.135 | 2.95109 | 2.95109 | 2.95109 | 1.135 | 1.135 | 0.03405 | 2.60008 | 0.0885327 | 4.31425 | 13.6543 | 1.135 | 0.0885327 | 0.0885327 | 2.33 | 6.91433 | 16.2543 | 4.31425 | 13.6543 | 0.224105 | 2.60008 | 79.6794 | 2.95109 | 2.95109 | 0.0780023 | 0.0885327
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 14.4157 (kgCO₂) | 249.502 | 0 | 1.67944 | 1.4569 | 0 | 0 | 0.873 | 1.36902 | 1.369 | 0 | 0.873 | 0.873 | 1.36902 | 0.873 | 1.369 | 1.36902 | 1.369 | 0.873 | 0.873 | 0.02619 | 2.08567 | 0.0410703 | 2.872 | 12.212 | 0.873 | 0.0410703 | 0.0410703 | 1.806 | 4.55144 | 13.8914 | 2.872 | 12.212 | 0.147308 | 2.44 | 36.9633 | 1.36902 | 1.36902 | 0.0625702 | 0.0410703
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 18.5696 (kgCO₂) | 321.397 | 0 | 2.12625 | 1.90312 | 0 | 0 | 0.875321 | 1.7635 | 1.76349 | 0 | 0.875321 | 0.875321 | 1.7635 | 0.875321 | 1.76349 | 1.7635 | 1.76349 | 0.875321 | 0.875321 | 0.0262596 | 2.14706 | 0.0529049 | 2.87 | 12.21 | 0.875321 | 0.0529049 | 0.0529049 | 1.81064 | 4.99625 | 14.3363 | 2.87 | 12.21 | 0.17424 | 2.44 | 47.6144 | 1.7635 | 1.7635 | 0.0644117 | 0.0529049
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Lateral | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_190 | 7.23011 (kgCO₂) | 125.137 | 0 | 0.400128 | 0.400128 | 0 | 0 | 1.716 | 0.68662 | 0.68662 | 0 | 1.716 | 1.716 | 0.68662 | 1.716 | 0.68662 | 1.09481 | 1.09481 | 1.716 | 1.716 | 0.05148 | 0.638 | 0.0205986 | 4.31425 | 13.6543 | 1.716 | 0.0205986 | 0.0328442 | 3.492 | 4.71438 | 14.0544 | 4.31425 | 13.6543 | 0.0754877 | 0.638 | 18.5388 | 0.68662 | 0.984984 | 0.01914 | 0.0295495 | ArchiCADProperties - ID of Connected Openings: OP - 003
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 34.2275 (kgCO₂) | 592.399 | 0 | 2.6 | 2.6 | 0 | 0 | 1.25018 | 3.25048 | 3.25048 | 0 | 1.25018 | 1.25018 | 3.25048 | 1.25018 | 3.25048 | 3.25048 | 3.25048 | 1.25018 | 1.25018 | 0.0375055 | 2.6 | 0.0975143 | 0.27 | 9.61 | 1.25018 | 0.0975143 | 0.0975143 | 2.56037 | 2.87 | 12.21 | 0.27 | 9.61 | 0.231011 | 2.44 | 87.7628 | 3.25048 | 3.25048 | 0.078 | 0.0975143
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 24.9398 (kgCO₂) | 431.65 | 0 | 2.12754 | 1.8218 | 0 | 0 | 1.19941 | 2.36846 | 2.36844 | 0 | 1.19941 | 1.19941 | 2.36846 | 1.19941 | 2.36844 | 2.36846 | 2.36844 | 1.19941 | 1.19941 | 0.0359824 | 2.6 | 0.0710534 | 2.872 | 12.212 | 1.19941 | 0.0710534 | 0.0710534 | 2.45882 | 4.99954 | 14.3395 | 2.872 | 12.212 | 0.191596 | 2.44 | 63.9481 | 2.36846 | 2.36846 | 0.078 | 0.0710534
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Despatx; Nau Santa Eulàlia; Office | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 32.4444 (kgCO₂) | 561.537 | 0 | 2.6 | 2.6 | 0 | 0 | 1.18505 | 3.08113 | 3.08113 | 0 | 1.18505 | 1.18505 | 3.08113 | 1.18505 | 3.08113 | 3.08113 | 3.08113 | 1.18505 | 1.18505 | 0.0355516 | 2.6 | 0.092434 | 0.27 | 9.61 | 1.18505 | 0.092434 | 0.092434 | 2.4301 | 2.87 | 12.21 | 0.27 | 9.61 | 0.227103 | 2.44 | 83.1906 | 3.08113 | 3.08113 | 0.078 | 0.092434
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 25.2799 (kgCO₂) | 437.537 | 0 | 2.12779 | 1.81757 | 0 | 0 | 1.217 | 2.40076 | 2.40074 | 0 | 1.217 | 1.217 | 2.40076 | 1.217 | 2.40074 | 2.40076 | 2.40074 | 1.217 | 1.217 | 0.03651 | 2.6 | 0.0720226 | 2.872 | 12.212 | 1.217 | 0.0720226 | 0.0720226 | 2.494 | 4.99979 | 14.3398 | 2.872 | 12.212 | 0.192548 | 2.44 | 64.8204 | 2.40076 | 2.40076 | 0.078 | 0.0720226
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia; Office | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 19.2131 (kgCO₂) | 332.534 | 0 | 2.6 | 2.6 | 0 | 0 | 0.701771 | 1.82461 | 1.82461 | 0 | 0.701771 | 0.701771 | 1.82461 | 0.701771 | 1.82461 | 1.82461 | 1.82461 | 0.701771 | 0.701771 | 0.0210531 | 2.6 | 0.0547382 | 0.27 | 9.61 | 0.701771 | 0.0547382 | 0.0547382 | 1.46354 | 2.87 | 12.21 | 0.27 | 9.61 | 0.198106 | 2.44 | 49.2643 | 1.82461 | 1.82461 | 0.078 | 0.0547382
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 25.0813 (kgCO₂) | 434.099 | 0 | 1.82148 | 1.45034 | 0 | 0 | 1.456 | 2.3819 | 2.38187 | 0 | 1.456 | 1.456 | 2.3819 | 1.456 | 2.38187 | 2.3819 | 2.38187 | 1.456 | 1.456 | 0.04368 | 2.6 | 0.0714566 | 2.872 | 12.212 | 1.456 | 0.0714566 | 0.0714566 | 2.972 | 4.69348 | 14.0335 | 2.872 | 12.212 | 0.186911 | 2.44 | 64.3109 | 2.3819 | 2.3819 | 0.078 | 0.0714566
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 25.0425 (kgCO₂) | 433.427 | 0 | 1.81719 | 1.44559 | 0 | 0 | 1.45777 | 2.37819 | 2.37821 | 0 | 1.45777 | 1.45777 | 2.37819 | 1.45777 | 2.37821 | 2.37819 | 2.37821 | 1.45777 | 1.45777 | 0.0437332 | 2.6 | 0.071346 | 2.872 | 12.212 | 1.45777 | 0.071346 | 0.071346 | 2.97555 | 4.68919 | 14.0292 | 2.872 | 12.212 | 0.186748 | 2.44 | 64.2114 | 2.37821 | 2.37821 | 0.078 | 0.071346
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 25.0785 (kgCO₂) | 434.051 | 0 | 1.8213 | 1.45016 | 0 | 0 | 1.456 | 2.38161 | 2.38164 | 0 | 1.456 | 1.456 | 2.38161 | 1.456 | 2.38164 | 2.38161 | 2.38164 | 1.456 | 1.456 | 0.04368 | 2.6 | 0.0714487 | 2.872 | 12.212 | 1.456 | 0.0714487 | 0.0714487 | 2.972 | 4.6933 | 14.0333 | 2.872 | 12.212 | 0.1869 | 2.44 | 64.3038 | 2.38164 | 2.38164 | 0.078 | 0.0714487
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 33.2704 (kgCO₂) | 575.834 | 0 | 2.6 | 2.6 | 0 | 0 | 1.21522 | 3.15958 | 3.15958 | 0 | 1.21522 | 1.21522 | 3.15958 | 1.21522 | 3.15958 | 3.15958 | 3.15958 | 1.21522 | 1.21522 | 0.0364567 | 2.6 | 0.0947874 | 0.27 | 9.61 | 1.21522 | 0.0947874 | 0.0947874 | 2.49045 | 2.87 | 12.21 | 0.27 | 9.61 | 0.228913 | 2.44 | 85.3087 | 3.15958 | 3.15958 | 0.078 | 0.0947874
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 2.245 (kgCO₂) | 38.8557 | 0 | 2.6 | 2.6 | 0 | 0 | 0.082 | 0.2132 | 0.2132 | 0 | 0.082 | 0.082 | 0.2132 | 0.082 | 0.2132 | 0.2132 | 0.2132 | 0.082 | 0.082 | 0.00246 | 2.6 | 0.006396 | 0.27 | 9.61 | 0.082 | 0.006396 | 0.006396 | 0.224 | 2.87 | 12.21 | 0.27 | 9.61 | 0.16092 | 2.44 | 5.7564 | 0.2132 | 0.2132 | 0.078 | 0.006396
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 18.2399 (kgCO₂) | 315.69 | 0 | 2.6 | 0 | 0 | 0 | 0.666223 | 1.73202 | 1.73234 | 0 | 0.696286 | 0.66616 | 1.73202 | 0.666286 | 1.73234 | 1.81002 | 1.81034 | 0.66616 | 0.666286 | 0.0199867 | 2.6 | 0.0519654 | 0.27 | 9.61 | 0.666286 | 0.0519654 | 0.0543054 | 1.39245 | 2.87 | 12.21 | 0.27 | 9.61 | 0.117973 | 2.44 | 46.7689 | 1.73234 | 1.73234 | 0.078 | 0.0519654
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 35.3411 (kgCO₂) | 611.674 | 0 | 2.6 | 2.6 | 0 | 0 | 1.29086 | 3.35623 | 3.35623 | 0 | 1.29086 | 1.29086 | 3.35623 | 1.29086 | 3.35623 | 3.35623 | 3.35623 | 1.29086 | 1.29086 | 0.0387258 | 2.6 | 0.100687 | 0.27 | 9.61 | 1.29086 | 0.100687 | 0.100687 | 2.64172 | 2.87 | 12.21 | 0.27 | 9.61 | 0.233452 | 2.44 | 90.6183 | 3.35623 | 3.35623 | 0.078 | 0.100687
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 24.939 (kgCO₂) | 431.636 | 0 | 2.12748 | 1.82174 | 0 | 0 | 1.19941 | 2.36836 | 2.36838 | 0 | 1.19941 | 1.19941 | 2.36836 | 1.19941 | 2.36838 | 2.36836 | 2.36838 | 1.19941 | 1.19941 | 0.0359823 | 2.6 | 0.0710512 | 2.872 | 12.212 | 1.19941 | 0.0710512 | 0.0710512 | 2.45882 | 4.99948 | 14.3395 | 2.872 | 12.212 | 0.191592 | 2.44 | 63.946 | 2.36838 | 2.36838 | 0.078 | 0.0710512
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 20.3001 (kgCO₂) | 351.348 | 0 | 2.6 | 2.6 | 0 | 0 | 0.741475 | 1.92784 | 1.92784 | 0 | 0.741475 | 0.741475 | 1.92784 | 0.741475 | 1.92784 | 1.92784 | 1.92784 | 0.741475 | 0.741475 | 0.0222443 | 2.6 | 0.0578351 | 0.27 | 9.61 | 0.741475 | 0.0578351 | 0.0578351 | 1.54295 | 2.87 | 12.21 | 0.27 | 9.61 | 0.200489 | 2.44 | 52.0516 | 1.92784 | 1.92784 | 0.078 | 0.0578351
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_140 | 17.0082 (kgCO₂) | 294.373 | 0 | 2.598 | 2.598 | 0 | 0 | 0.621714 | 1.61521 | 1.61521 | 0 | 0.621714 | 0.621714 | 1.61521 | 0.621714 | 1.61521 | 1.61521 | 1.61521 | 0.621714 | 0.621714 | 0.0186514 | 2.598 | 0.0484564 | 1.71425 | 11.0543 | 0.621714 | 0.0484564 | 0.0484564 | 1.30343 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.193183 | 2.598 | 43.6108 | 1.61521 | 1.61521 | 0.07794 | 0.0484564
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 33.5395 (kgCO₂) | 580.491 | 0 | 2.6 | 2.6 | 0 | 0 | 1.22505 | 3.18513 | 3.18513 | 0 | 1.22505 | 1.22505 | 3.18513 | 1.22505 | 3.18513 | 3.18513 | 3.18513 | 1.22505 | 1.22505 | 0.0367516 | 2.6 | 0.095554 | 0.27 | 9.61 | 1.22505 | 0.095554 | 0.095554 | 2.5101 | 2.87 | 12.21 | 0.27 | 9.61 | 0.229503 | 2.44 | 85.9986 | 3.18513 | 3.18513 | 0.078 | 0.095554
