Properties of the parts of a building model (IFC2X3), part 11 of 99

# IfcBuildingElementProxy: Gypsum Plasterboard 30 (373)
Name | Reference Line Location | Inside Face Surface = Edge Surface | Outside Face Surface | Element ID = Hotlink and Element ID = Parent ID | Colliding Zones | Surfaces (All) | Number of Openings | 107.AMB.NomTipus | 109.AMB.CodiTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_107.NomTipus | Gypsum Plasterboard, Embodied Carbon | Gypsum Plasterboard, Embodied Energy (MJ) | Number of Windows | Maximum Height of the Wall (m) | Minimum Height of the Wall (m) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Surface Area of the Wall Inside Face (Conditional) (m2) | Length of the Wall Outside Face (Conditional) (m) | Surface Area of the Wall Outside Face (Conditional) (m2) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = Gypsum Plasterboard, Rectangular Component Height (m) | Volume (Net) (m3) = Gypsum Plasterboard, Component Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | 3D Length (m) | Volume (Conditional) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | 503.AMB.Altura (m) | Gypsum Plasterboard, Mass (kg) | Gypsum Plasterboard, Projected Component Area (Net) (m2) | Gypsum Plasterboard, Projected Component Area (Gross) (m2) | Gypsum Plasterboard, Component Cross Section Area (m2) | Gypsum Plasterboard, Component Volume (Gross) (m3)
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.249 (kgCO₂) | 281.232 | 0 | 1.447 | 1.447 | 0 | 0 | 1.06642 | 1.54311 | 1.54311 | 0 | 1.06642 | 1.06642 | 1.54311 | 1.06642 | 1.54311 | 1.54311 | 1.54311 | 1.06642 | 1.06642 | 0.0319926 | 1.447 | 0.0462933 | 2.872 | 12.212 | 1.06642 | 0.0462933 | 0.0462933 | 2.19284 | 4.319 | 13.659 | 2.872 | 12.212 | 0.150805 | 2.44 | 41.664 | 1.54311 | 1.54311 | 0.04341 | 0.0462933
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.6638 (kgCO₂) | 288.413 | 0 | 1.447 | 0 | 0.496828 | 0.496828 | 1.437 | 1.58251 | 1.58251 | 0.0149048 | 1.437 | 0.341001 | 2.07934 | 0.341001 | 2.07934 | 2.07934 | 2.07934 | 1.437 | 1.437 | 0.01023 | 1.447 | 0.0474753 | 2.872 | 12.212 | 1.437 | 0.0623802 | 0.0623802 | 2.934 | 4.319 | 13.659 | 2.872 | 12.212 | 0.126561 | 2.44 | 42.7278 | 1.58251 | 2.07934 | 0.04341 | 0.0623802 | ArchiCADProperties - ID of Connected Openings: OP - 005; OP - 006
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.7314 (kgCO₂) | 289.582 | 0 | 1.447 | 0 | 0.494751 | 0.494751 | 1.44 | 1.58893 | 1.58893 | 0.0148425 | 1.44 | 0.344001 | 2.08368 | 0.344001 | 2.08368 | 2.08368 | 2.08368 | 1.44 | 1.44 | 0.01032 | 1.447 | 0.0476679 | 2.872 | 12.212 | 1.44 | 0.0625104 | 0.0625104 | 2.94 | 4.319 | 13.659 | 2.872 | 12.212 | 0.113255 | 2.44 | 42.9011 | 1.58893 | 2.08368 | 0.04341 | 0.0625104 | ArchiCADProperties - ID of Connected Openings: OP - 005; OP - 005
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 12.32 (kgCO₂) | 213.231 | 0 | 1.447 | 0 | 0.307394 | 0.307394 | 1.021 | 1.16999 | 1.16999 | 0.00922181 | 1.021 | 0.570154 | 1.47739 | 0.570154 | 1.47739 | 1.47739 | 1.47739 | 1.021 | 1.021 | 0.010315 | 1.447 | 0.0350998 | 2.872 | 12.212 | 1.021 | 0.0443216 | 0.0443216 | 2.102 | 4.319 | 13.659 | 2.872 | 12.212 | 0.100529 | 2.44 | 31.5898 | 1.16999 | 1.47739 | 0.04341 | 0.0443216 | ArchiCADProperties - ID of Connected Openings: OP - 020; OP - 013
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Espai de treball; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 19.7013 (kgCO₂) | 340.984 | 0 | 1.447 | 1.447 | 0 | 0 | 1.293 | 1.87097 | 1.87097 | 0 | 1.293 | 1.293 | 1.87097 | 1.293 | 1.87097 | 1.87097 | 1.87097 | 1.293 | 1.293 | 0.03879 | 1.447 | 0.0561291 | 2.872 | 12.212 | 1.293 | 0.0561291 | 0.0561291 | 2.646 | 4.319 | 13.659 | 2.872 | 12.212 | 0.1644 | 2.44 | 50.5162 | 1.87097 | 1.87097 | 0.04341 | 0.0561291
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.8938 (kgCO₂) | 327.008 | 0 | 1.447 | 1.447 | 0 | 0 | 1.24 | 1.79428 | 1.79428 | 0 | 1.24 | 1.24 | 1.79428 | 1.24 | 1.79428 | 1.79428 | 1.79428 | 1.24 | 1.24 | 0.0372 | 1.447 | 0.0538284 | 2.872 | 12.212 | 1.24 | 0.0538284 | 0.0538284 | 2.54 | 4.319 | 13.659 | 2.872 | 12.212 | 0.16122 | 2.44 | 48.4456 | 1.79428 | 1.79428 | 0.04341 | 0.0538284
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.97 (kgCO₂) | 328.326 | 0 | 1.447 | 1.447 | 0 | 0 | 1.245 | 1.80151 | 1.80151 | 0 | 1.245 | 1.245 | 1.80151 | 1.245 | 1.80151 | 1.80151 | 1.80151 | 1.245 | 1.245 | 0.03735 | 1.447 | 0.0540455 | 2.872 | 12.212 | 1.245 | 0.0540455 | 0.0540455 | 2.55 | 4.319 | 13.659 | 2.872 | 12.212 | 0.16152 | 2.44 | 48.6409 | 1.80151 | 1.80151 | 0.04341 | 0.0540455
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 29.1821 (kgCO₂) | 505.075 | 0 | 2.6 | 0 | 0 | 0 | 1.05087 | 2.77353 | 2.76912 | 0 | 1.06505 | 1.0367 | 2.77353 | 1.06505 | 2.76912 | 2.77353 | 2.76912 | 1.0367 | 1.06505 | 0.0319769 | 2.6 | 0.0831399 | 0.27 | 9.61 | 1.06674 | 0.0831399 | 0.0831399 | 2.17302 | 2.87 | 12.21 | 0.27 | 9.61 | 0.141954 | 2.44 | 74.8259 | 2.77353 | 2.77353 | 0.078 | 0.0831399
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.881 (kgCO₂) | 292.172 | 0 | 1.447 | 0 | 0.49646 | 0.49646 | 1.451 | 1.60314 | 1.60314 | 0.0148938 | 1.451 | 0.355429 | 2.0996 | 0.355429 | 2.0996 | 2.0996 | 2.0996 | 1.451 | 1.451 | 0.0106629 | 1.447 | 0.0480941 | 2.872 | 12.212 | 1.451 | 0.0629879 | 0.0629879 | 2.962 | 4.319 | 13.659 | 2.872 | 12.212 | 0.127423 | 2.44 | 43.2847 | 1.60314 | 2.0996 | 0.04341 | 0.0629879 | ArchiCADProperties - ID of Connected Openings: OP - 006; OP - 006
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 19.5348 (kgCO₂) | 338.103 | 0 | 1.447 | 1.447 | 0 | 0 | 1.28207 | 1.85516 | 1.85516 | 0 | 1.28207 | 1.28207 | 1.85516 | 1.28207 | 1.85516 | 1.85516 | 1.85516 | 1.28207 | 1.28207 | 0.0384622 | 1.447 | 0.0556548 | 2.872 | 12.212 | 1.28207 | 0.0556548 | 0.0556548 | 2.62415 | 4.319 | 13.659 | 2.872 | 12.212 | 0.163744 | 2.44 | 50.0893 | 1.85516 | 1.85516 | 0.04341 | 0.0556548
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.6547 (kgCO₂) | 288.255 | 0 | 1.447 | 0 | 0.497692 | 0.497692 | 1.437 | 1.58165 | 1.58165 | 0.0149308 | 1.437 | 0.341001 | 2.07934 | 0.341001 | 2.07934 | 2.07934 | 2.07934 | 1.437 | 1.437 | 0.01023 | 1.447 | 0.0474494 | 2.872 | 12.212 | 1.437 | 0.0623802 | 0.0623802 | 2.934 | 4.319 | 13.659 | 2.872 | 12.212 | 0.126532 | 2.44 | 42.7045 | 1.58165 | 2.07934 | 0.04341 | 0.0623802 | ArchiCADProperties - ID of Connected Openings: OP - 008; OP - 009
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 15.5099 (kgCO₂) | 268.441 | 0 | 1.447 | 1.447 | 0 | 0 | 1.01792 | 1.47293 | 1.47293 | 0 | 1.01792 | 1.01792 | 1.47293 | 1.01792 | 1.47293 | 1.47293 | 1.47293 | 1.01792 | 1.01792 | 0.0305375 | 1.447 | 0.0441878 | 2.872 | 12.212 | 1.01792 | 0.0441878 | 0.0441878 | 2.09584 | 4.319 | 13.659 | 2.872 | 12.212 | 0.147895 | 2.44 | 39.769 | 1.47293 | 1.47293 | 0.04341 | 0.0441878
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 15.8432 (kgCO₂) | 274.21 | 0 | 1.447 | 1.447 | 0 | 0 | 1.03979 | 1.50458 | 1.50458 | 0 | 1.03979 | 1.03979 | 1.50458 | 1.03979 | 1.50458 | 1.50458 | 1.50458 | 1.03979 | 1.03979 | 0.0311938 | 1.447 | 0.0451374 | 2.872 | 12.212 | 1.03979 | 0.0451374 | 0.0451374 | 2.13959 | 4.319 | 13.659 | 2.872 | 12.212 | 0.149208 | 2.44 | 40.6237 | 1.50458 | 1.50458 | 0.04341 | 0.0451374 | ArchiCADProperties - ID of Connected Openings: OP - 006
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 12.3372 (kgCO₂) | 213.529 | 0 | 1.447 | 0 | 0.30576 | 0.30576 | 1.021 | 1.17163 | 1.17163 | 0.00917281 | 1.021 | 0.575551 | 1.47739 | 0.575551 | 1.47739 | 1.47739 | 1.47739 | 1.021 | 1.021 | 0.0104229 | 1.447 | 0.0351488 | 2.872 | 12.212 | 1.021 | 0.0443216 | 0.0443216 | 2.102 | 4.319 | 13.659 | 2.872 | 12.212 | 0.100636 | 2.44 | 31.6339 | 1.17163 | 1.47739 | 0.04341 | 0.0443216 | ArchiCADProperties - ID of Connected Openings: OP - 005; OP - 004
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.241 (kgCO₂) | 281.093 | 0 | 1.447 | 0 | 0 | 0 | 1.06505 | 1.54358 | 1.54112 | 0 | 1.06505 | 1.06505 | 1.54358 | 1.06505 | 1.54112 | 1.54358 | 1.54112 | 1.06505 | 1.06505 | 0.0319769 | 1.447 | 0.0462705 | 2.872 | 12.212 | 1.06674 | 0.0462705 | 0.0462705 | 2.1901 | 4.319 | 13.659 | 2.872 | 12.212 | 0.107364 | 2.44 | 41.6435 | 1.54358 | 1.54358 | 0.04341 | 0.0462705
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia; Office | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 14.8557 (kgCO₂) | 257.118 | 0 | 0.940531 | 0.940531 | 0 | 0 | 1.5 | 1.4108 | 1.4108 | 0 | 1.5 | 1.5 | 1.4108 | 1.5 | 1.4108 | 1.4108 | 1.4108 | 1.5 | 1.5 | 0.045 | 0.940531 | 0.0423239 | 3.3784 | 12.7184 | 1.5 | 0.0423239 | 0.0423239 | 3.06 | 4.31893 | 13.6589 | 3.3784 | 12.7184 | 0.146432 | 2.44 | 38.0915 | 1.4108 | 1.4108 | 0.0282159 | 0.0423239
F6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 57.6604 (kgCO₂) | 997.968 | 0 | 3.07729 | 3.07729 | 0 | 0 | 1.77943 | 5.47582 | 5.47582 | 0 | 1.77943 | 1.77943 | 5.47582 | 1.77943 | 5.47582 | 5.47582 | 5.47582 | 1.77943 | 1.77943 | 0.0533828 | 3.07729 | 0.164275 | 0.27 | 9.61 | 1.77943 | 0.164275 | 0.164275 | 3.61885 | 3.34729 | 12.6873 | 0.27 | 9.61 | 0.291403 | 2.44 | 147.847 | 5.47582 | 5.47582 | 0.0923188 | 0.164275
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia; Rack | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 22.3325 (kgCO₂) | 386.524 | 0 | 2.6 | 0 | 0 | 0 | 0.793483 | 2.16349 | 2.0782 | 0 | 0.799308 | 0.787658 | 2.16349 | 0.799308 | 2.0782 | 2.16349 | 2.0782 | 0.787658 | 0.799308 | 0.0244713 | 2.6 | 0.0636253 | 0.27 | 9.61 | 0.83211 | 0.0636253 | 0.0636253 | 1.64915 | 2.87 | 12.21 | 0.27 | 9.61 | 0.126943 | 2.44 | 57.2628 | 2.16349 | 2.16349 | 0.078 | 0.0636253
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 12.3662 (kgCO₂) | 214.031 | 0 | 1.447 | 0 | 0.305901 | 0.305901 | 1.023 | 1.17438 | 1.17438 | 0.00917702 | 1.023 | 0.570356 | 1.48028 | 0.570356 | 1.48028 | 1.48028 | 1.48028 | 1.023 | 1.023 | 0.0104736 | 1.447 | 0.0352314 | 2.872 | 12.212 | 1.023 | 0.0444084 | 0.0444084 | 2.106 | 4.319 | 13.659 | 2.872 | 12.212 | 0.100747 | 2.44 | 31.7083 | 1.17438 | 1.48028 | 0.04341 | 0.0444084 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 005
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 41.5491 (kgCO₂) | 719.119 | 0 | 2.6 | 1.105 | 0 | 0 | 1.60011 | 3.94578 | 3.94578 | 0 | 1.60011 | 1.60011 | 3.94578 | 1.60011 | 3.94578 | 4.16028 | 4.16028 | 1.60011 | 1.60011 | 0.0480033 | 2.6 | 0.118374 | 0.27 | 9.61 | 1.60011 | 0.118374 | 0.124809 | 3.26022 | 2.87 | 12.21 | 0.27 | 9.61 | 0.252007 | 2.44 | 106.536 | 3.94581 | 4.16028 | 0.078 | 0.124809
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia; Rack | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 14.6385 (kgCO₂) | 253.358 | 0 | 0.926779 | 0.926779 | 0 | 0 | 1.5 | 1.39017 | 1.39017 | 0 | 1.5 | 1.5 | 1.39017 | 1.5 | 1.39017 | 1.39017 | 1.39017 | 1.5 | 1.5 | 0.045 | 0.926779 | 0.0417051 | 3.39215 | 12.7321 | 1.5 | 0.0417051 | 0.0417051 | 3.06 | 4.31893 | 13.6589 | 3.39215 | 12.7321 | 0.145607 | 2.44 | 37.5345 | 1.39017 | 1.39017 | 0.0278034 | 0.0417051
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia; Rack | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 10.2867 (kgCO₂) | 178.039 | 0 | 1.44693 | 0 | 0 | 0 | 0.658751 | 1.00063 | 0.953165 | 0 | 0.658751 | 0.658751 | 1.00063 | 0.658751 | 0.953165 | 1.00063 | 0.953165 | 0.658751 | 0.658751 | 0.0202545 | 1.44693 | 0.0293069 | 2.872 | 12.212 | 0.691552 | 0.0293069 | 0.0293069 | 1.3775 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.0839169 | 2.44 | 26.3762 | 1.00063 | 1.00063 | 0.0434079 | 0.0293069
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 22.8108 (kgCO₂) | 394.802 | 0 | 1.44693 | 0 | 0 | 0 | 1.5 | 2.12698 | 2.17039 | 0 | 1.5 | 1.5 | 2.12698 | 1.5 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.0449145 | 1.44693 | 0.064988 | 2.872 | 12.212 | 1.5 | 0.064988 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.176645 | 2.44 | 58.4892 | 2.17038 | 2.17039 | 0.0434079 | 0.0651118
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.5359 (kgCO₂) | 355.429 | 0 | 1.44693 | 0 | 0.220167 | 0.220167 | 1.5 | 1.95023 | 1.95023 | 0.00660502 | 1.5 | 0.957001 | 2.17039 | 0.957001 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.02871 | 1.44693 | 0.0585068 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.160526 | 2.44 | 52.6561 | 1.95023 | 2.17039 | 0.0434079 | 0.0651118 | ArchiCADProperties - ID of Connected Openings: OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 34.54 (kgCO₂) | 597.807 | 0 | 2.6 | 1.45847 | 0.619853 | 0.619853 | 1.5 | 3.28015 | 3.28015 | 0.0185956 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.0984044 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.22971 | 2.44 | 88.564 | 3.28015 | 3.9 | 0.078 | 0.117 | ArchiCADProperties - ID of Connected Openings: OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 40.4464 (kgCO₂) | 700.034 | 0 | 2.6 | 2.13347 | 0.0589344 | 0.0589344 | 1.5 | 3.84107 | 3.84107 | 0.00176803 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.115232 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.228214 | 2.44 | 103.709 | 3.84107 | 3.9 | 0.078 | 0.117 | ArchiCADProperties - ID of Connected Openings: OP - 006
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 22.1213 (kgCO₂) | 382.868 | 0 | 1.44693 | 0 | 0.0696089 | 0.0696089 | 1.5 | 2.10078 | 2.10078 | 0.00208827 | 1.5 | 1.5 | 2.17039 | 1.5 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.0398497 | 1.44693 | 0.0630235 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.159501 | 2.44 | 56.7212 | 2.10078 | 2.17039 | 0.0434079 | 0.0651118 | ArchiCADProperties - ID of Connected Openings: OP - 006
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 22.3203 (kgCO₂) | 386.312 | 0 | 1.44693 | 0 | 0.0507094 | 0.0507094 | 1.5 | 2.11968 | 2.11968 | 0.00152128 | 1.5 | 1.5 | 2.17039 | 1.5 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.0412481 | 1.44693 | 0.0635905 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.1609 | 2.44 | 57.2315 | 2.11968 | 2.17039 | 0.0434079 | 0.0651118 | ArchiCADProperties - ID of Connected Openings: OP - 006
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 22.8542 (kgCO₂) | 395.554 | 0 | 1.44693 | 1.44693 | 0 | 0 | 1.5 | 2.17039 | 2.17039 | 0 | 1.5 | 1.5 | 2.17039 | 1.5 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.045 | 1.44693 | 0.0651118 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.176816 | 2.44 | 58.6006 | 2.17039 | 2.17039 | 0.0434079 | 0.0651118
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 40.2236 (kgCO₂) | 696.178 | 0 | 2.6 | 2.13347 | 0.080093 | 0.080093 | 1.5 | 3.81991 | 3.81991 | 0.00240279 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.114597 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.226854 | 2.44 | 103.138 | 3.81991 | 3.9 | 0.078 | 0.117 | ArchiCADProperties - ID of Connected Openings: OP - 006
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 34.5751 (kgCO₂) | 598.416 | 0 | 2.6 | 2.6 | 0 | 0 | 1.26288 | 3.28349 | 3.28349 | 0 | 1.26288 | 1.26288 | 3.28349 | 1.26288 | 3.28349 | 3.28349 | 3.28349 | 1.26288 | 1.26288 | 0.0378864 | 2.6 | 0.0985046 | 0.27 | 9.61 | 1.26288 | 0.0985046 | 0.0985046 | 2.58576 | 2.87 | 12.21 | 0.27 | 9.61 | 0.231773 | 2.44 | 88.6542 | 3.28349 | 3.28349 | 0.078 | 0.0985046
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 39.4608 (kgCO₂) | 682.975 | 0 | 2.6 | 2.22045e-16 | 0 | 0 | 1.41626 | 3.7997 | 3.69522 | 0 | 1.42124 | 1.41128 | 3.7997 | 1.42124 | 3.69522 | 3.7997 | 3.69522 | 1.41128 | 1.42124 | 0.0432399 | 2.6 | 0.112424 | 0.27 | 9.61 | 1.46142 | 0.112424 | 0.112424 | 2.89413 | 2.87 | 12.21 | 0.27 | 9.61 | 0.16448 | 2.44 | 101.181 | 3.7997 | 3.7997 | 0.078 | 0.112424
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Despatx; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 41.067 (kgCO₂) | 710.775 | 0 | 2.6 | 2.6 | 0 | 0 | 1.5 | 3.9 | 3.9 | 0 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.117 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.246 | 2.44 | 105.3 | 3.9 | 3.9 | 0.078 | 0.117
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 21.9603 (kgCO₂) | 380.083 | 0 | 1.44693 | 0 | 0 | 0 | 1.42124 | 2.11457 | 2.05643 | 0 | 1.42124 | 1.42124 | 2.11457 | 1.42124 | 2.05643 | 2.11457 | 2.05643 | 1.42124 | 1.42124 | 0.0432399 | 1.44693 | 0.0625651 | 2.872 | 12.212 | 1.46142 | 0.0625651 | 0.0625651 | 2.90248 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.129888 | 2.44 | 56.3086 | 2.11457 | 2.11457 | 0.0434079 | 0.0625651
2 x T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 29.7676 (kgCO₂) | 515.209 | 0 | 2.6 | 2.6 | 0 | 0 | 1.08728 | 2.82694 | 2.82694 | 0 | 1.08728 | 1.08728 | 2.82694 | 1.08728 | 2.82694 | 2.82694 | 2.82694 | 1.08728 | 1.08728 | 0.0326185 | 2.6 | 0.0848081 | 0.27 | 9.61 | 1.08728 | 0.0848081 | 0.0848081 | 2.23457 | 2.87 | 12.21 | 0.27 | 9.61 | 0.221237 | 2.44 | 76.3273 | 2.82694 | 2.82694 | 0.078 | 0.0848081
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 18.3862 (kgCO₂) | 318.223 | 0 | 1.73698 | 1.45839 | 0 | 0 | 1.09288 | 1.74607 | 1.74609 | 0 | 1.09288 | 1.09288 | 1.74607 | 1.09288 | 1.74609 | 1.74607 | 1.74609 | 1.09288 | 1.09288 | 0.0327864 | 2.34917 | 0.0523823 | 2.872 | 12.212 | 1.09288 | 0.0523823 | 0.0523823 | 2.24576 | 4.60898 | 13.949 | 2.872 | 12.212 | 0.162482 | 2.44 | 47.1441 | 1.74609 | 1.74609 | 0.0704751 | 0.0523823
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 19.6566 (kgCO₂) | 340.21 | 0 | 1.75458 | 1.45837 | 0 | 0 | 1.162 | 1.86673 | 1.86671 | 0 | 1.162 | 1.162 | 1.86673 | 1.162 | 1.86671 | 1.86673 | 1.86671 | 1.162 | 1.162 | 0.03486 | 2.34917 | 0.0560017 | 2.872 | 12.212 | 1.162 | 0.0560017 | 0.0560017 | 2.384 | 4.62658 | 13.9666 | 2.872 | 12.212 | 0.167223 | 2.44 | 50.4015 | 1.86673 | 1.86673 | 0.0704751 | 0.0560017
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 31.1563 (kgCO₂) | 539.244 | 0 | 2.12773 | 1.73747 | 0 | 0 | 1.531 | 2.9588 | 2.95883 | 0 | 1.531 | 1.531 | 2.9588 | 1.531 | 2.95883 | 2.9588 | 2.95883 | 1.531 | 1.531 | 0.04593 | 2.34917 | 0.0887645 | 2.872 | 12.212 | 1.531 | 0.0887645 | 0.0887645 | 3.122 | 4.99973 | 14.3397 | 2.872 | 12.212 | 0.209285 | 2.44 | 79.888 | 2.95883 | 2.95883 | 0.0704751 | 0.0887645
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 35.3417 (kgCO₂) | 611.683 | 0 | 2.6 | 2.6 | 0 | 0 | 1.29088 | 3.35629 | 3.35629 | 0 | 1.29088 | 1.29088 | 3.35629 | 1.29088 | 3.35629 | 3.35629 | 3.35629 | 1.29088 | 1.29088 | 0.0387264 | 2.6 | 0.100689 | 0.27 | 9.61 | 1.29088 | 0.100689 | 0.100689 | 2.64176 | 2.87 | 12.21 | 0.27 | 9.61 | 0.233453 | 2.44 | 90.6198 | 3.35629 | 3.35629 | 0.078 | 0.100689
F6 | Outside Face | Tiles - Terracota Arena 10x20 | Tiles - Terracota Arena 10x20 | F6 | Nau Santa Eulàlia | Tiles - Terracota Arena 10x20 | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 23.1167 (kgCO₂) | 400.096 | 0 | 2.2 | 2.2 | 0 | 0 | 0.997871 | 2.19532 | 2.19532 | 0 | 0.997871 | 0.997871 | 2.19532 | 0.997871 | 2.19532 | 2.19532 | 2.19532 | 0.997871 | 0.997871 | 0.0299361 | 2.2 | 0.0658595 | 0.27 | 9.61 | 0.997871 | 0.0658595 | 0.0658595 | 2.05574 | 2.47 | 11.81 | 0.27 | 9.61 | 0.191872 | 2.44 | 59.2736 | 2.19532 | 2.19532 | 0.066 | 0.0658595
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 30.2388 (kgCO₂) | 523.363 | 0 | 2.12777 | 1.75025 | 0 | 0 | 1.481 | 2.87169 | 2.87167 | 0 | 1.481 | 1.481 | 2.87169 | 1.481 | 2.87167 | 2.87169 | 2.87167 | 1.481 | 1.481 | 0.04443 | 2.34917 | 0.0861504 | 2.872 | 12.212 | 1.481 | 0.0861504 | 0.0861504 | 3.022 | 4.99977 | 14.3398 | 2.872 | 12.212 | 0.206621 | 2.44 | 77.5353 | 2.87169 | 2.87169 | 0.0704751 | 0.0861504
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 19.3041 (kgCO₂) | 334.109 | 0 | 1.74972 | 1.45839 | 0 | 0 | 1.14288 | 1.83324 | 1.83325 | 0 | 1.14288 | 1.14288 | 1.83324 | 1.14288 | 1.83325 | 1.83324 | 1.83325 | 1.14288 | 1.14288 | 0.0342864 | 2.34917 | 0.0549973 | 2.872 | 12.212 | 1.14288 | 0.0549973 | 0.0549973 | 2.34576 | 4.62172 | 13.9617 | 2.872 | 12.212 | 0.165913 | 2.44 | 49.4976 | 1.83325 | 1.83325 | 0.0704751 | 0.0549973
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 30.2382 (kgCO₂) | 523.353 | 0 | 2.12773 | 1.75022 | 0 | 0 | 1.481 | 2.87161 | 2.87164 | 0 | 1.481 | 1.481 | 2.87161 | 1.481 | 2.87164 | 2.87161 | 2.87164 | 1.481 | 1.481 | 0.04443 | 2.34917 | 0.0861487 | 2.872 | 12.212 | 1.481 | 0.0861487 | 0.0861487 | 3.022 | 4.99973 | 14.3397 | 2.872 | 12.212 | 0.206619 | 2.44 | 77.5338 | 2.87164 | 2.87164 | 0.0704751 | 0.0861487
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 13.7118 (kgCO₂) | 237.319 | 0 | 1.63614 | 0 | 0.442029 | 0.442029 | 1.14628 | 1.35516 | 1.24923 | 0.0132609 | 1.14628 | 0.216604 | 1.79719 | 0.216604 | 1.69126 | 1.86975 | 1.76382 | 1.14628 | 1.14628 | 0.00687235 | 2.20626 | 0.0390649 | 2.872 | 12.212 | 1.17123 | 0.0523258 | 0.0545024 | 2.35256 | 4.50814 | 13.8481 | 2.872 | 12.212 | 0.0418449 | 2.44 | 35.1584 | 1.35516 | 1.79719 | 0.0661879 | 0.0523258 | ArchiCADProperties - ID of Connected Openings: OP - 003
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 29.9107 (kgCO₂) | 517.686 | 0 | 2.12777 | 1.75479 | 0 | 0 | 1.46322 | 2.84054 | 2.84051 | 0 | 1.46322 | 1.46322 | 2.84054 | 1.46322 | 2.84051 | 2.84054 | 2.84051 | 1.46322 | 1.46322 | 0.0438967 | 2.34917 | 0.0852157 | 2.872 | 12.212 | 1.46322 | 0.0852157 | 0.0852157 | 2.98645 | 4.99977 | 14.3398 | 2.872 | 12.212 | 0.205674 | 2.44 | 76.6942 | 2.84054 | 2.84054 | 0.0704751 | 0.0852157
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.8552 (kgCO₂) | 326.341 | 0 | 2.6 | 0 | 1.144 | 1.144 | 1.13426 | 1.87529 | 1.70595 | 0.0343199 | 1.14628 | 1.12225 | 3.01929 | 1.14628 | 2.84995 | 3.14967 | 2.98033 | 1.12225 | 1.14628 | 0.033861 | 2.6 | 0.0537186 | 0.27 | 9.61 | 1.16126 | 0.0880385 | 0.0919499 | 2.33327 | 2.87 | 12.21 | 0.27 | 9.61 | 0.0398317 | 2.44 | 48.3468 | 1.87529 | 3.01929 | 0.078 | 0.0880385 | ArchiCADProperties - ID of Connected Openings: OP - 003
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 38.8606 (kgCO₂) | 672.587 | 0 | 2.6 | 0 | -3.04981e-09 | 0 | 1.49297 | 3.72096 | 3.65997 | -1.53589e-09 | 1.5 | 1.48593 | 3.72096 | 1.5 | 3.65997 | 3.96487 | 3.9 | 1.48593 | 1.5 | 0.0425823 | 2.6 | 0.110714 | 0.27 | 9.61 | 1.43412 | 0.110714 | 0.117973 | 3.04907 | 2.87 | 12.21 | 0.27 | 9.61 | 0.0851645 | 2.44 | 99.6425 | 3.72871 | 3.72871 | 0.078 | 0.110714
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 28.249 (kgCO₂) | 488.925 | 0 | 2.00844 | 0 | -2.03599e-09 | 0 | 1.5 | 2.70337 | 2.66204 | -1.06585e-09 | 1.5 | 1.5 | 2.70337 | 1.5 | 2.66204 | 2.76678 | 2.72569 | 1.5 | 1.5 | 0.0442037 | 2.20626 | 0.0804815 | 2.872 | 12.212 | 1.48593 | 0.0804815 | 0.0823874 | 3.06 | 4.88044 | 14.2204 | 2.872 | 12.212 | 0.150068 | 2.44 | 72.4333 | 2.70337 | 2.70337 | 0.0661879 | 0.0804815
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 19.0964 (kgCO₂) | 330.515 | 0 | 1.51498 | 1.28199 | 0.328927 | 0.328927 | 1.385 | 1.81344 | 1.81361 | 0.00986781 | 1.385 | 0 | 2.14237 | 0 | 2.14254 | 2.14237 | 2.14254 | 1.385 | 1.385 | 0 | 1.72236 | 0.0544058 | 3.3559 | 12.6959 | 1.385 | 0.0642736 | 0.0642736 | 2.83 | 5 | 14.34 | 3.48502 | 12.825 | 0.123174 | 2.44 | 48.9652 | 1.8138 | 2.14273 | 0.0516708 | 0.0642736 | ArchiCADProperties - ID of Connected Openings: OP - 003
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 30.1629 (kgCO₂) | 522.05 | 0 | 1.89491 | 1.4598 | 0 | 0 | 1.70773 | 2.86414 | 2.86481 | 0 | 1.70773 | 1.70773 | 2.86414 | 1.70773 | 2.86481 | 2.86414 | 2.86481 | 1.70773 | 1.70773 | 0.051232 | 2.20626 | 0.0859342 | 2.872 | 12.212 | 1.70773 | 0.0859342 | 0.0859342 | 3.47546 | 4.76691 | 14.1069 | 2.872 | 12.212 | 0.204743 | 2.44 | 77.3408 | 2.86481 | 2.86481 | 0.0661879 | 0.0859342
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 46.7543 (kgCO₂) | 809.209 | 0 | 2.6 | 2.6 | 0 | 0 | 1.70773 | 4.4401 | 4.4401 | 0 | 1.70773 | 1.70773 | 4.4401 | 1.70773 | 4.4401 | 4.4401 | 4.4401 | 1.70773 | 1.70773 | 0.051232 | 2.6 | 0.133203 | 0.27 | 9.61 | 1.70773 | 0.133203 | 0.133203 | 3.47546 | 2.87 | 12.21 | 0.27 | 9.61 | 0.258464 | 2.44 | 119.883 | 4.4401 | 4.4401 | 0.078 | 0.133203
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Espai d'espera; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 41.4078 (kgCO₂) | 716.673 | 0 | 2.6 | 0 | 0 | 0 | 1.60997 | 3.93457 | 3.93016 | 0 | 1.62415 | 1.59579 | 3.93457 | 1.62415 | 3.93016 | 4.22719 | 4.22278 | 1.59579 | 1.62415 | 0.0478484 | 2.6 | 0.117971 | 0.27 | 9.61 | 1.59579 | 0.117971 | 0.12675 | 3.29122 | 2.87 | 12.21 | 0.27 | 9.61 | 0.173697 | 2.44 | 106.174 | 3.93457 | 4.14907 | 0.078 | 0.124406
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 19.3038 (kgCO₂) | 334.105 | 0 | 1.7497 | 1.45837 | 0 | 0 | 1.14288 | 1.83323 | 1.83321 | 0 | 1.14288 | 1.14288 | 1.83323 | 1.14288 | 1.83321 | 1.83323 | 1.83321 | 1.14288 | 1.14288 | 0.0342864 | 2.34917 | 0.0549967 | 2.872 | 12.212 | 1.14288 | 0.0549967 | 0.0549967 | 2.34576 | 4.6217 | 13.9617 | 2.872 | 12.212 | 0.165911 | 2.44 | 49.497 | 1.83323 | 1.83323 | 0.0704751 | 0.0549967
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | F1_Extradossat_190 | F1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 0.193443 (kgCO₂) | 3.34805 | 0 | 0.136317 | 0 | 0 | 0 | 1.385 | 0.188799 | 0 | 0 | 1.385 | 1.385 | 0.188799 | 1.385 | 0 | 0.188799 | 0.188799 | 1.385 | 1.385 | 0.00404294 | 0.136317 | 0.000551119 | 0.27 | 9.61 | 1.385 | 0.000551119 | 0.00566396 | 2.83 | 0.406317 | 9.74632 | 0.27 | 9.61 | 0.00888171 | 2.44 | 0.496007 | 0.188799 | 0.188799 | 0.0040895 | 0.000551119
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 34.037 (kgCO₂) | 589.102 | 0 | 2.6 | 2.6 | 0 | 0 | 1.24322 | 3.23238 | 3.23238 | 0 | 1.24322 | 1.24322 | 3.23238 | 1.24322 | 3.23238 | 3.23238 | 3.23238 | 1.24322 | 1.24322 | 0.0372967 | 2.6 | 0.0969714 | 0.27 | 9.61 | 1.24322 | 0.0969714 | 0.0969714 | 2.54645 | 2.87 | 12.21 | 0.27 | 9.61 | 0.230593 | 2.44 | 87.2743 | 3.23238 | 3.23238 | 0.078 | 0.0969714
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Espai d'espera; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.6746 (kgCO₂) | 323.215 | 0 | 1.37 | 1.10802 | 0 | 0 | 1.406 | 1.77361 | 1.77333 | 0 | 1.406 | 1.406 | 1.77361 | 1.406 | 1.77333 | 1.77361 | 1.77333 | 1.406 | 1.406 | 0.04218 | 1.98647 | 0.0532041 | 3.63 | 12.97 | 1.406 | 0.0532041 | 0.0532041 | 2.872 | 5 | 14.34 | 3.63 | 12.97 | 0.157174 | 2.44 | 47.8837 | 1.77377 | 1.77377 | 0.0595942 | 0.0532041
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Espai d'espera; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 43.0281 (kgCO₂) | 744.718 | 2 | 2.6 | 0 | 0 | 0 | 1.55313 | 4.04211 | 4.05666 | 0 | 1.56026 | 1.546 | 4.04211 | 1.56026 | 4.05666 | 4.12023 | 4.05666 | 1.546 | 1.56026 | 0.047149 | 2.6 | 0.122587 | 0.27 | 9.61 | 1.5847 | 0.122587 | 0.122653 | 3.16947 | 2.87 | 12.21 | 0.27 | 9.61 | 0.172298 | 2.44 | 110.329 | 4.12023 | 4.12023 | 0.078 | 0.122653
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Espai d'espera; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 27.9288 (kgCO₂) | 483.382 | 0 | 1.86594 | 0 | 0 | 0 | 1.62415 | 2.65388 | 2.65073 | 0 | 1.62415 | 1.62415 | 2.65388 | 1.62415 | 2.65073 | 2.69736 | 2.69421 | 1.62415 | 1.62415 | 0.0487244 | 2.18759 | 0.0795691 | 2.872 | 12.212 | 1.62415 | 0.0795691 | 0.0808735 | 3.30829 | 4.73794 | 14.0779 | 2.872 | 12.212 | 0.154103 | 2.44 | 71.6122 | 2.65388 | 2.65388 | 0.0656276 | 0.0795691
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 27.9687 (kgCO₂) | 484.073 | 0 | 1.85349 | 0 | 0 | 0 | 1.6406 | 2.65777 | 2.65442 | 0 | 1.6406 | 1.6406 | 2.65777 | 1.6406 | 2.65442 | 2.70103 | 2.69768 | 1.6406 | 1.6406 | 0.0483432 | 2.26687 | 0.0796829 | 2.872 | 12.212 | 1.61234 | 0.0796829 | 0.0809807 | 3.34119 | 4.72549 | 14.0655 | 2.872 | 12.212 | 0.15383 | 2.44 | 71.7146 | 2.65777 | 2.65777 | 0.0680062 | 0.0796829
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Espai d'espera; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 30.3161 (kgCO₂) | 524.702 | 0 | 2.03166 | 0 | 0 | 0 | 1.56026 | 2.87326 | 2.86014 | 0 | 1.56026 | 1.56026 | 2.87326 | 1.56026 | 2.86014 | 2.89935 | 2.86014 | 1.56026 | 1.56026 | 0.047149 | 2.18759 | 0.0863707 | 2.872 | 12.212 | 1.5847 | 0.0863707 | 0.0863928 | 3.18051 | 4.90366 | 14.2437 | 2.872 | 12.212 | 0.156775 | 2.44 | 77.7336 | 2.90003 | 2.90003 | 0.0656276 | 0.0863928
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.1405 (kgCO₂) | 279.355 | 0 | 2.6 | 0 | 1.144 | 1.144 | 1.07112 | 1.60724 | 1.45839 | 0.0343199 | 1.08407 | 1.05817 | 2.75123 | 1.08407 | 2.60238 | 2.96743 | 2.81858 | 1.05817 | 1.08407 | 0.0308863 | 2.6 | 0.0459844 | 0.27 | 9.61 | 1.05817 | 0.0803043 | 0.0867902 | 2.20763 | 2.87 | 12.21 | 0.27 | 9.61 | 0.0338823 | 2.44 | 41.3859 | 1.60724 | 2.75123 | 0.078 | 0.0803043 | ArchiCADProperties - ID of Connected Openings: OP - 003
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 44.118 (kgCO₂) | 763.581 | 0 | 2.6 | 0 | 0 | 0 | 1.62647 | 4.19208 | 4.18741 | 0 | 1.6406 | 1.61234 | 4.19208 | 1.6406 | 4.18741 | 4.27022 | 4.26555 | 1.61234 | 1.6406 | 0.0483432 | 2.6 | 0.125692 | 0.27 | 9.61 | 1.61234 | 0.125692 | 0.128037 | 3.32415 | 2.87 | 12.21 | 0.27 | 9.61 | 0.174686 | 2.44 | 113.123 | 4.19208 | 4.19208 | 0.078 | 0.125692
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 12.09 (kgCO₂) | 209.251 | 0 | 1.63778 | 0 | 0.442029 | 0.442029 | 1.08407 | 1.19486 | 1.10151 | 0.0132609 | 1.08407 | 0.154394 | 1.63689 | 0.154394 | 1.54354 | 1.76472 | 1.67098 | 1.08407 | 1.08407 | 0.00383752 | 2.18759 | 0.0344446 | 2.872 | 12.212 | 1.06982 | 0.0477054 | 0.0515346 | 2.22814 | 4.50978 | 13.8498 | 2.872 | 12.212 | 0.0357383 | 2.44 | 31.0001 | 1.19486 | 1.63689 | 0.0656276 | 0.0477054 | ArchiCADProperties - ID of Connected Openings: OP - 003
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.8816 (kgCO₂) | 326.797 | 0 | 1.51403 | 1.23944 | 0.149657 | 0.149657 | 1.389 | 1.7933 | 1.79294 | 0.00448972 | 1.389 | 1.04361e-14 | 1.94296 | 1.04361e-14 | 1.9426 | 1.94296 | 1.9426 | 1.389 | 1.389 | 0 | 1.6529 | 0.0537937 | 3.48597 | 12.826 | 1.389 | 0.0582834 | 0.0582834 | 2.838 | 5 | 14.34 | 3.48597 | 12.826 | 0.123243 | 2.44 | 48.4143 | 1.79345 | 1.94311 | 0.0495871 | 0.0582834 | ArchiCADProperties - ID of Connected Openings: OP - 003
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 11.9233 (kgCO₂) | 206.366 | 0 | 1.62174 | 0 | 0.442029 | 0.434437 | 1.08016 | 1.17637 | 1.09049 | 0.0131789 | 1.08016 | 0.150481 | 1.6184 | 0.166449 | 1.52493 | 1.7463 | 1.65247 | 1.08016 | 1.08016 | 0.00341069 | 2.26687 | 0.0339696 | 2.872 | 12.212 | 1.06502 | 0.0471485 | 0.0509802 | 2.22031 | 4.49374 | 13.8337 | 2.872 | 12.212 | 0.0351614 | 2.44 | 30.5727 | 1.17637 | 1.6184 | 0.0680062 | 0.0471485 | ArchiCADProperties - ID of Connected Openings: OP - 003
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 46.6701 (kgCO₂) | 807.752 | 0 | 2.6 | 0 | 0 | 0 | 1.68601 | 4.46093 | 4.40329 | 0 | 1.69357 | 1.67844 | 4.46093 | 1.69357 | 4.40329 | 4.46093 | 4.40329 | 1.67844 | 1.69357 | 0.0511397 | 2.6 | 0.132963 | 0.27 | 9.61 | 1.71574 | 0.132963 | 0.132963 | 3.43561 | 2.87 | 12.21 | 0.27 | 9.61 | 0.180279 | 2.44 | 119.667 | 4.46093 | 4.46093 | 0.078 | 0.132963
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 32.8439 (kgCO₂) | 568.452 | 0 | 2.04871 | 0 | 0 | 0 | 1.69157 | 3.13657 | 3.10156 | 0 | 1.69157 | 1.69157 | 3.13657 | 1.69157 | 3.10156 | 3.13657 | 3.10156 | 1.69157 | 1.69157 | 0.0510797 | 2.26687 | 0.0935723 | 2.872 | 12.212 | 1.71374 | 0.0935723 | 0.0935723 | 3.44314 | 4.92071 | 14.2607 | 2.872 | 12.212 | 0.165247 | 2.44 | 84.2151 | 3.13738 | 3.13738 | 0.0680062 | 0.0935723
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.0955 (kgCO₂) | 278.577 | 0 | 2.6 | 0 | 1.144 | 1.12435 | 1.06712 | 1.5966 | 1.46598 | 0.0341077 | 1.08016 | 1.05407 | 2.74059 | 1.08016 | 2.59033 | 2.95867 | 2.80841 | 1.05407 | 1.08016 | 0.0307553 | 2.6 | 0.0458562 | 0.27 | 9.61 | 1.05407 | 0.0799639 | 0.0865061 | 2.19977 | 2.87 | 12.21 | 0.27 | 9.61 | 0.0337929 | 2.44 | 41.2706 | 1.5966 | 2.74059 | 0.078 | 0.0799639 | ArchiCADProperties - ID of Connected Openings: OP - 003
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 33.6038 (kgCO₂) | 581.604 | 0 | 2.598 | 2.598 | 0 | 0 | 1.22835 | 3.19124 | 3.19124 | 0 | 1.22835 | 1.22835 | 3.19124 | 1.22835 | 3.19124 | 3.19124 | 3.19124 | 1.22835 | 1.22835 | 0.0368504 | 2.598 | 0.0957373 | 1.71425 | 11.0543 | 1.22835 | 0.0957373 | 0.0957373 | 2.51669 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.229581 | 2.598 | 86.1636 | 3.19124 | 3.19124 | 0.07794 | 0.0957373
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 1.99092 (kgCO₂) | 34.4582 | 0 | 0.136317 | 0.136317 | 0 | 0 | 1.387 | 0.189071 | 0.189071 | 0 | 1.387 | 1.387 | 0.189071 | 1.387 | 0.189071 | 0.189071 | 0.189071 | 1.387 | 1.387 | 0.04161 | 0.136317 | 0.00567213 | 0.27 | 9.61 | 1.387 | 0.00567213 | 0.00567213 | 2.834 | 0.406317 | 9.74632 | 0.27 | 9.61 | 0.091399 | 2.44 | 5.10492 | 0.189071 | 0.189071 | 0.0040895 | 0.00567213
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_140 | 16.9403 (kgCO₂) | 293.197 | 0 | 2.598 | 2.598 | 0 | 0 | 0.619232 | 1.60876 | 1.60876 | 0 | 0.619232 | 0.619232 | 1.60876 | 0.619232 | 1.60876 | 1.60876 | 1.60876 | 0.619232 | 0.619232 | 0.018577 | 2.598 | 0.0482629 | 1.71425 | 11.0543 | 0.619232 | 0.0482629 | 0.0482629 | 1.29846 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.193034 | 2.598 | 43.4366 | 1.60876 | 1.60876 | 0.07794 | 0.0482629
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_140 | 17.5051 (kgCO₂) | 302.974 | 0 | 2.78213 | 2.58713 | 0 | 0 | 0.619232 | 1.66241 | 1.66241 | 0 | 0.619232 | 0.619232 | 1.66241 | 0.619232 | 1.66241 | 1.7611 | 1.7611 | 0.619232 | 0.619232 | 0.018577 | 2.844 | 0.0498722 | 4.31625 | 13.6563 | 0.619232 | 0.0498722 | 0.0528329 | 1.29846 | 7.09838 | 16.4384 | 4.31625 | 13.6563 | 0.179655 | 2.844 | 44.885 | 1.66241 | 1.7611 | 0.08532 | 0.0528329
F5 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F5 | Nau Lateral; Sala d'actes | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 35.099 (kgCO₂) | 607.482 | 0 | 2.598 | 2.598 | 0 | 0 | 1.283 | 3.33323 | 3.33323 | 0 | 1.283 | 1.283 | 3.33323 | 1.283 | 3.33323 | 3.33323 | 3.33323 | 1.283 | 1.283 | 0.03849 | 2.598 | 0.099997 | 1.71425 | 11.0543 | 1.283 | 0.099997 | 0.099997 | 2.626 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.23286 | 2.598 | 89.9973 | 3.33323 | 3.33323 | 0.07794 | 0.099997
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 1.51338 (kgCO₂) | 26.1932 | 0 | 0.302572 | 0.0320521 | 0 | 0 | 0.859 | 0.143725 | 0.143718 | 0 | 0.859 | 0.859 | 0.143725 | 0.859 | 0.143718 | 0.363675 | 0.363668 | 0.859 | 0.859 | 0.02577 | 2.81803 | 0.00431163 | 7.16228 | 16.5023 | 0.859 | 0.00431163 | 0.0109101 | 1.778 | 7.46485 | 16.8049 | 7.16228 | 16.5023 | 0.0358087 | 2.81803 | 3.88047 | 0.143718 | 0.363668 | 0.0845408 | 0.0109101
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 19.2224 (kgCO₂) | 332.696 | 0 | 2.21992 | 2.21992 | 0.617503 | 0.617503 | 0.859 | 1.82549 | 1.82549 | 0.0185251 | 0.859 | 0 | 2.443 | 0 | 2.443 | 2.443 | 2.443 | 0.859 | 0.859 | 0 | 2.844 | 0.0547648 | 4.31625 | 13.6563 | 0.859 | 0.0732899 | 0.0732899 | 1.778 | 7.16025 | 16.5003 | 4.94033 | 14.2803 | 0.154722 | 2.844 | 49.2883 | 1.82549 | 2.443 | 0.08532 | 0.0732899 | ArchiCADProperties - ID of Connected Openings: OP - 003
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 19.2241 (kgCO₂) | 332.725 | 0 | 2.21999 | 2.21999 | 0.617342 | 0.617342 | 0.859 | 1.82565 | 1.82565 | 0.0185203 | 0.859 | 0 | 2.443 | 0 | 2.443 | 2.443 | 2.443 | 0.859 | 0.859 | 0 | 2.844 | 0.0547696 | 4.31625 | 13.6563 | 0.859 | 0.0732899 | 0.0732899 | 1.778 | 7.16025 | 16.5003 | 4.94026 | 14.2803 | 0.154723 | 2.844 | 49.2927 | 1.82565 | 2.443 | 0.08532 | 0.0732899 | ArchiCADProperties - ID of Connected Openings: OP - 003
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 8.55461 (kgCO₂) | 148.061 | 0 | 0.931198 | 0.240659 | 0.183652 | 0.183651 | 1.283 | 0.812408 | 0.812399 | 0.00550954 | 1.283 | 1.283 | 0.99606 | 1.283 | 0.996049 | 1.32458 | 1.32457 | 1.283 | 1.283 | 0.03849 | 2.81803 | 0.0243721 | 7.16228 | 16.5023 | 1.283 | 0.0298816 | 0.0397372 | 2.626 | 8.09348 | 17.4335 | 7.16228 | 16.5023 | 0.0629397 | 2.81803 | 21.9349 | 0.812403 | 1.32457 | 0.0845408 | 0.0397372 | ArchiCADProperties - ID of Connected Openings: OP - 003
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 3.96676 (kgCO₂) | 68.6554 | 0 | 0.573805 | 0.303285 | 0 | 0 | 0.859 | 0.376713 | 0.376706 | 0 | 0.859 | 0.859 | 0.376713 | 0.859 | 0.376706 | 0.596664 | 0.596657 | 0.859 | 0.859 | 0.02577 | 2.81803 | 0.0113013 | 7.16228 | 16.5023 | 0.859 | 0.0113013 | 0.0178998 | 1.778 | 7.73609 | 17.0761 | 7.16228 | 16.5023 | 0.0520827 | 2.81803 | 10.1712 | 0.376706 | 0.596657 | 0.0845408 | 0.0178998
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 19.2264 (kgCO₂) | 332.765 | 0 | 2.22059 | 2.22059 | 0.617126 | 0.617126 | 0.859 | 1.82587 | 1.82587 | 0.0185138 | 0.859 | 0 | 2.443 | 0 | 2.443 | 2.443 | 2.443 | 0.859 | 0.859 | 0 | 2.844 | 0.0547761 | 4.31625 | 13.6563 | 0.859 | 0.0732899 | 0.0732899 | 1.778 | 7.16025 | 16.5003 | 4.93966 | 14.2797 | 0.154749 | 2.844 | 49.2985 | 1.82587 | 2.443 | 0.08532 | 0.0732899 | ArchiCADProperties - ID of Connected Openings: OP - 003
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 25.6457 (kgCO₂) | 443.868 | 0 | 2.844 | 2.59705 | 0 | 0 | 0.890407 | 2.43549 | 2.43549 | 0 | 0.890407 | 0.890407 | 2.43549 | 0.890407 | 2.43549 | 2.53232 | 2.53232 | 0.890407 | 0.890407 | 0.0267122 | 2.844 | 0.0730647 | 4.31625 | 13.6563 | 0.890407 | 0.0730647 | 0.0759695 | 1.84081 | 7.16025 | 16.5003 | 4.31625 | 13.6563 | 0.193131 | 2.844 | 65.7583 | 2.43549 | 2.53232 | 0.08532 | 0.0759695
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 |  | Wood - Pine Grained Horizontal blank | 1 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 7.59795 (kgCO₂) | 131.503 | 0 | 1.65398 | 0 | 0.583025 | 0.583025 | 0.859 | 0.721556 | 0.721549 | 0.0174908 | 0.859 | 0.859 | 1.30458 | 0.859 | 1.30457 | 1.52453 | 1.52452 | 0.859 | 0.859 | 0.021213 | 2.844 | 0.0216466 | 7.16228 | 16.5023 | 0.859 | 0.0391373 | 0.0457358 | 1.778 | 8.81626 | 18.1563 | 7.16228 | 16.5023 | 0.0767986 | 2.844 | 19.4819 | 0.721549 | 1.52452 | 0.08532 | 0.0457358 | ArchiCADProperties - ID of Connected Openings: OP - 003
