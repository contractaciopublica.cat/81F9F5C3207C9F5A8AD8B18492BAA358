Properties of the parts of a building model (IFC2X3), part 83 of 99

# IfcBuildingElementProxy: Rhino_Object_459 (4)
ArchiCADQuantities - Length (A): 1.16978 m; Area: 0.995912 m2; Height: 2.693 m; Volume (Net): 0.0896178 m3; Width: 0.851365 m; Elevation to Project Zero: 1.19947 m; Elevation to 1st Reference Level: 1.19947 m; Elevation to 2nd Reference Level: 1.19947 m; Elevation to Sea Level: 10.5395 m; Elevation to Linked/Home Story: 1.19947 m; Home Offset: 1.19947 m; Surface Area: 3.78638 m2; Top Elevation To First Reference Level: 3.89247 m; Top Elevation To Home Story: 3.89247 m; Top Elevation To Project Zero: 3.89247 m; Top Elevation To Sea Level: 13.2325 m; Top Elevation To Second Reference Level: 3.89247 m; Bottom Elevation To First Reference Level: 1.19947 m; Bottom Elevation To Home Story: 1.19947 m; Bottom Elevation To Project Zero: 1.19947 m; Bottom Elevation To Sea Level: 10.5395 m; Bottom Elevation To Second Reference Level: 1.19947 m; Survey Coordinate Z: 10.5395 m; Top Surface Area (Net): 0.995912 m2; Bottom Surface Area (Net): 3.78638 m2
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_459_; 109.AMB.CodiTipus: Object_459; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Pset_Rhino_Object_459 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m) | Colliding Zones
Object_459 | 12.3076 | 426589 | 4579799
Object_459 | 89.1077 | 426537 | 4579784 | Espai públic
Object_459 | 299.52 | 426558 | 4579790 | Espai públic; Nau Santa Eulàlia
Object_459 | 100.931 | 426568 | 4579793 | Espai públic; Nau Santa Eulàlia

# IfcBuildingElementProxy: Rhino_Object_46, Object_46
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_46 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_46; Hotlink and Element ID: Object_46; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_46; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_46; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 21.8418 m; Area: 29.8329 m2; Height: 0.05 m; Volume (Net): 0.0328211 m3; Width: 1.36586 m; Elevation to Project Zero: 4.2598 m; Elevation to 1st Reference Level: 4.2598 m; Elevation to 2nd Reference Level: 4.2598 m; Elevation to Sea Level: 13.5998 m; Elevation to Linked/Home Story: 4.2598 m; Home Offset: 4.2598 m; Surface Area: 3.50392 m2; Top Elevation To First Reference Level: 4.3098 m; Top Elevation To Home Story: 4.3098 m; Top Elevation To Project Zero: 4.3098 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.3098 m; Bottom Elevation To First Reference Level: 4.2598 m; Bottom Elevation To Home Story: 4.2598 m; Bottom Elevation To Project Zero: 4.2598 m; Bottom Elevation To Sea Level: 13.5998 m; Bottom Elevation To Second Reference Level: 4.2598 m; Survey Coordinate X: 426569 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.5998 m; Top Surface Area (Net): 29.8329 m2; Bottom Surface Area (Net): 3.50392 m2
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_46_; 109.AMB.CodiTipus: Object_46; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
5 AMB.Geometria - 502.AMB.Amplada: 1.36586 m; 503.AMB.Altura: 0.05 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0328211 m3; Component, Component Volume (Gross): 0.0328211 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_46 - Dimension 1: 21.8418 m; Dimension 2: 1.36586 m; Height: 0.05 m; Bottom Level: 0 m; Top Level: 0.05 m

# IfcBuildingElementProxy: Rhino_Object_462 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_462; Hotlink and Element ID: Object_462; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_462; Building Material / Composite / Profile / Fill: Common Brick; Fill Type: Common Brick; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_462; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_462 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_462_; 109.AMB.CodiTipus: Object_462; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.649034 m; Area: 0.380733 m2; Height: 2.79183 m; Volume (Net): 0.840774 m3; Width: 0.586615 m; Elevation to Project Zero: 1.28155 m; Elevation to 1st Reference Level: 1.28155 m; Elevation to 2nd Reference Level: 1.28155 m; Elevation to Sea Level: 10.6216 m; Elevation to Linked/Home Story: 1.28155 m; Home Offset: 1.28155 m; Surface Area: 6.81863 m2; Top Elevation To First Reference Level: 4.07338 m; Top Elevation To Home Story: 4.07338 m; Top Elevation To Project Zero: 4.07338 m; Top Elevation To Sea Level: 13.4134 m; Top Elevation To Second Reference Level: 4.07338 m; Bottom Elevation To First Reference Level: 1.28155 m; Bottom Elevation To Home Story: 1.28155 m; Bottom Elevation To Project Zero: 1.28155 m; Bottom Elevation To Sea Level: 10.6216 m; Bottom Elevation To Second Reference Level: 1.28155 m; Survey Coordinate Z: 10.6216 m; Top Surface Area (Net): 0.380733 m2; Bottom Surface Area (Net): 6.81863 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.586615 m; 503.AMB.Altura: 2.79183 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.840774 m3; Component, Component Volume (Gross): 0.840774 m3
AC_Equantity_Rhino_Object_462 - Dimension 1: 0.649034 m; Dimension 2: 0.586615 m; Height: 2.79183 m; Bottom Level: -8.55142e-10 m; Top Level: 2.79183 m
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_462 | 13.5006 | 426561 | 4579785
Object_462 | 20.6313 | 426569 | 4579787

# IfcBuildingElementProxy: Rhino_Object_464 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_464; Hotlink and Element ID: Object_464; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_464; Building Material / Composite / Profile / Fill: Common Brick; Fill Type: Common Brick; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_464; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_464 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 2; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 5; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_464_; 109.AMB.CodiTipus: Object_464; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.815799 m; Area: 0.486881 m2; Height: 2.76056 m; Volume (Net): 0.854934 m3; Width: 0.596815 m; Elevation to Project Zero: 1.28155 m; Elevation to 1st Reference Level: 1.28155 m; Elevation to 2nd Reference Level: 1.28155 m; Elevation to Sea Level: 10.6216 m; Elevation to Linked/Home Story: 1.28155 m; Home Offset: 1.28155 m; Surface Area: 7.11893 m2; Top Elevation To First Reference Level: 4.04211 m; Top Elevation To Home Story: 4.04211 m; Top Elevation To Project Zero: 4.04211 m; Top Elevation To Sea Level: 13.3821 m; Top Elevation To Second Reference Level: 4.04211 m; Bottom Elevation To First Reference Level: 1.28155 m; Bottom Elevation To Home Story: 1.28155 m; Bottom Elevation To Project Zero: 1.28155 m; Bottom Elevation To Sea Level: 10.6216 m; Bottom Elevation To Second Reference Level: 1.28155 m; Survey Coordinate Z: 10.6216 m; Top Surface Area (Net): 0.486881 m2; Bottom Surface Area (Net): 7.11893 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_464 - Dimension 1: 0.815799 m; Dimension 2: 0.596815 m; Height: 2.76056 m; Bottom Level: -1.0445e-12 m; Top Level: 2.76056 m
5 AMB.Geometria - 502.AMB.Amplada: 0.596815 m; 503.AMB.Altura: 2.76056 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.854934 m3; Component, Component Volume (Gross): 0.854934 m3
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_464 | 13.5006 | 426563 | 4579786
Object_464 | 20.6313 | 426566 | 4579787

# IfcBuildingElementProxy: Rhino_Object_467 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_467; Hotlink and Element ID: Object_467; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_467; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_467; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_467 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_467_; 109.AMB.CodiTipus: Object_467; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_467 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_467 | 20.6313 | 426569 | 4579787
Object_467 | 13.5006 | 426561 | 4579785

# IfcBuildingElementProxy: Rhino_Object_468 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_468; Hotlink and Element ID: Object_468; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_468; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_468; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_468 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_468_; 109.AMB.CodiTipus: Object_468; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_468 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_468 | 20.6313 | 426568 | 4579787
Object_468 | 13.5006 | 426561 | 4579785

# IfcBuildingElementProxy: Rhino_Object_469 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_469_; 109.AMB.CodiTipus: Object_469; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_469 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_469; Hotlink and Element ID: Object_469; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_469; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_469; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Equantity_Rhino_Object_469 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_469 | 20.6313 | 426568 | 4579787
Object_469 | 13.5006 | 426561 | 4579785

# IfcBuildingElementProxy: Rhino_Object_470 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_470 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_470_; 109.AMB.CodiTipus: Object_470; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_470; Hotlink and Element ID: Object_470; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_470; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_470; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_470 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_470 | 20.6313 | 426568 | 4579787
Object_470 | 13.5006 | 426562 | 4579785

# IfcBuildingElementProxy: Rhino_Object_471 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_471 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_471; Hotlink and Element ID: Object_471; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_471; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_471; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_471_; 109.AMB.CodiTipus: Object_471; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
AC_Equantity_Rhino_Object_471 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_471 | 20.6313 | 426568 | 4579787
Object_471 | 13.5006 | 426562 | 4579785

# IfcBuildingElementProxy: Rhino_Object_472 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_472; Hotlink and Element ID: Object_472; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_472; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_472; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_472 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_472_; 109.AMB.CodiTipus: Object_472; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_472 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_472 | 20.6313 | 426568 | 4579787
Object_472 | 13.5006 | 426562 | 4579785

# IfcBuildingElementProxy: Rhino_Object_473 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_473; Hotlink and Element ID: Object_473; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_473; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_473; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_473 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_473_; 109.AMB.CodiTipus: Object_473; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_473 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_473 | 20.6313 | 426567 | 4579787
Object_473 | 13.5006 | 426562 | 4579785

# IfcBuildingElementProxy: Rhino_Object_474 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_474; Hotlink and Element ID: Object_474; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_474; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_474; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_474_; 109.AMB.CodiTipus: Object_474; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_474 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_474 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
Pset_BuildingElementProxyCommon - Status: EXISTING
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_474 | 20.6313 | 426567 | 4579787
Object_474 | 13.5006 | 426562 | 4579785

# IfcBuildingElementProxy: Rhino_Object_475 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_475; Hotlink and Element ID: Object_475; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_475; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_475; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_475 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_475 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_475_; 109.AMB.CodiTipus: Object_475; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_475 | 20.6313 | 426567 | 4579786
Object_475 | 13.5006 | 426563 | 4579785

# IfcBuildingElementProxy: Rhino_Object_476 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_476; Hotlink and Element ID: Object_476; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_476; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_476; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_476 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_476 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_476_; 109.AMB.CodiTipus: Object_476; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_476 | 20.6313 | 426567 | 4579786
Object_476 | 13.5006 | 426563 | 4579785

# IfcBuildingElementProxy: Rhino_Object_477 (2)
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Surface: Brick - Aged Natural; Element ID: Object_477; Hotlink and Element ID: Object_477; Layer: 00_ORNAMENTOS PLANTA; Library Part Name: Rhino_Object_477; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_477; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_477 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_477_; 109.AMB.CodiTipus: Object_477; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.12 m; Volume (Net): 0.00120376 m3; Width: 0.111797 m; Elevation to Project Zero: 1.32885 m; Elevation to 1st Reference Level: 1.32885 m; Elevation to 2nd Reference Level: 1.32885 m; Elevation to Sea Level: 10.6688 m; Elevation to Linked/Home Story: 1.32885 m; Home Offset: 1.32885 m; Surface Area: 0.0782062 m2; Top Elevation To First Reference Level: 1.44885 m; Top Elevation To Home Story: 1.44885 m; Top Elevation To Project Zero: 1.44885 m; Top Elevation To Sea Level: 10.7888 m; Top Elevation To Second Reference Level: 1.44885 m; Bottom Elevation To First Reference Level: 1.32885 m; Bottom Elevation To Home Story: 1.32885 m; Bottom Elevation To Project Zero: 1.32885 m; Bottom Elevation To Sea Level: 10.6688 m; Bottom Elevation To Second Reference Level: 1.32885 m; Survey Coordinate Z: 10.6688 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0782062 m2
AC_Equantity_Rhino_Object_477 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.12 m; Bottom Level: 0 m; Top Level: 0.12 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.12 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120376 m3; Component, Component Volume (Gross): 0.00120376 m3
Name | Rotation Angle (deg) | Survey Coordinate X (m) | Survey Coordinate Y (m)
Object_477 | 20.6313 | 426567 | 4579786
Object_477 | 13.5006 | 426563 | 4579785

# IfcBuildingElementProxy: Rhino_Object_48, Object_48
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_48 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_48_; 109.AMB.CodiTipus: Object_48; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
