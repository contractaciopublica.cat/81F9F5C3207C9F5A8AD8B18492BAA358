Properties of the parts of a building model (IFC2X3), part 91 of 99

# IfcBuildingElementProxy: Ridge Tile 27 (333)
Name | Classification | Rotation Angle (deg) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Renovation Status | Inclination (deg) | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | 119.AMB.FaseCreacio = 120.AMB.FaseEnderroc | AUX_107.NomTipus | Status | Length (A) (m) | Area (m2) = Top Surface Area (Net) (m2) | ArchiCADQuantities, Height (m) = AC_Equantity_Ridge_Tile_27, Height (m) = 503.AMB.Altura (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) = Survey Coordinate Z (m) | Surface Area (m2) = Bottom Surface Area (Net) (m2) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Survey Coordinate X (m) | Survey Coordinate Y (m) | Ridge Height (m) | Full Length (m)
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 6.61155 | 1.18347 | 1.7455 | 0.02922 | 4.68956 | 14.0296 | 3.55599 | 6.46995 | 15.8099 | 426588 | 4579800 | 1.69756 | 6.826
5 x Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 283.57 | Cu3 | New | 36.5 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 2.49196 | 0.44606 | 1.88374 | 0.0132944 | 4.75337 | 14.0934 | 1.61843 | 6.66026 | 16.0003 | 426531 | 4579794 | 1.84395 | 3.1
5 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 3.95836 | 0.708547 | 1.29376 | 0.0177794 | 7.53393 | 16.8739 | 2.16067 | 8.8505 | 18.1905 | 426534 | 4579814 | 1.24655 | 4.15
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 4.84292 | 0.866882 | 1.29139 | 0.0213934 | 5.1388 | 14.4788 | 2.60725 | 6.46762 | 15.8076 | 426568 | 4579792 | 1.24345 | 5
2 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 5.61778 | 1.00558 | 1.49035 | 0.0248163 | 4.93716 | 14.2772 | 3.02284 | 6.46493 | 15.8049 | 426568 | 4579793 | 1.4424 | 5.8
3 x Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 5.42407 | 0.970908 | 1.44061 | 0.0239606 | 4.98856 | 14.3286 | 2.91894 | 6.4666 | 15.8066 | 426588 | 4579799 | 1.39266 | 5.6
Cu1 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 287.066 | Cu1 | New | 14.4 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Cu1_CobertaR60 | Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat | Nau Santa Eulalia | Obra | CobertaR60 | NEW | 5.03663 | 0.901557 | 1.34113 | 0.0222491 | 5.08471 | 14.4247 | 2.71115 | 6.46327 | 15.8033 | 426568 | 4579793 | 1.29319 | 5.2
Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 13.5698 | Cu3 | New | 0 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 2.843 | 0.508897 | 0.0495 | 0.0121849 | 6.62932 | 15.9693 | 1.48671 | 6.71746 | 16.0575 | 426529 | 4579796 | 0 | 2.843
Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 283.57 | Cu3 | New | 36.5 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 2.49196 | 0.44606 | 1.88374 | 0.0132944 | 4.75337 | 14.0934 | 1.61843 | 6.66026 | 16.0003 | 426533 | 4579794 | 1.84395 | 3.1
4 x Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 283.57 | Cu3 | New | 36.5 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 2.49196 | 0.44606 | 1.88374 | 0.0132944 | 4.75337 | 14.0934 | 1.61843 | 6.66026 | 16.0003 | 426532 | 4579794 | 1.84395 | 3.1
Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426537 | 4579805 | 2.91362 | 9.7
5 x Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 283.57 | Cu3 | New | 36.5 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 2.49196 | 0.44606 | 1.88374 | 0.0132944 | 4.75337 | 14.0934 | 1.61843 | 6.66026 | 16.0003 | 426531 | 4579799 | 1.84395 | 3.1
2 x Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 283.57 | Cu3 | New | 36.5 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 2.49196 | 0.44606 | 1.88374 | 0.0132944 | 4.75337 | 14.0934 | 1.61843 | 6.66026 | 16.0003 | 426530 | 4579793 | 1.84395 | 3.1
2 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 3.95836 | 0.708547 | 1.29376 | 0.0177794 | 7.53393 | 16.8739 | 2.16067 | 8.8505 | 18.1905 | 426535 | 4579812 | 1.24655 | 4.15
Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 283.57 | Cu3 | New | 36.5 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 2.49196 | 0.44606 | 1.88374 | 0.0132944 | 4.75337 | 14.0934 | 1.61843 | 6.66026 | 16.0003 | 426530 | 4579794 | 1.84395 | 3.1
3 x Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 283.57 | Cu3 | New | 36.5 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 2.49196 | 0.44606 | 1.88374 | 0.0132944 | 4.75337 | 14.0934 | 1.61843 | 6.66026 | 16.0003 | 426530 | 4579799 | 1.84395 | 3.1
4 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 3.95836 | 0.708547 | 1.29376 | 0.0177794 | 7.53393 | 16.8739 | 2.16067 | 8.8505 | 18.1905 | 426534 | 4579816 | 1.24655 | 4.15
4 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426535 | 4579809 | 2.91362 | 9.7
5 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 3.95836 | 0.708547 | 1.29376 | 0.0177794 | 7.53393 | 16.8739 | 2.16067 | 8.8505 | 18.1905 | 426534 | 4579815 | 1.24655 | 4.15
2 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 3.95836 | 0.708547 | 1.29376 | 0.0177794 | 7.53393 | 16.8739 | 2.16067 | 8.8505 | 18.1905 | 426534 | 4579813 | 1.24655 | 4.15
2 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 3.95836 | 0.708547 | 1.29376 | 0.0177794 | 7.53393 | 16.8739 | 2.16067 | 8.8505 | 18.1905 | 426535 | 4579813 | 1.24655 | 4.15
Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 283.57 | Cu3 | New | 36.5 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 2.49196 | 0.44606 | 1.88374 | 0.0132944 | 4.75337 | 14.0934 | 1.61843 | 6.66026 | 16.0003 | 426530 | 4579798 | 1.84395 | 3.1
4 x Cu3 | 30.20.10 Cobertes (GuBIMclass CA) | 283.57 | Cu3 | New | 36.5 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu3_Coberta inclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | Obra | Coberta inclinada | NEW | 2.49196 | 0.44606 | 1.88374 | 0.0132944 | 4.75337 | 14.0934 | 1.61843 | 6.66026 | 16.0003 | 426529 | 4579798 | 1.84395 | 3.1
4 x Object_1945 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 193.641 | Object_1945 | Existing | 17.48 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Object_1945_ |  | Nau Lateral | Preexistències |  | EXISTING | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426533 | 4579819 | 2.91362 | 9.7
5 x Object_1945 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 193.641 | Object_1945 | Existing | 17.48 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Object_1945_ |  | Nau Lateral | Preexistències |  | EXISTING | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426533 | 4579818 | 2.91362 | 9.7
Object_1945 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 193.641 | Object_1945 | Existing | 17.48 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Object_1945_ |  | Nau Lateral | Preexistències |  | EXISTING | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426533 | 4579817 | 2.91362 | 9.7
4 x Object_1945 | 30.20.10.40 Acabats de cobertes (GuBIMclass CA) | 193.641 | Object_1945 | Existing | 17.48 | 30.20.10.40 Acabats de cobertes | 30.20.10.40 | Acabats de cobertes | Object_1945_ |  | Nau Lateral | Preexistències |  | EXISTING | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426534 | 4579817 | 2.91362 | 9.7
5 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426535 | 4579811 | 2.91362 | 9.7
4 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426536 | 4579805 | 2.91362 | 9.7
5 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426536 | 4579806 | 2.91362 | 9.7
4 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426536 | 4579807 | 2.91362 | 9.7
5 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426536 | 4579808 | 2.91362 | 9.7
Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426536 | 4579809 | 2.91362 | 9.7
4 x Cu5 | 30.20.10 Cobertes (GuBIMclass CA) | 193.641 | Cu5 | New | 17.48 | 30.20.10 Cobertes | 30.20.10 | Cobertes | Cu5_Coberta R60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | Nau Lateral | Obra | Coberta R60 | NEW | 9.25207 | 1.65612 | 2.96083 | 0.0415336 | 7.53379 | 16.8738 | 5.04708 | 10.5221 | 19.8621 | 426535 | 4579810 | 2.91362 | 9.7

# IfcBuildingElementProxy: Round Window 27 (2)
In: planta baixa
Classification: 30.10.20.10 Finestres de façanes (GuBIMclass CA)
Pset_BuildingElementProxyCommon - ThermalTransmittance: 0; Status: NEW
ArchiCADProperties - Wall Structure: Insulation; Marker Text: <Custom Text>; Opening Library Part Name: Round Window 27; Opening Side Fill Index: Background; Layer: 00_TABIQUE; Library Part Name: Round Window 27; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Window; Parent ID: F5; Surfaces (All): Glass - Clear Fast; Metal - Aluminium; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Round_Window_27 - Wall Contours (0-None,1-Full,2-Side,3-Length): 0; Hotspots 0-None,1-2D,2-3D,3-All: 3; Floor Plan Display Option: 3; Hole Position Angle: 0 deg; Hole has Wall's Side Surface: yes; Hole Surface's Split is Curved in Curved Walls: no; Show 2D Hotspots in 3D: yes; Wall Type: 1; Wall Direction Type: 1; Reveal Anchor Position: 1; Flip: no; Demolition / New construction: 1; New Wall Fill Type: Masonry Block; New Wall Fill Pen: General - General; New Wall Fill Background Pen: Backgrounds - color 1; Show new construction on Wall: no; Demolition line type: 4; Show Demolition/New parameter: no; Fully Editable: yes; 2D Detail Level: 1; Show Reveal on Symbol: 1; 3D Detail Level: 8; Nominal Size: 0; Set Wallhole Size as Nominal Size: yes; Set Reveal Size as Nominal Size: no; Set Unit Size as Nominal Size: no; Transfer Current Nominal Size to Selection: no; Uniform Sashes: no; Fixed Glass Direction (FixGlassDir): By Opening Direction; Fixed Glass Direction (FixGlassDir_m): 1; Opening Type Main Sash: Fixed Glass; Opening Type: 1; Sash Type (MullionStyle_00): No Grid; Sash Type (iMullionStyle_00): 1; Sash Type (MullionStyle_01): No Grid; Sash Type (iMullionStyle_01): 1; Grid Position (MullionPosition): Throughout; Grid Position (iMullionPosition): 3; Panes Number Vertically: 3; Panes Number Horizontally: 3; Panes Number Vertically 2: 2; Panes Number Horizontally 2: 2; Window Handle: no; Window Handle Type (gs_handle_type_win): Style 1; Window Handle Type (gs_handle_type_win_m): 1; Casing Outside: no; Casing Type Outside (gs_trimtype_out): Simple; Casing Type Outside (gs_trimtype_out_int): 1; Uniform Casing Widths (gs_trim_outside_uniform): no; Casing Inside: no; Casing Type Inside (gs_trimtype_in): Simple; Casing Type Inside (gs_trimtype_in_int): 1; Uniform Casing Widths (gs_trim_inside_uniform): no; Sill (gs_sill_outside): no; Sill Oversize: no; Type of the Sill: 1; Sill Angle: 3 deg; Sill is Curved in Curved Walls: yes; Insulation below Sill: yes; Use Wall Insulation Skin: no; Brick Sill 3D Detail Level: 1; Board (gs_board_inside): no; Board Angle: 0 deg; Board is Curved in Curved Walls: yes; Board in Polygonal Walls: 1; Sunshade: no; Sunshade Type: 1; Enabled Sunshade Types: 38; Number of Panels: 2; Number of Panels 2: 1; Panel Position (gs_shutter_panelPos): Symmetric; Panel Position (gs_shutter_iPanelPos): 1; Automatic Shutter Height: yes; Extra Frame: no; Cover Type (gs_slidingShutter_cover): Z-Profile; Cover Type (gs_slidingShutter_iCover): 1; Stacking Direction (gs_foldingShutter_stacking): Inside; Stacking Direction (gs_foldingShutter_iStacking): 1; Open in 3D: yes; 3D Opening Angle: 180 deg; Show 2D Symbol: yes; Show Opening Lines on Symbol: no; Panel Type (gs_shutPanel_type): Style 1; Panel Type (gs_shutPanel_iType): 1; Different Bottom Frame Width: no; Automatic Shutter Width: yes; Louver Angle: 30 deg; Holes Number Horizontal: 5; Holes Number Vertical: 8; Rolling Shutter Placement (gs_shutRoll_placement): On Facade; Rolling Shutter Placement (gs_shutRoll_iPlacement): 1; Box Type (gs_shutRoll_boxType): Rectangular; Box Type (gs_shutRoll_iBoxType): 1; Rail Position (gs_shutRoll_railPos): On Casing; Rail Position (gs_shutRoll_iRailPos): 1; Show Casing behind Sunshade (gs_shutRoll_showCasingBehind): no; Insulation behind Box (gs_shutRoll_cutWallBehind): no; Include Height in Wallhole Height: no; Box Top Angle: 10 deg; Box Default Width (gs_shutRoll_boxDefaultSize): Reveal Width; Box Default Width (gs_shutRoll_iBoxDefaultSize): 1; Venetian Blinds Placement (gs_shutLam_placement): Fixed on Facade; Venetian Blinds Placement (gs_shutLam_iPlacement): 1; Insulation behind Box (gs_shutLam_cutWallBehind): no; Opened Box: yes; Rail: yes; Rail Position (gs_shutLam_railPos): On Casing; Rail Position (gs_shutLam_iRailPos): 1; Show Casing behind Sunshade (gs_shutLam_showCasingBehind): no; Rotation Angle of Slats (gs_shutLam_rotation): 45 deg; Rotation Angle of Slats (gs_shutLam2_rotation): 45 deg; Masonry Arch (bMasonryArch): no; Masonry Arch (gs_masonry_arch_int): 7; Masonry Arch Type (gs_masonry_arch_structure): Stucco Arch; Masonry Arch Type (gs_masonry_arch_structure_int): 1; Arch on Header: yes; Niche below Arch: yes; Skewback Angle: 75 deg; Custom Niche Surface: no; Reveal Type (gs_reveal_type_new): No Reveal - Edge; Reveal Type (gs_reveal_type_int): 1; Bottom Reveal Type (gs_reveal_type_bottom): Uniform; Bottom Reveal Type (gs_reveal_type_bottom_int): 1; Outer Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleOuterTypeInt): 0; Inner Reveal Type: No Reveal; Reveal Type (gs_reveal_doubleInnerTypeInt): 0; Uniform Jamb Depth: yes; Angle Side 2: 20 deg; Angle Side: 20 deg; Upper Side Angle: 20 deg; Bottom Side Angle: 20 deg; Use Wall Finish Component: no; Auto Turn Inside Face Plaster: yes; Turn Inside Face Plaster: 0; Auto Turn Outside Face Plaster: yes; Turn Outside Face Plaster: 0; Dimensionable on 2D: no; Show in 3D: no; Closure Type (gs_closure_type): No Closure; Closure Type (gs_closure_type_int): 1; Turn Skin on Side (gs_cavity_side): Both; Turn Skin on Side (iCavityClosureSide): 1; Number of Skins to Turn: 1; Number from (gs_nTurnDir): Outside Face; Number from (iCavityClosureTurnDir): 1; Place Closer on Side 2: yes; Place Closer on Side 1: yes; Place Closer on Top: no; Place Closer on Bottom: no; Place Closer to Skin: 1; Place Closer from Side (gs_cc_dutch_ClosureToSide): 1; Gap at Outside Skin: yes; Turn Skin to Closer: no; Insert Insulation Strip: yes; Show Insulation Strip: yes; Contour Pen (gs_penJoint): Openings - Cut Non-Structural; Contour Line Type (gs_ltJoint): 1; Fill Type (gs_fillJoint): Rigid Insulation; Fill Pen (gs_penJointFg): General - General; Fill Background Pen (gs_penJointBg): 2D Elements - Drafting; Custom Surface: no; Surface: Wood - Pine Grained Horizontal; Contour Pen (gs_penPlug): Openings - Cut Non-Structural; Contour Line Type (gs_ltPlug): 1; Fill Type (gs_fillPlug): Rigid Insulation; Fill Pen (gs_penPlugFg): General - General; Fill Background Pen (gs_penPlugBg): 2D Elements - Drafting; Edited Jamb Side: 1; Edited Wall Side: 1; Edited Skin Number: 1; Turn-in Skin: no; Consider Skin as Plaster: no; Turn-in Thickness: 1; Hatch Orientation: 1; Separating Line at Turn-in: no; Separating Line Pen: General - General; Last Selected Side: no; Closure Method Changed Automatically: no; Connection on the Left: no; Connection on the Right: no; Connection on the Top: no; Connection on the Bottom: no; Wall Inset: no; Wall Inset Sizes (gs_parapet_sizes_st): Automatic; Wall Inset Sizes (iParapetSize): 1; Auto Width and Height Dimensions: yes; Wall Inset Bottom at (gs_parapet_bottom_st): Current Story; Wall Inset Bottom at (iParapetBottom): 1; Show Hidden Parapet: yes; Hidden Parapet Line Type: 1; Opening Angle of Main Sash (openingAngle_01): 0 deg; Opening Angle of Main Sash (openingAngle2_01): 0 deg; Opening Angle in 2D: 0 deg; Override MVO for 2D Symbolic Display: no; Opening Line Type: 1; Opening Line Shape (or_SwingType): Curved; Opening Line Shape (or_iSwingType): 1; Opening Line Shape (or_iSlidingType): 0; Opening Line Pen in 2D/3D (or_opLinePen): Openings - General; Opening Line Pen in 2D/3D (or_iOpLinePen): 3; Override MVO for 3D Projections: no; Show Opening Line: yes; Line Type Opening Side (or_opLineType3dIn): Dashed; Line Type Opening Side (or_iOpLineType3dIn): 1; Line Type Opposite Side (or_opLineType3dOut): Solid Line; Line Type Opposite Side (or_iOpLineType3dOut): 0; Line Orientation (or_oplineStyle): Handle; Line Orientation (or_iOplineStyle): 1; Uncut Line Pen: Openings - General; Cut Line Pen: Openings - Cut Structural; Casing Cut Line Pen on Both Sides: Openings - General; Wall Contour Line (gs_wcont_line): Both Sides; Wall Contour Line (iWallContourLine): 4; Wall Contour Line Type Inside: 1; Wall Contour Line Type Outside: 1; Hidden Wall Contour Line Type Inside: 4; Hidden Wall Contour Line Type Outside: 4; Wall Contour Line Pen: Openings - General; Use Fills: yes; Frame Fill Type: Background; Frame Fill Pen: Openings - Cut Fills; Frame Fill Background Pen: Backgrounds - color 1; Sash Fill Type: Air Space; Sash Fill Pen: Openings - Cut Fills; Sash Fill Background Pen: Backgrounds - color 1; Uncut Fill Type: Background; Uncut Fill Pen: Openings - Cut Fills; Uncut Fill Background Pen: Backgrounds - color 1; Plan Symbol Fill Type: Background; Plan Symbol Fill Pen: Backgrounds - color 1; Plan Symbol Fill Background Pen: Backgrounds - color 1; Sill 3D and Uncut Pen: General - General; Sill Section Contour Pen: General - General; Sill Section Fill Type: Air Space; Sill Section Fill Pen: Backgrounds - color 1; Sill Section Fill Bkg. Pen: Backgrounds - color 1; Section Insulation Contour Pen: General - General; Section Insulation Fill Type: Rigid Insulation; Section Insulation Fill Pen: General - General; Section Insulation Fill Background Pen: Backgrounds - color 1; Board 3D and Uncut Pen: General - General; Board Section Contour Pen: General - General; Board Section Fill Type: Air Space; Board Section Fill Pen: Backgrounds - color 1; Board Section Fill Bkg. Pen: Backgrounds - color 1; Casing Fill Type Inside: Air Space; Casing Fill Pen Inside: Backgrounds - color 1; Casing Fill Background Pen Inside: Backgrounds - color 1; Casing Fill Type Outside: Air Space; Casing Fill Pen Outside: Backgrounds - color 1; Casing Fill Background Pen Outside: Backgrounds - color 1; Arch Section Fill Type: Background; Arch Section Fill Pen: Backgrounds - color 1; Arch Section Fill Bkg. Pen: Backgrounds - color 1; Sunshade Symbol Line Type: 1; Sunshade Cut Line Pen: General - General; 3D/Section Uncut Line Pen: General - General; Sunshade Cut Fill Type: Background; Sunshade Cut Fill Pen: General - General; Sunshade Cut Fill Background Pen: Window Background; Sunshade Insulation Fill Type: Batt Insulation; Sunshade Insulation Fill Pen: General - General; Sunshade Insulation Background Pen: Window Background; Curve Resolution: 60; Frame Pen: Openings - General; Sash Pen: Openings - General; Glass Pen: Openings - Cut Non-Structural; Masonry Arch Pen: Walls/Curtain Walls - General; Shadow: yes; Uniform Window Surfaces: yes; Frame Outside: Metal - Aluminium; Frame Inside: Metal - Aluminium; Sash Outside: Metal - Aluminium; Sash Inside: Metal - Aluminium; Glass: Glass - Clear Fast; Grid Outside: Metal - Aluminium; Grid Inside: Metal - Aluminium; Solid Panel Outside: Metal - Aluminium; Solid Panel Inside: Metal - Aluminium; Window Handle Surface: Metal - Stainless Steel; Uniform Casing Surfaces: yes; Interior Casing: Wood - Pine Grained Horizontal; Exterior Casing: Wood - Pine Grained Horizontal; Shutter Panel: Wood - Pine Grained Horizontal; Shutter Panel Frame: Wood - Pine Grained Horizontal; Rolling Shutter Box: Metal - Stainless Steel; Rolling Shutter Blades: Paint - Glossy White; Rolling Shutter Rail: Paint - Glossy White; Venetian Blinds Box: Metal - Stainless Steel; Venetian Blinds Segments: Paint - Glossy White; Sliding Shutter Rail: Metal - Stainless Steel; Sill (gs_sill_mat): Wood - Pine Grained Horizontal; Brick Sill Mortar: Stucco - White Rough; Board (gs_board_mat): Wood - Pine Grained Horizontal; Masonry Arch Brick: Brick - Running Bond; Masonry Arch Mortar: Stucco - White Rough; Masonry Arch Keystone: Stone - Sandstone 01; Niche: Paint - Lead Oxide Yellow; Opening Direction: 1; Head Depth on Symbol: no; Head Depth Symbol Line Type: 21; Head Depth Symbol Pen: Annotation Text - General; Window belongs to the Zone into which it opens: no; Cost: 0; Total Glazed Area (gs_list_glassarea_tmp): 0; Override Glazed Area: no; Total Glass Perimeter: 0; Group Type (FM_Type): Default Objects; Group Type (iFMType): 1; Object Weight: 0; Object Weight Unit: kg; Window Orientation Definition: 0; IFC Operation (ifc_optypestr): Other; IFC Operation (ifc_optype): 10; Shutter Opening Angle: 180 deg; Opening Line Style: 1
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.20.10 Finestres de façanes; 104.AMB.ClassificacioCodi: 30.10.20.10; 105.AMB.ClassificacioDescripcio: Finestres de façanes; 111.AMB.DescripcioTipus: Finestra fixa; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: FinestraTipusI
ArchiCADQuantities - Wall Thickness: 0.08 m; Frame Thickness: 0.05 m
AC_Equantity_Round_Window_27 - Z Dimension: 1 m; Bottom Level: 1 m; Top Level: 0 m; Reveal to Wall Core: 0 m; New Wall Fill Width Right: 0.15 m; New Wall Fill Width Left: 0.15 m; Maximal Tolerance: 0.1 m; Tolerance (gs_tolerance): 0 m; Tolerance (gs_tolerance_left): 0 m; Tolerance Right: 0 m; Tolerance Upper: 0 m; Tolerance Lower: 0 m; Frame Thickness: 0.05 m; Frame Width: 0.05 m; Rebate Depth: 0.025 m; Sash Frame Thickness: 0.05 m; Sash Frame Width: 0.05 m; Grill Width: 0.02 m; Grill Thickness: 0.025 m; Glass Thickness: 0.02 m; Left Opening Oversize: 0 m; Right Opening Oversize: 0 m; Upper Opening Oversize: 0 m; Lower Opening Oversize: 0 m; Width Side (gs_tw_right_out): 0.1 m; Width Side (gs_tw_left_out): 0.1 m; Width Top (gs_tw_top_out): 0.1 m; Width Bottom (gs_tw_bottom_out): 0.1 m; Thickness on Wall (gs_trim_thk_out): 0.025 m; Thickness in Wallhole (gs_trim_width_out): 0.025 m; Offset (gs_trim_offs_out): 0 m; Width Side (gs_tw_right_in): 0.1 m; Width Side (gs_tw_left_in): 0.1 m; Width Top (gs_tw_top_in): 0.1 m; Width Bottom (gs_tw_bottom_in): 0.1 m; Thickness on Wall (gs_trim_thk_in): 0.025 m; Thickness in Wallhole (gs_trim_width_in): 0.025 m; Offset (gs_trim_offs_in): 0 m; Width of Sill: 0 m; Sill Top Width: 0.01 m; Sill Top Height: 0.01 m; Sill Thickness: 0.025 m; Sill Front Side Thickness: 0.015 m; Sill Elevation: 0.005 m; Sill Drip Overlap: 0.02 m; Sill Drip Width: 0.03 m; Sill Nosing: 0.03 m; Sill Overhang Left: 0 m; Sill Overhang Right: 0 m; Sill Slip-in Depth: 0.02 m; Rear Hole Depth (gs_sill_holeDepthBehind): 0 m; Brick Thickness (gs_brick_sill_br_thk): 0.065 m; Mortar Thickness (gs_brick_sill_mort_thk): 0.015 m; Board Width: 0.1 m; Board Thickness: 0.025 m; Board Nosing: 0.03 m; Board Overhang Left: 0 m; Board Overhang Right: 0 m; Board Slip-in Depth: 0 m; Panel Height: 1.5 m; Inner Offset: 0.02 m; Closing Depth: 0 m; Extra Frame Width: 0.04 m; Extra Frame Thickness: 0.03 m; Rail Width: 0.03 m; Hanging Stick Length: 0.02 m; Hanging Stick Radius: 0.005 m; Panel Distance: 0.006 m; Outside Overhang: 0 m; Inner Panel Width: 0.12 m; 3D Opening Length: 1.5 m; 3D Closed Length: 0 m; 3D Opening Length 1: 0.56 m; 3D Opening Length 2: 0.14 m; 3D Opening Height: 1.5 m; 3D Closed Height: 0 m; Panel Thickness: 0.05 m; Panel Frame Width: 0.05 m; Frame Width Bottom: 0.05 m; Panel Width: 0 m; Panel Fill Thickness: 0.01 m; Louver Thickness: 0.01 m; Louver Width: 0.04 m; Horizontal Frame Divider Width: 0.05 m; Vertical Frame Divider Width: 0.05 m; Hole Radius: 0.01 m; Vertical Board Width: 0.1 m; Z Frame Width: 0.05 m; Z Frame Thickness: 0.025 m; Vertical Boards Thickness: 0.025 m; Horizontal Boards Thickness: 0.025 m; Vertical Boards Approximate Width: 0.08 m; Horizontal Boards Approximate Width: 0.115 m; Box Height (gs_shutRoll_boxHeight): 0.2 m; Box Depth (gs_shutRoll_boxWidth): 0.15 m; Box Left Offset: 0 m; Box Right Offset: 0 m; Depth of Rails: 0.0725 m; Distance from Wall (gs_shutRoll_distFromWall): 0 m; Distance from Header (gs_shutRoll_distFromHead): 0 m; Slat Width: 0.05 m; Box Height (gs_shutLam_boxHeight): 0.2 m; Box Depth (gs_shutLam_boxWidth): 0.15 m; Cover Width: 0 m; Distance from Wall (gs_shutLam_distFromWall): 0 m; Distance from Header (gs_shutLam_distFromHead): 0 m; Segment Width (gs_shutLam_segmentWidth): 0.06 m; Box Height (gs_shutLam2_boxHeight): 0.06 m; Box Width: 0.06 m; Distance from Window: 0.06 m; Distance from Header (gs_shutLam2_distFromHead): 0.06 m; Box Axis Height from Header: 0 m; Segment Width (gs_shutLam2_segmentWidth): 0.06 m; Distance between Arch and Window: 0 m; Masonry Arch Overhang Left: 0 m; Masonry Arch Overhang Right: 0 m; Masonry Arch Rise: 0.03 m; Masonry Arch Projection: 0 m; Masonry Arch Height: 0.25 m; Masonry Arch Depth: 0.12 m; Rear Hole Depth (gs_masonry_arch_rearHoleDepth): 0 m; Brick Thickness (gs_masonry_arch_brick_thk): 0.065 m; Mortar Thickness (gs_masonry_arch_mort_thk): 0.01 m; Keystone Width: 0.1 m; Keystone Oversize: 0 m; Keystone Projection: 0.01 m; Reveal Depth (gs_wido_sill): 0 m; Reveal Depth (AC_wido_sill): 0 m; Jamb Depth Side 2: 0.06 m; Jamb Depth: 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_splayed_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_splayed_innerRight): 0.06 m; Inner Jamb Depth Side 2 (gs_reveal_double_innerLeft): 0.06 m; Inner Jamb Depth (gs_reveal_double_innerRight): 0.06 m; Head Jamb Depth: 0.06 m; Sill Jamb Depth: 0.06 m; Inner Head Depth (gs_reveal_splayed_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_splayed_innerBottom): 0.06 m; Inner Head Depth (gs_reveal_double_innerTop): 0.06 m; Inner Sill Depth (gs_reveal_double_innerBottom): 0.06 m; Outer Jamb Depth: 0.08 m; Plaster Thickness Limit: 0.04 m; Distance of Skin from Closer: 0 m; Closer Width: 0.038 m; Closer Thickness: 0.1 m; Strip Thickness: 0.025 m; Profile Width: 0.075 m; Custom Thickness: 0.015 m; Skin Overhang to Frame Depth: 0 m; Depth of Inset: 0.05 m; Parapet Width: 1 m; Overhang Side 1: 0 m; Overhang Side 2: 0 m; Parapet Height: 0.9 m; Bottom Overhang: 0 m; AC Left Opening Oversize: 0 m; AC Right Opening Oversize: 0 m; AC Upper Opening Oversize: 0 m; AC Lower Opening Oversize: 0 m
5 AMB.Geometria - 506.AMB.Profunditat: 0 m
Name | Reveal Dimensions = Wallhole Dimensions = Unit Dimensions = Nominal W x H Size | Nominal W x H x T Size | Element ID = Hotlink and Element ID = 109.AMB.CodiTipus | Total Glazed Area (gs_list_glassarea) | 107.AMB.NomTipus | W/D Opening Opening Volume (m3) | W/D Opening Nominal Volume (m3) | W/D Opening Surface Area (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | W/D Opening Nominal Surface Area (m2) = Nominal W/D Opening Surface Area on the Reveal Side (m2) = Nominal W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | W/D Opening Width on the Reveal Side (m) = W/D Opening Height on the Reveal Side (m) = W/D Opening Width on the Side Opposite to the Reveal Side (m) = W/D Opening Height on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Width on the Reveal Side (m) = Nominal W/D Opening Height on the Reveal Side (m) = Nominal W/D Opening Width on the Side Opposite to the Reveal Side (m) = Nominal W/D Opening Height on the Side Opposite to the Reveal Side (m) = ArchiCADQuantities, Height (m) = ArchiCADQuantities, Width (m) = AC_Equantity_Round_Window_27, Width (m) = AC_Equantity_Round_Window_27, Height (m) = Wallhole Width (m) = Wallhole Height (m) = Reveal Width (m) = Reveal Height (m) = Unit Width (m) = Unit Height (m) = 502.AMB.Amplada (m) = 503.AMB.Altura (m) | W/D Opening Surface Area on the Reveal Side (m2) = W/D Opening Surface Area on the Side Opposite to the Reveal Side (m2) | Sill/Header Value (m) = W/D Nominal Sill Height (m) = Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Home Offset (m) = Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | W/D Sill Height on the Reveal Side (m) = W/D Sill Height on the Side Opposite to the Reveal Side (m) | W/D Nominal Head Height (m) = Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | W/D Head Height on the Reveal Side (m) = W/D Head Height on the Side Opposite to the Reveal Side (m) | Volume (Net) (m3) = Component, Component Volume (Net) (m3) = Component, Component Volume (Gross) (m3) | Elevation to Sea Level (m) = Bottom Elevation To Sea Level (m) | Elevation to Linked/Home Story (m) = Sill Height to Current Story (m) | Top Elevation To Sea Level (m) | Horizontal Division Height (m)
V205 | 1.200,0×1.200,0 | 1.200,0×1.200,0×80,0 | V205 | 0.950332 | V205_FinestraTipusI | 0.0903126 | 0.1152 | 2.68802 | 1.44 | 1.2 | 1.12891 | 7.14686 | 5.33261 | 8.34686 | 6.53261 | 0.00901558 | 16.4869 | 2.64686 | 17.6869 | 0.84
V206 | 750,0×750,0 | 750,0×750,0×80,0 | V206 | 0.331831 | V206_FinestraTipusI | 0.0352784 | 0.045 | 1.14259 | 0.5625 | 0.75 | 0.440979 | 7.40004 | 5.58579 | 8.15004 | 6.33579 | 0.00548774 | 16.74 | 2.90004 | 17.49 | 0.59

# IfcBuildingElementProxy: Steel - Cielo 30, F14
In: planta coberta
Classification: 40.10.20.10 Revestiments discontinus (GuBIMclass CA); Material: Steel - Cielo
ArchiCADProperties - Wall Complexity: Straight; Geometry Method: Uniform; Reference Line Location: Outside Face; Inside Face Surface: Metal - Iron; Outside Face Surface: Metal - Iron; Wall Inside Slant Angle: 90 deg; Wall Outside Slant Angle: 90 deg; Element ID: F14; Hotlink and Element ID: F14; Layer: 00_TRAMEX; Building Material / Composite / Profile / Fill: Steel - Cielo; Building Material: Steel - Cielo; Colliding Zones: Nau Santa Eulàlia; Vestíbul; Locked: no; Home Story Name: planta coberta; Home Story Number: 1; Element Type: Wall; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: F14; Building Materials (All): Steel - Cielo; Surfaces (All): Metal - Iron; Slant Angle: 90 deg; Number of Openings: 0; Edge Surface: Metal - Iron; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 40.10.20.10 Revestiments discontinus; 104.AMB.ClassificacioCodi: 40.10.20.10; 105.AMB.ClassificacioDescripcio: Revestiments discontinus; 107.AMB.NomTipus: F14_ReixaMetal·lica; 109.AMB.CodiTipus: F14; 111.AMB.DescripcioTipus: Reixa metàl·lica per coberta; 115.AMB.Nivell: planta coberta; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40; AUX_107.NomTipus: ReixaMetal·lica
Pset_BuildingElementProxyCommon - Status: NEW
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
5 AMB.Geometria - 501.AMB.Longitud: 7.49568 m; 502.AMB.Amplada: 0.03 m; 503.AMB.Altura: 2.44 m; 504.AMB.Gruix: 0.03 m; 506.AMB.Profunditat: 0 m
Component Properties - Steel - Cielo, Embodied Carbon: 17584 (kgCO₂); Steel - Cielo, Embodied Energy: 162116 MJ
ArchiCADQuantities - Number of Doors: 0; Number of Holes (Number of Empty Openings): 0; Number of Windows: 0; Number of Columns: 0; Volume of the Columns: 0 m3; Maximum Height of the Wall Skin on the Inside Face: 0 m; Minimum Height of the Wall Skin on the Inside Face: 0 m; Maximum Height of the Wall: 1.60947 m; Minimum Height of the Wall: 1.60947 m; Maximum Height of the Wall Skin on the Outside Face: 0 m; Minimum Height of the Wall Skin on the Outside Face: 0 m; Air Skin Thickness: 0 m; Area of the Doors: 0 m2; Combined Width of Doors: 0 m; Wall Component Thickness on the Inside Face: 0 m; Wall Component Thickness on the Outside Face: 0 m; Area of the Windows: 0 m2; Combined Width of Windows: 0 m; Analytic Surface Area of Openings on the Inside Face: 0 m2; Analytic Surface Area of Openings on the Outside Face: 0 m2; Average length of the Wall: 7.49568 m; Surface Area of the Wall Inside Face (Net): 12.0641 m2; Surface Area of the Wall Outside Face (Net): 12.0641 m2; Analytic Volume of the Openings: 0 m3; Length of Reference Line: 7.49568 m; Length of the Wall Inside Face (Conditional): 7.49568 m; Surface Area of the Wall Inside Face (Conditional): 12.0641 m2; Length of the Wall Outside Face (Conditional): 7.49568 m; Surface Area of the Wall Outside Face (Conditional): 12.0641 m2; Surface Area of the Wall Inside Face (Gross): 12.0641 m2; Surface Area of the Wall Outside Face (Gross): 12.0641 m2; End Thickness of the Wall: 0.03 m; Length of the Wall at the Center: 7.49568 m; Length of the Wall on the Inside Face: 7.49568 m; Length of the Wall on the Outside Face: 7.49568 m; Surface Area of Empty Openings in the Wall: 0 m2; Area: 0.224871 m2; Height: 1.60947 m; Volume (Net): 0.361923 m3; Width: 0.03 m; Elevation to Project Zero: 4.5 m; Elevation to 1st Reference Level: 4.5 m; Elevation to 2nd Reference Level: 4.5 m; Elevation to Sea Level: 13.84 m; Elevation to Linked/Home Story: 0 m; Home Offset: 0 m; Top Offset: 0 m; Surface Area: 12.0641 m2; 3D Length: 7.49568 m; Thickness: 0.03 m; Volume (Conditional): 0.361923 m3; Volume (Gross): 0.361923 m3; Insulation Skin Thickness: 0 m; Floor Plan Perimeter: 15.0514 m; Top Elevation To First Reference Level: 6.10947 m; Top Elevation To Home Story: 1.60947 m; Top Elevation To Project Zero: 6.10947 m; Top Elevation To Sea Level: 15.4495 m; Top Elevation To Second Reference Level: 6.10947 m; Bottom Elevation To First Reference Level: 4.5 m; Bottom Elevation To Home Story: 0 m; Bottom Elevation To Project Zero: 4.5 m; Bottom Elevation To Sea Level: 13.84 m; Bottom Elevation To Second Reference Level: 4.5 m; Top Surface Area (Net): 0.224871 m2; Edge Surface Area (Net): 0.546309 m2; Bottom Surface Area (Net): 12.0641 m2
Component Quantities - Steel - Cielo, Mass: 2859.19 kg; Steel - Cielo, Projected Component Area (Net): 12.0641 m2; Steel - Cielo, Projected Component Area (Gross): 12.0641 m2; Steel - Cielo, Component Thickness: 0.03 m; Steel - Cielo, Rectangular Component Height: 1.60947 m; Steel - Cielo, Rectangular Component Width: 0.03 m; Steel - Cielo, Component Cross Section Area: 0.0482842 m2; Steel - Cielo, Component Volume (Net): 0.361923 m3; Steel - Cielo, Component Volume (Gross): 0.361923 m3

# IfcBuildingElementProxy: Steel - Cielo 50 (4)
In: planta baixa
Classification: 40.20.10.10 Falsos sostres interiors (GuBIMclass CA); Material: Steel - Cielo
ArchiCADProperties - Geometry Method: Single-plane; Pitch: -14.3 deg; Roof Level: 1; Trimming Body: Contours Down; Element ID: Cu1; Hotlink and Element ID: Cu1; Layer: 00_CIELO INTERIOR; Building Material / Composite / Profile / Fill: Steel - Cielo; Building Material: Steel - Cielo; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Roof; Structure Type: Basic; Parent ID: Cu1; Building Materials (All): Steel - Cielo; Surfaces (All): Metal - Iron; Cover Fill: Roof Tile 01; Edge Surface: Metal - Iron; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 40.20.10.10 Falsos sostres interiors; 104.AMB.ClassificacioCodi: 40.20.10.10; 105.AMB.ClassificacioDescripcio: Falsos sostres interiors; 107.AMB.NomTipus: Cu1_CobertaInclinadaR60; 109.AMB.CodiTipus: Cu1; 111.AMB.DescripcioTipus: Coberta amb teules Verea reutilitzades, aïllament tèrmic de llana de roca i sistema suspès inclinat; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40; AUX_107.NomTipus: CobertaInclinadaR60
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.05 m; Vertical Thickness: 0.0515987 m; Height: 0.05 m
5 AMB.Geometria - 503.AMB.Altura: 0.05 m; 504.AMB.Gruix: 0.05 m; 506.AMB.Profunditat: 0 m
Component Quantities - Steel - Cielo, Component Thickness: 0.05 m
Name | Colliding Zones | Steel - Cielo, Embodied Carbon | Steel - Cielo, Embodied Energy (MJ) | Surface Area of the Roof Bottom (Gross) (m2) = Surface Area of the Roof Top (Gross) (m2) = Surface Area of the Roof Bottom (Net) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Steel - Cielo, Mass (kg) | Steel - Cielo, Projected Component Area (Net) (m2) = Steel - Cielo, Projected Component Area (Gross) (m2) | Steel - Cielo, Component Volume (Net) (m3) = Steel - Cielo, Component Volume (Gross) (m3)
Cu1 | Despatx; Espai d'atenció; Espai de treball; Lavabo; Nau Santa Eulàlia; Office; Rack | 150634 (kgCO₂) | 1388772 | 62.0084 | 2.58188 | 5 | 14.34 | 5.0516 | 14.3916 | 4.32022 | 13.6602 | 24493.3 | 62.3005 | 3.10042
Cu1 | Espai d'atenció; Lavabo; Lavabo; Nau Santa Eulàlia; Neteja; Office | 143963 (kgCO₂) | 1327269 | 59.2623 | 2.46675 | 4.94864 | 14.2886 | 5.00024 | 14.3402 | 4.26197 | 13.602 | 23408.6 | 59.5402 | 2.96312
Cu1 | Despatx; Espai d'atenció; Espai d'espera; Nau Santa Eulàlia | 146494 (kgCO₂) | 1350604 | 60.3042 | 2.51763 | 4.94864 | 14.2886 | 5.00024 | 14.3402 | 4.25628 | 13.5963 | 23820.2 | 60.5831 | 3.01521
Cu1 | Espai d'atenció; Espai de treball; Espai d'espera; Nau Santa Eulàlia; Sala de reunions | 151532 (kgCO₂) | 1397050 | 62.378 | 2.6267 | 5 | 14.34 | 5.0516 | 14.3916 | 4.32417 | 13.6642 | 24639.3 | 62.6704 | 3.1189

# IfcBuildingElementProxy: Steel - Cielo 54 (3)
In: planta baixa
Material: Steel - Cielo
ArchiCADProperties - Geometry Method: Single-plane; Roof Level: 1; Trimming Body: Contours Down; Building Material / Composite / Profile / Fill: Steel - Cielo; Building Material: Steel - Cielo; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Roof; Structure Type: Basic; Building Materials (All): Steel - Cielo; Surfaces (All): Metal - Iron; Edge Surface: Metal - Iron; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 115.AMB.Nivell: planta baixa; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
Pset_BuildingElementProxyCommon - Status: NEW
5 AMB.Geometria - 503.AMB.Altura: 0.0538584 m; 504.AMB.Gruix: 0.0538584 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Dome Connection Length: 0 m; Eaves Length: 0 m; End Wall Connection Length: 0 m; Gables Length: 0 m; Hips Length: 0 m; Holes Surface Area: 0 m2; Hollow Connection Length: 0 m; Number of Holes: 0; Number of Skylights: 0; Openings Surface Area: 0 m2; Peaks Length: 0 m; Ridges Length: 0 m; Side Wall Connection Length: 0 m; Valleys Length: 0 m; Thickness: 0.0538584 m; Height: 0.0538584 m
Component Quantities - Steel - Cielo, Component Thickness: 0.0538584 m
Name | Classification | Pitch (deg) | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Layer | Cover Fill | 103.AMB.Classificacio | 104.AMB.ClassificacioCodi | 105.AMB.ClassificacioDescripcio | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_104.AMB.ClassificacioCodiCateg | AUX_107.NomTipus | Steel - Cielo, Embodied Carbon | Steel - Cielo, Embodied Energy (MJ) | Surface Area of the Roof Bottom (Gross) (m2) = Surface Area of the Roof Top (Gross) (m2) = Surface Area of the Roof Bottom (Net) (m2) = Steel - Cielo, Projected Component Area (Net) (m2) = Steel - Cielo, Projected Component Area (Gross) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Vertical Thickness (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Steel - Cielo, Mass (kg) | Steel - Cielo, Component Volume (Net) (m3) = Steel - Cielo, Component Volume (Gross) (m3)
Cu3 | 40.20.10.10 Falsos sostres interiors (GuBIMclass CA) | -36.5 | Cu3 | 00_CLT | Roof Tile 01 | 40.20.10.10 Falsos sostres interiors | 40.20.10.10 | Falsos sostres interiors | Cu3_CobertaInclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | 40 | CobertaInclinada | 16810.8 (kgCO₂) | 154988 | 6.42442 | 0.548396 | 0.067 | 5.79999 | 15.14 | 5.867 | 15.207 | 4.44954 | 13.7895 | 2733.47 | 0.346009 | ArchiCADProperties - Colliding Zones: Lavabo; Nau Annexa
Cu3 | 40.20.10.10 Falsos sostres interiors (GuBIMclass CA) | -36.5 | Cu3 | 00_CLT | Roof Tile 01 | 40.20.10.10 Falsos sostres interiors | 40.20.10.10 | Falsos sostres interiors | Cu3_CobertaInclinada | Coberta amb teules Verea, aïllament i acabat en contraxapat de pi | Annex | 40 | CobertaInclinada | 7120.19 (kgCO₂) | 65644.7 | 2.72104 | 0.40495 | 0.067 | 5.79999 | 15.14 | 5.867 | 15.207 | 5.24169 | 14.5817 | 1157.75 | 0.146551
F14 | 30.20.10.20 Cobertes Pre-fabricades (GuBIMclass CA) | 11.8888 | F14 | 00_TRAMEX | Grid 15x15 | 30.20.10.20 Cobertes Pre-fabricades | 30.20.10.20 | Cobertes Pre-fabricades | F14_ReixaMetal·lica | Reixa metàl·lica per coberta | Nau Santa Eulalia | 30 | ReixaMetal·lica | 26493.1 (kgCO₂) | 244253 | 10.1246 | 0.952631 | 0.055039 | 6.05402 | 15.394 | 6.41567 | 15.7557 | 6.07967 | 15.4197 | 4307.82 | 0.545293

# IfcBuildingElementProxy: Steel - Cielo 64 (3)
In: planta baixa
Classification: 40.20.10.10 Falsos sostres interiors (GuBIMclass CA); Material: Steel - Cielo
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Layer: 00_CIELO INTERIOR; Building Material / Composite / Profile / Fill: Steel - Cielo; Building Material: Steel - Cielo; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Structure Type: Basic; Building Materials (All): Steel - Cielo; Surfaces (All): Metal - Iron; Edge Surface: Metal - Iron; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 40
1 AMB.Identificacio - 103.AMB.Classificacio: 40.20.10.10 Falsos sostres interiors; 104.AMB.ClassificacioCodi: 40.20.10.10; 105.AMB.ClassificacioDescripcio: Falsos sostres interiors; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Lateral; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
Pset_BuildingElementProxyCommon - Status: NEW
ArchiCADQuantities - Thickness: 0.064 m; Height: 0.064 m
5 AMB.Geometria - 503.AMB.Altura: 0.064 m; 504.AMB.Gruix: 0.064 m; 506.AMB.Profunditat: 0 m
Component Quantities - Steel - Cielo, Component Thickness: 0.064 m
Name | Geometry Method | Pitch (deg) | Roof Level | Trimming Body | Element ID = Hotlink and Element ID = Parent ID = 109.AMB.CodiTipus | Element Type | Cover Fill | AUX_107.NomTipus | 107.AMB.NomTipus | 111.AMB.DescripcioTipus | Steel - Cielo, Embodied Carbon | Steel - Cielo, Embodied Energy (MJ) | Dome Connection Length (m) = Eaves Length (m) = End Wall Connection Length (m) = Gables Length (m) = Hips Length (m) = Hollow Connection Length (m) = Number of Holes = Number of Skylights = Openings Surface Area (m2) = Peaks Length (m) = Ridges Length (m) = Side Wall Connection Length (m) = Valleys Length (m) | Surface Area of the Roof Bottom (Gross) (m2) = Surface Area of the Roof Top (Gross) (m2) = Surface Area of the Roof Bottom (Net) (m2) | Surface Area of the Roof Edges (Gross) (m2) | Holes Surface Area (m2) | Vertical Thickness (m) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Steel - Cielo, Mass (kg) | Steel - Cielo, Projected Component Area (Net) (m2) | Steel - Cielo, Projected Component Area (Gross) (m2) | Steel - Cielo, Component Volume (Net) (m3) | Steel - Cielo, Component Volume (Gross) (m3)
Cu5 | Single-plane | -17.48 | 1 | Contours Down | Cu5 | Roof | Roof Tile 01 | CobertaInclinadaR60 | Cu5_CobertaInclinadaR60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | 186831 (kgCO₂) | 1722495 | 0 | 60.0852 | 2.03286 | 0 | 0.0670985 | 9.40673 | 18.7467 | 9.2859 | 18.6259 | 6.90323 | 16.2432 | 30379.1 | 60.2432 | 60.2432 | 3.84546 | 3.84546
Cu5 | Single-plane | 0 | 1 | Contours Down | Cu5 | Roof | Roof Tile 01 | CobertaInclinadaR60 | Cu5_CobertaInclinadaR60 | Coberta amb acabat en malla suspesa i aïllament de llana de roca amb suport CLT | 37413.6 (kgCO₂) | 344935 | 0 | 12.0323 | 0.922482 | 0 | 0.064 | 6.91433 | 16.2543 | 6.97833 | 16.3183 | 6.91433 | 16.2543 | 6083.51 | 12.0323 | 12.0323 | 0.770065 | 0.770065
Cu4 |  |  |  |  | Cu4 | Slab | Carpet | Coberta plana | Cu4_ Coberta plana | Paviment transitable sobre sistema d’aïllament i impermeabilització, amb llosa CLT | 53634.7 (kgCO₂) | 494486 |  |  |  | 0.703904 |  | 4.71438 | 14.0544 | 4.77838 | 14.1184 | 4.71438 | 14.0544 | 8721.09 | 17.249 | 17.9529 | 1.10394 | 1.14899 | ArchiCADProperties - Reference Plane Location: Bottom; Number of Openings: 0; Top Surface: Metal - Iron; Bottom Surface: Metal - Iron; ArchiCADQuantities - Elevation Bottom: 4.71438 m; Surface Area of the Slab Top (Conditional): 17.9529 m2; Surface Area of the Slab Bottom (Gross): 17.9529 m2; Surface Area of the Slab Bottom (Gross, with holes): 17.249 m2; Surface Area of the Slab Edges (Gross): 1.08472 m2; Surface Area of the Slab Edges (Gross, with holes): 1.30529 m2; Surface Area of the Slab Top (Gross): 17.9529 m2; Surface Area of the Slab Top (Gross, with holes): 17.249 m2; Elevation Top: 4.77838 m; Area: 17.249 m2; Volume (Net): 1.10394 m3; Surface Area: 17.249 m2; Volume (Conditional): 1.14899 m3; Volume (Gross): 1.14899 m3; Floor Plan Perimeter: 20.3952 m; Floor Plan Holes Perimeter: 3.44643 m; Top Surface Area (Net): 17.249 m2; Top Surface Area (Conditional): 17.9529 m2; Edge Surface Area (Net): 1.30529 m2; Bottom Surface Area (Net): 17.249 m2; Bottom Surface Area (Conditional): 17.9529 m2; Bottom Surface Area (Gross): 17.9529 m2; Edge Surface Area (Gross): 1.08472 m2; Top Surface Area (Gross): 17.9529 m2

# IfcBuildingElementProxy: Steel - Structural 2 x 30 (58)
In: planta baixa
Classification: 30.10.10.20 Façanes prefabricades (GuBIMclass CA); Material: Steel - Structural
ArchiCADProperties - Column Cross Section: Rectangular; Column Slant Angle: 90 deg; Extrusion Surface: Metal - Nickel; End Surface: Metal - Nickel; Element ID: PE102; Hotlink and Element ID: PE102; Layer: 00_TRAMEX; Building Material / Composite / Profile / Fill: Steel - Structural; Building Material: Steel - Structural; Colliding Zones: Nau Annexa; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Column; Absolute Top Link Story: Not Linked; Relative Top Link Story: Not Linked; Top Link Story: Not Linked; Structure Type: Basic; Parent ID: PE102; Building Materials (All): Steel - Structural; Surfaces (All): Metal - Nickel; Cover Fill: Background; Slant Angle: 90 deg; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: New; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 30.10.10.20 Façanes prefabricades; 104.AMB.ClassificacioCodi: 30.10.10.20; 105.AMB.ClassificacioDescripcio: Façanes prefabricades; 107.AMB.NomTipus: PE102_TipusW; 109.AMB.CodiTipus: PE102; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra; 120.AMB.FaseEnderroc: Obra
2 AMB.Caracteristiques - 201.AMB.EsEstructural: No
4 AMB.Normativa - 402.AMB.DBSIResistenciaFoc: R60
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 30; AUX_107.NomTipus: TipusW
Pset_BuildingElementProxyCommon - Status: NEW
