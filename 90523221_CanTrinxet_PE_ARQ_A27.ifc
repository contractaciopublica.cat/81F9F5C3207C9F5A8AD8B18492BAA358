Properties of the parts of a building model (IFC2X3), part 25 of 99

# IfcBuildingElementProxy: Rhino_Object_1133, Object_1133
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1133 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1134, Object_1134
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1134; Hotlink and Element ID: Object_1134; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1134; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1134; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1134 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1134 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1134_; 109.AMB.CodiTipus: Object_1134; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1135, Object_1135
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1135; Hotlink and Element ID: Object_1135; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1135; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1135; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1135 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1135_; 109.AMB.CodiTipus: Object_1135; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1135 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1136, Object_1136
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1136; Hotlink and Element ID: Object_1136; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1136; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1136; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1136 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1136_; 109.AMB.CodiTipus: Object_1136; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1136 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1137, Object_1137
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1137; Hotlink and Element ID: Object_1137; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1137; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1137; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1137 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1137_; 109.AMB.CodiTipus: Object_1137; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1137 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1138, Object_1138
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1138; Hotlink and Element ID: Object_1138; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1138; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1138; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1138 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1138_; 109.AMB.CodiTipus: Object_1138; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1138 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1139, Object_1139
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1139; Hotlink and Element ID: Object_1139; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1139; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1139; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1139_; 109.AMB.CodiTipus: Object_1139; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_1139 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1139 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_114, Object_114
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_114; Hotlink and Element ID: Object_114; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_114; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_114; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_114 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_114_; 109.AMB.CodiTipus: Object_114; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426577 m; Survey Coordinate Y: 4579790 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_114 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1140, Object_1140
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1140; Hotlink and Element ID: Object_1140; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1140; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1140; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1140 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1140_; 109.AMB.CodiTipus: Object_1140; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1140 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1141, Object_1141
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1141; Hotlink and Element ID: Object_1141; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1141; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1141; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1141 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1141_; 109.AMB.CodiTipus: Object_1141; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Equantity_Rhino_Object_1141 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2

# IfcBuildingElementProxy: Rhino_Object_1142, Object_1142
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1142; Hotlink and Element ID: Object_1142; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1142; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1142; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1142 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1142_; 109.AMB.CodiTipus: Object_1142; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1142 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1143, Object_1143
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1143; Hotlink and Element ID: Object_1143; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1143; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1143; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1143 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1143_; 109.AMB.CodiTipus: Object_1143; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1143 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_1144, Object_1144
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1144; Hotlink and Element ID: Object_1144; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1144; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1144; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1144 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1144_; 109.AMB.CodiTipus: Object_1144; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1144 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1145, Object_1145
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1145; Hotlink and Element ID: Object_1145; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1145; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1145; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1145 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1145_; 109.AMB.CodiTipus: Object_1145; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1145 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1146, Object_1146
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1146; Hotlink and Element ID: Object_1146; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1146; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1146; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1146 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Equantity_Rhino_Object_1146 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1146_; 109.AMB.CodiTipus: Object_1146; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1147, Object_1147
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1147; Hotlink and Element ID: Object_1147; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1147; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1147; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1147_; 109.AMB.CodiTipus: Object_1147; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_1147 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207044 m; Area: 0.0231931 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.11202 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231931 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_1147 - Dimension 1: 0.207044 m; Dimension 2: 0.11202 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.11202 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1148, Object_1148
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
