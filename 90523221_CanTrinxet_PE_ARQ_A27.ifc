Properties of the parts of a building model (IFC2X3), part 10 of 99

# IfcBuildingElementProxy: Gypsum Plasterboard 30 (373)
Name | Reference Line Location | Inside Face Surface = Edge Surface | Outside Face Surface | Element ID = Hotlink and Element ID = Parent ID | Colliding Zones | Surfaces (All) | Number of Openings | 107.AMB.NomTipus | 109.AMB.CodiTipus | 111.AMB.DescripcioTipus | 117.AMB.Localitzacio | AUX_107.NomTipus | Gypsum Plasterboard, Embodied Carbon | Gypsum Plasterboard, Embodied Energy (MJ) | Number of Windows | Maximum Height of the Wall (m) | Minimum Height of the Wall (m) | Analytic Surface Area of Openings on the Inside Face (m2) | Analytic Surface Area of Openings on the Outside Face (m2) | Average length of the Wall (m) = Length of the Wall at the Center (m) | Surface Area of the Wall Inside Face (Net) (m2) | Surface Area of the Wall Outside Face (Net) (m2) = Surface Area (m2) = Bottom Surface Area (Net) (m2) | Analytic Volume of the Openings (m3) | Length of Reference Line (m) = 501.AMB.Longitud (m) | Length of the Wall Inside Face (Conditional) (m) | Surface Area of the Wall Inside Face (Conditional) (m2) | Length of the Wall Outside Face (Conditional) (m) | Surface Area of the Wall Outside Face (Conditional) (m2) | Surface Area of the Wall Inside Face (Gross) (m2) | Surface Area of the Wall Outside Face (Gross) (m2) | Length of the Wall on the Inside Face (m) | Length of the Wall on the Outside Face (m) | Area (m2) = Top Surface Area (Net) (m2) | Height (m) = Gypsum Plasterboard, Rectangular Component Height (m) | Volume (Net) (m3) = Gypsum Plasterboard, Component Volume (Net) (m3) | Elevation to Project Zero (m) = Elevation to 1st Reference Level (m) = Elevation to 2nd Reference Level (m) = Elevation to Linked/Home Story (m) = Home Offset (m) | Elevation to Sea Level (m) | 3D Length (m) | Volume (Conditional) (m3) | Volume (Gross) (m3) | Floor Plan Perimeter (m) | Top Elevation To First Reference Level (m) = Top Elevation To Home Story (m) = Top Elevation To Project Zero (m) = Top Elevation To Second Reference Level (m) | Top Elevation To Sea Level (m) | Bottom Elevation To First Reference Level (m) = Bottom Elevation To Home Story (m) = Bottom Elevation To Project Zero (m) = Bottom Elevation To Second Reference Level (m) | Bottom Elevation To Sea Level (m) | Edge Surface Area (Net) (m2) | 503.AMB.Altura (m) | Gypsum Plasterboard, Mass (kg) | Gypsum Plasterboard, Projected Component Area (Net) (m2) | Gypsum Plasterboard, Projected Component Area (Gross) (m2) | Gypsum Plasterboard, Component Cross Section Area (m2) | Gypsum Plasterboard, Component Volume (Gross) (m3)
3 x F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 41.067 (kgCO₂) | 710.775 | 0 | 2.6 | 2.6 | 0 | 0 | 1.5 | 3.9 | 3.9 | 0 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.117 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.246 | 2.44 | 105.3 | 3.9 | 3.9 | 0.078 | 0.117
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Lavabo; Nau Santa Eulàlia; Office | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 70.1711 (kgCO₂) | 1214.5 | 0 | 1.44693 | 0 | 0 | 0 | 4.58776 | 6.6897 | 6.63816 | 0 | 4.58776 | 4.58776 | 6.6897 | 4.58776 | 6.63816 | 6.6897 | 6.63816 | 4.58776 | 4.58776 | 0.138167 | 1.44693 | 0.199918 | 2.872 | 12.212 | 4.62338 | 0.199918 | 0.199918 | 9.23551 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.319742 | 2.44 | 179.926 | 6.6897 | 6.6897 | 0.0434079 | 0.199918
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.5145 (kgCO₂) | 355.059 | 0 | 1.44693 | 0 | 0.222195 | 0.222195 | 1.5 | 1.9482 | 1.9482 | 0.00666585 | 1.5 | 0.952001 | 2.17039 | 0.952001 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.02856 | 1.44693 | 0.0584459 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.160376 | 2.44 | 52.6013 | 1.9482 | 2.17039 | 0.0434079 | 0.0651118 | ArchiCADProperties - ID of Connected Openings: OP - 004
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Lavabo; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 16.6639 (kgCO₂) | 288.414 | 0 | 1.44693 | 0 | 0.095918 | 0.095918 | 1.16 | 1.58252 | 1.58252 | 0.00287754 | 1.16 | 1.16 | 1.67844 | 1.16 | 1.67844 | 1.67844 | 1.67844 | 1.16 | 1.16 | 0.0277031 | 1.44693 | 0.0474756 | 2.872 | 12.212 | 1.16 | 0.0503531 | 0.0503531 | 2.38 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.137155 | 2.44 | 42.728 | 1.58252 | 1.67844 | 0.0434079 | 0.0503531 | ArchiCADProperties - ID of Connected Openings: OP - 004
3 x T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 22.8542 (kgCO₂) | 395.554 | 0 | 1.44693 | 1.44693 | 0 | 0 | 1.5 | 2.17039 | 2.17039 | 0 | 1.5 | 1.5 | 2.17039 | 1.5 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.045 | 1.44693 | 0.0651118 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.176816 | 2.44 | 58.6006 | 2.17039 | 2.17039 | 0.0434079 | 0.0651118
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.5523 (kgCO₂) | 355.712 | 0 | 1.44693 | 0 | 0.218612 | 0.218612 | 1.5 | 1.95178 | 1.95178 | 0.00655836 | 1.5 | 0.952001 | 2.17039 | 0.952001 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.02856 | 1.44693 | 0.0585534 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.160376 | 2.44 | 52.6981 | 1.95178 | 2.17039 | 0.0434079 | 0.0651118 | ArchiCADProperties - ID of Connected Openings: OP - 004
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 22.5838 (kgCO₂) | 390.873 | 0 | 1.44693 | 0 | 0.0256855 | 0.0256855 | 1.5 | 2.14471 | 2.14471 | 0.000770566 | 1.5 | 1.5 | 2.17039 | 1.5 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.0430996 | 1.44693 | 0.0643412 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.162751 | 2.44 | 57.9071 | 2.14471 | 2.17039 | 0.0434079 | 0.0651118 | ArchiCADProperties - ID of Connected Openings: OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Lavabo; Nau Santa Eulàlia; Office | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 124.449 (kgCO₂) | 2153.92 | 0 | 2.6 | 0 | 0 | 0 | 4.58228 | 11.8648 | 11.7722 | 0 | 4.58776 | 4.57681 | 11.8648 | 4.58776 | 11.7722 | 12.0208 | 11.9282 | 4.57681 | 4.58776 | 0.136367 | 2.6 | 0.354554 | 0.27 | 9.61 | 4.5636 | 0.354554 | 0.359234 | 9.2265 | 2.87 | 12.21 | 0.27 | 9.61 | 0.350734 | 2.44 | 319.099 | 11.8654 | 11.8654 | 0.078 | 0.354554
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 22.8882 (kgCO₂) | 396.142 | 0 | 2.6 | 0 | 0.110365 | 0.110365 | 0.923582 | 2.14963 | 2.19434 | 0.00331094 | 0.923582 | 0.923582 | 2.25999 | 0.923582 | 2.3047 | 2.40131 | 2.40131 | 0.923582 | 0.923582 | 0.0265927 | 2.6 | 0.0652086 | 0.27 | 9.61 | 0.908349 | 0.0685195 | 0.0720394 | 1.90716 | 2.87 | 12.21 | 0.27 | 9.61 | 0.126634 | 2.44 | 58.6877 | 2.25134 | 2.36171 | 0.078 | 0.0685195 | ArchiCADProperties - ID of Connected Openings: OP - 005
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 39.514 (kgCO₂) | 683.896 | 0 | 2.6 | 2.13347 | 0.147484 | 0.147484 | 1.5 | 3.75252 | 3.75252 | 0.00442452 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.112575 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.22252 | 2.44 | 101.318 | 3.75252 | 3.9 | 0.078 | 0.117 | ArchiCADProperties - ID of Connected Openings: OP - 004
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 21.5045 (kgCO₂) | 372.194 | 0 | 1.44693 | 0 | 0.128178 | 0.128178 | 1.5 | 2.04221 | 2.04221 | 0.00384535 | 1.5 | 1.5 | 2.17039 | 1.5 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.0355162 | 1.44693 | 0.0612664 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.155168 | 2.44 | 55.1398 | 2.04221 | 2.17039 | 0.0434079 | 0.0651118 | ArchiCADProperties - ID of Connected Openings: OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 34.8896 (kgCO₂) | 603.858 | 0 | 2.6 | 1.52947 | 0.586652 | 0.586652 | 1.5 | 3.31335 | 3.31335 | 0.0175996 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.0994005 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.22956 | 2.44 | 89.4604 | 3.31335 | 3.9 | 0.078 | 0.117 | ArchiCADProperties - ID of Connected Openings: OP - 004
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 36.5058 (kgCO₂) | 631.832 | 0 | 1.44693 | 1.44693 | 0 | 0 | 2.396 | 3.46684 | 3.46684 | 0 | 2.396 | 2.396 | 3.46684 | 2.396 | 3.46684 | 3.46684 | 3.46684 | 2.396 | 2.396 | 0.07188 | 1.44693 | 0.104005 | 2.872 | 12.212 | 2.396 | 0.104005 | 0.104005 | 4.852 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.230576 | 2.44 | 93.6047 | 3.46684 | 3.46684 | 0.0434079 | 0.104005
2 x F5 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F5 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 38.2176 (kgCO₂) | 661.459 | 0 | 2.598 | 2.598 | 0 | 0 | 1.397 | 3.62941 | 3.62941 | 0 | 1.397 | 1.397 | 3.62941 | 1.397 | 3.62941 | 3.62941 | 3.62941 | 1.397 | 1.397 | 0.04191 | 2.598 | 0.108882 | 1.71425 | 11.0543 | 1.397 | 0.108882 | 0.108882 | 2.854 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.2397 | 2.598 | 97.994 | 3.62941 | 3.62941 | 0.07794 | 0.108882
F5 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F5 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 31.5167 (kgCO₂) | 545.482 | 0 | 2.6 | 4.44089e-16 | 0 | 0 | 1.13618 | 2.99288 | 2.9932 | 0 | 1.15124 | 1.12112 | 2.99288 | 1.15124 | 2.9932 | 2.99291 | 2.99323 | 1.12112 | 1.15124 | 0.0345351 | 2.6 | 0.0897913 | 1.71425 | 11.0543 | 1.15123 | 0.0897913 | 0.0897922 | 2.34488 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.14707 | 2.6 | 80.8121 | 2.9932 | 2.9932 | 0.078 | 0.0897913
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 31.075 (kgCO₂) | 537.836 | 0 | 2.60008 | 2.60008 | 0 | 0 | 1.135 | 2.95109 | 2.95109 | 0 | 1.135 | 1.135 | 2.95109 | 1.135 | 2.95109 | 2.95109 | 2.95109 | 1.135 | 1.135 | 0.03405 | 2.60008 | 0.0885327 | 4.31425 | 13.6543 | 1.135 | 0.0885327 | 0.0885327 | 2.33 | 6.91433 | 16.2543 | 4.31425 | 13.6543 | 0.224105 | 2.60008 | 79.6794 | 2.95109 | 2.95109 | 0.0780023 | 0.0885327
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 14.4886 (kgCO₂) | 250.764 | 0 | 0.962192 | 0.962192 | 0 | 0 | 1.43 | 1.37593 | 1.37593 | 0 | 1.43 | 1.43 | 1.37593 | 1.43 | 1.37593 | 1.37593 | 1.37593 | 1.43 | 1.43 | 0.0429 | 0.962192 | 0.041278 | 3.35681 | 12.6968 | 1.43 | 0.041278 | 0.041278 | 2.92 | 4.319 | 13.659 | 3.35681 | 12.6968 | 0.143532 | 2.44 | 37.1502 | 1.37593 | 1.37593 | 0.0288658 | 0.041278
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 38.2001 (kgCO₂) | 661.155 | 0 | 2.60243 | 2.59118 | 0 | 0 | 1.397 | 3.63434 | 3.62114 | 0 | 1.397 | 1.397 | 3.63434 | 1.397 | 3.62114 | 3.9787 | 3.9787 | 1.397 | 1.397 | 0.04191 | 2.84803 | 0.108832 | 4.31425 | 13.6543 | 1.397 | 0.108832 | 0.119361 | 2.854 | 6.91668 | 16.2567 | 4.31425 | 13.6543 | 0.197718 | 2.84803 | 97.9489 | 3.63434 | 3.9787 | 0.0854408 | 0.119361
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 40.9069 (kgCO₂) | 708.005 | 0 | 2.60846 | 2.59709 | 0 | 0 | 1.49256 | 3.89183 | 3.87773 | 0 | 1.49256 | 1.49256 | 3.89183 | 1.49256 | 3.87773 | 4.25084 | 4.25084 | 1.49256 | 1.49256 | 0.0447767 | 2.84803 | 0.116544 | 4.31425 | 13.6543 | 1.49256 | 0.116544 | 0.127525 | 3.04511 | 6.92271 | 16.2627 | 4.31425 | 13.6543 | 0.200944 | 2.84803 | 104.89 | 3.89183 | 4.25084 | 0.0854408 | 0.127525
F5 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F5 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 40.8318 (kgCO₂) | 706.704 | 0 | 2.598 | 2.598 | 0 | 0 | 1.49256 | 3.87766 | 3.87766 | 0 | 1.49256 | 1.49256 | 3.87766 | 1.49256 | 3.87766 | 3.87766 | 3.87766 | 1.49256 | 1.49256 | 0.0447767 | 2.598 | 0.11633 | 1.71425 | 11.0543 | 1.49256 | 0.11633 | 0.11633 | 3.04511 | 4.31225 | 13.6523 | 1.71425 | 11.0543 | 0.245433 | 2.598 | 104.697 | 3.87766 | 3.87766 | 0.07794 | 0.11633
4 x T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 23.901 (kgCO₂) | 413.671 | 0 | 2.6 | 2.6 | 0 | 0 | 0.873 | 2.2698 | 2.2698 | 0 | 0.873 | 0.873 | 2.2698 | 0.873 | 2.2698 | 2.2698 | 2.2698 | 0.873 | 0.873 | 0.02619 | 2.6 | 0.068094 | 0.27 | 9.61 | 0.873 | 0.068094 | 0.068094 | 1.806 | 2.87 | 12.21 | 0.27 | 9.61 | 0.20838 | 2.44 | 61.2846 | 2.2698 | 2.2698 | 0.078 | 0.068094
F6 | Inside Face | Wood - Pine Grained Horizontal blank | Tiles - Terracota Arena 10x20 | F6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank; Tiles - Terracota Arena 10x20 | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 73.3227 (kgCO₂) | 1269.05 | 0 | 2.2 | 0 | 0 | 0 | 3.14511 | 6.93414 | 6.99231 | 0 | 3.15188 | 3.15188 | 6.93414 | 3.13833 | 6.99231 | 6.93414 | 6.99231 | 3.15188 | 3.13833 | 0.094953 | 2.2 | 0.208897 | 0.27 | 9.61 | 3.17832 | 0.208897 | 0.208897 | 6.35313 | 2.47 | 11.81 | 0.27 | 9.61 | 0.255906 | 2.44 | 188.007 | 6.99231 | 6.99231 | 0.066 | 0.208897
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 15.3145 (kgCO₂) | 265.059 | 0 | 0.962192 | 0 | 0 | 0 | 1.4983 | 1.46709 | 1.44165 | 0 | 1.4983 | 1.4983 | 1.46709 | 1.4983 | 1.44165 | 1.46709 | 1.44165 | 1.4983 | 1.4983 | 0.0453455 | 0.962192 | 0.0436311 | 3.35681 | 12.6968 | 1.52474 | 0.0436311 | 0.0436311 | 3.05659 | 4.319 | 13.659 | 3.35681 | 12.6968 | 0.119557 | 2.44 | 39.268 | 1.46709 | 1.46709 | 0.0288658 | 0.0436311
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.5291 (kgCO₂) | 320.696 | 0 | 1.37 | 1.08272 | 0 | 0 | 1.41 | 1.75941 | 1.75989 | 0 | 1.41 | 1.41 | 1.75941 | 1.41 | 1.75989 | 1.75941 | 1.75989 | 1.41 | 1.41 | 0.0423 | 1.842 | 0.0527895 | 3.63 | 12.97 | 1.41 | 0.0527895 | 0.0527895 | 2.88 | 5 | 14.34 | 3.63 | 12.97 | 0.157401 | 2.44 | 47.5106 | 1.76006 | 1.76006 | 0.05526 | 0.0527895
F6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 18.9725 (kgCO₂) | 328.369 | 0 | 2.6 | 0 | 1.144 | 1.144 | 1.12193 | 1.88781 | 1.71569 | 0.0343199 | 1.13372 | 1.11013 | 3.03181 | 1.13372 | 2.85969 | 3.11978 | 2.94767 | 1.11013 | 1.13372 | 0.0350053 | 2.6 | 0.0540526 | 0.27 | 9.61 | 1.19997 | 0.0883725 | 0.0910118 | 2.3084 | 2.87 | 12.21 | 0.27 | 9.61 | 0.0409207 | 2.44 | 48.6473 | 1.88781 | 3.03181 | 0.078 | 0.0883725 | ArchiCADProperties - ID of Connected Openings: OP - 003
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 39.3106 (kgCO₂) | 680.376 | 0 | 2.6 | 0 | 0 | 0 | 1.53339 | 3.73035 | 3.73605 | 0 | 1.54952 | 1.51725 | 3.73035 | 1.54952 | 3.73605 | 4.02306 | 4.02876 | 1.51725 | 1.54952 | 0.0455504 | 2.6 | 0.111996 | 0.27 | 9.61 | 1.51944 | 0.111996 | 0.120777 | 3.14083 | 2.87 | 12.21 | 0.27 | 9.61 | 0.169101 | 2.44 | 100.796 | 3.73605 | 3.95055 | 0.078 | 0.118431
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 26.3405 (kgCO₂) | 455.893 | 0 | 1.84116 | 0 | 0 | 0 | 1.549 | 2.49944 | 2.5035 | 0 | 1.549 | 1.549 | 2.49944 | 1.549 | 2.5035 | 2.54296 | 2.54702 | 1.549 | 1.549 | 0.0464696 | 2.6 | 0.0750441 | 2.872 | 12.212 | 1.549 | 0.0750441 | 0.0763498 | 3.158 | 4.71316 | 14.0532 | 2.872 | 12.212 | 0.148716 | 2.44 | 67.5397 | 2.5035 | 2.5035 | 0.078 | 0.0750441
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 29.5236 (kgCO₂) | 510.985 | 0 | 2.05669 | 0 | -1.8437e-09 | 0 | 1.533 | 2.83749 | 2.76997 | -7.11144e-10 | 1.533 | 1.533 | 2.83749 | 1.533 | 2.76997 | 2.92039 | 2.85335 | 1.533 | 1.533 | 0.0450917 | 2.09488 | 0.0841128 | 2.872 | 12.212 | 1.52296 | 0.0841128 | 0.0866071 | 3.126 | 4.92869 | 14.2687 | 2.872 | 12.212 | 0.153317 | 2.44 | 75.7015 | 2.83749 | 2.83749 | 0.0628464 | 0.0841128
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 40.3996 (kgCO₂) | 699.224 | 0 | 2.6 | 2.6 | 0 | 0 | 1.47562 | 3.83662 | 3.83662 | 0 | 1.47562 | 1.47562 | 3.83662 | 1.47562 | 3.83662 | 3.83662 | 3.83662 | 1.47562 | 1.47562 | 0.0442687 | 2.6 | 0.115099 | 0.27 | 9.61 | 1.47562 | 0.115099 | 0.115099 | 3.01125 | 2.87 | 12.21 | 0.27 | 9.61 | 0.244537 | 2.44 | 103.589 | 3.83662 | 3.83662 | 0.078 | 0.115099
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 14.0536 (kgCO₂) | 243.236 | 0 | 1.67913 | 0 | 0.442029 | 0.442029 | 1.13374 | 1.38361 | 1.28576 | 0.0132609 | 1.13374 | 0.204064 | 1.82564 | 0.204064 | 1.72779 | 1.86412 | 1.76626 | 1.13374 | 1.13374 | 0.00671906 | 1.76458 | 0.0400388 | 2.872 | 12.212 | 1.17355 | 0.0532997 | 0.054454 | 2.32748 | 4.55113 | 13.8911 | 2.872 | 12.212 | 0.042435 | 2.44 | 36.0349 | 1.38361 | 1.82564 | 0.0529373 | 0.0532997 | ArchiCADProperties - ID of Connected Openings: OP - 003
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 13.1595 (kgCO₂) | 227.76 | 0 | 2.6 | 2.6 | 0 | 0 | 0.480658 | 1.24971 | 1.24971 | 0 | 0.480658 | 0.480658 | 1.24971 | 0.480658 | 1.24971 | 1.24971 | 1.24971 | 0.480658 | 0.480658 | 0.0144198 | 2.6 | 0.0374914 | 0.27 | 9.61 | 0.480658 | 0.0374914 | 0.0374914 | 1.02132 | 2.87 | 12.21 | 0.27 | 9.61 | 0.18484 | 2.44 | 33.7422 | 1.24971 | 1.24971 | 0.078 | 0.0374914
T2 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T2 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 37.4821 (kgCO₂) | 648.728 | 0 | 2.60008 | 0 | 0 | 0 | 1.39902 | 3.55955 | 3.55955 | 0 | 1.39902 | 1.39902 | 3.55955 | 1.39902 | 3.55955 | 3.84556 | 3.84556 | 1.39902 | 1.39902 | 0.0410705 | 2.60008 | 0.106786 | 4.31425 | 13.6543 | 1.36902 | 0.106786 | 0.115367 | 2.85803 | 6.91433 | 16.2543 | 4.31425 | 13.6543 | 0.160143 | 2.60008 | 96.1078 | 3.55955 | 3.55955 | 0.0780023 | 0.106786
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 38.8823 (kgCO₂) | 672.963 | 0 | 2.6 | 0 | 0 | 0 | 1.4016 | 3.66393 | 3.72112 | 0 | 1.394 | 1.4092 | 3.66393 | 1.394 | 3.72112 | 3.66393 | 3.72112 | 1.4092 | 1.394 | 0.0426061 | 2.6 | 0.110776 | 0.27 | 9.61 | 1.4312 | 0.110776 | 0.110776 | 2.86684 | 2.87 | 12.21 | 0.27 | 9.61 | 0.163212 | 2.44 | 99.6982 | 3.72112 | 3.72112 | 0.078 | 0.110776
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 34.8506 (kgCO₂) | 603.184 | 0 | 2.6 | 0 | 0 | 0 | 1.28867 | 3.29735 | 3.32195 | 0 | 1.27767 | 1.29967 | 3.29735 | 1.27767 | 3.32195 | 3.37914 | 3.40373 | 1.29967 | 1.27767 | 0.0381883 | 2.6 | 0.0992895 | 0.27 | 9.61 | 1.27767 | 0.0992895 | 0.101743 | 2.64454 | 2.87 | 12.21 | 0.27 | 9.61 | 0.154377 | 2.44 | 89.3606 | 3.32195 | 3.32195 | 0.078 | 0.0992895
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Extradossat_170 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_170 | 12.1797 (kgCO₂) | 210.802 | 0 | 0.867714 | 0 | 0 | 0 | 1.344 | 1.14712 | 1.16621 | 0 | 1.344 | 1.344 | 1.14712 | 1.344 | 1.16621 | 1.1794 | 1.19849 | 1.344 | 1.344 | 0.03999 | 0.867714 | 0.0346999 | 2.872 | 12.212 | 1.344 | 0.0346999 | 0.0356683 | 2.748 | 3.73971 | 13.0797 | 2.872 | 12.212 | 0.106012 | 2.44 | 31.2299 | 1.16621 | 1.16621 | 0.0260314 | 0.0346999
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Extradossat_170 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_170 | 11.8661 (kgCO₂) | 205.374 | 0 | 1.13792 | 0 | 0 | 0 | 1.16585 | 1.11911 | 1.13469 | 0 | 1.16585 | 1.16585 | 1.11911 | 1.16585 | 1.13469 | 1.35168 | 1.36244 | 1.16585 | 1.16585 | 0.0348337 | 1.13792 | 0.0338065 | 2.872 | 12.212 | 1.16585 | 0.0338065 | 0.0407118 | 2.39171 | 4.00992 | 13.3499 | 2.872 | 12.212 | 0.0603688 | 2.44 | 30.4258 | 1.13469 | 1.32665 | 0.0341376 | 0.0396379
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 35.4 (kgCO₂) | 612.692 | 0 | 2.6 | 0 | 0 | 0 | 1.29588 | 3.32093 | 3.40271 | 0 | 1.27728 | 1.31448 | 3.32093 | 1.27728 | 3.40271 | 3.41765 | 3.49943 | 1.31448 | 1.27728 | 0.0387902 | 2.6 | 0.100855 | 0.27 | 9.61 | 1.30874 | 0.100855 | 0.103756 | 2.66259 | 2.87 | 12.21 | 0.27 | 9.61 | 0.0775804 | 2.44 | 90.7691 | 3.40271 | 3.40271 | 0.078 | 0.100855
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Extradossat_170 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_170 | 13.4385 (kgCO₂) | 232.589 | 0 | 1.13792 | 0 | 0 | 0 | 1.27728 | 1.25903 | 1.29333 | 0 | 1.27728 | 1.27728 | 1.25903 | 1.27728 | 1.29333 | 1.49166 | 1.52151 | 1.27728 | 1.27728 | 0.0399062 | 1.13792 | 0.0382862 | 2.872 | 12.212 | 1.34594 | 0.0382862 | 0.0451977 | 2.61456 | 4.00992 | 13.3499 | 2.872 | 12.212 | 0.0399179 | 2.44 | 34.4576 | 1.29438 | 1.52151 | 0.0341376 | 0.0451977
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Enva_140 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 39.5065 (kgCO₂) | 683.766 | 0 | 2.6 | 2.6 | 0 | 0 | 1.443 | 3.7518 | 3.7518 | 0 | 1.443 | 1.443 | 3.7518 | 1.443 | 3.7518 | 3.7518 | 3.7518 | 1.443 | 1.443 | 0.04329 | 2.6 | 0.112554 | 0.27 | 9.61 | 1.443 | 0.112554 | 0.112554 | 2.946 | 2.87 | 12.21 | 0.27 | 9.61 | 0.24258 | 2.44 | 101.299 | 3.7518 | 3.7518 | 0.078 | 0.112554
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Extradossat_170 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_170 | 13.449 (kgCO₂) | 232.772 | 0 | 1.09345 | 0 | 0 | 0 | 1.27767 | 1.26005 | 1.29434 | 0 | 1.27767 | 1.27767 | 1.26005 | 1.27767 | 1.29434 | 1.56299 | 1.59336 | 1.27767 | 1.27767 | 0.039918 | 1.19245 | 0.0383163 | 2.872 | 12.212 | 1.34633 | 0.0383163 | 0.0473452 | 2.61534 | 3.96545 | 13.3054 | 2.872 | 12.212 | 0.039918 | 2.44 | 34.4847 | 1.29441 | 1.59336 | 0.0357734 | 0.0473452
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Extradossat_170 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_170 | 13.7138 (kgCO₂) | 237.354 | 0 | 0.868161 | 0.868161 | 0 | 0 | 1.50013 | 1.30236 | 1.30236 | 0 | 1.50013 | 1.50013 | 1.30236 | 1.50013 | 1.30236 | 1.30236 | 1.30236 | 1.50013 | 1.50013 | 0.0450039 | 0.868161 | 0.0390707 | 2.872 | 12.212 | 1.50013 | 0.0390707 | 0.0390707 | 3.06026 | 3.74016 | 13.0802 | 2.872 | 12.212 | 0.142098 | 2.44 | 35.1636 | 1.30236 | 1.30236 | 0.0260448 | 0.0390707
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Enva_140 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 14.3052 (kgCO₂) | 247.59 | 0 | 2.6 | 2.6 | 0 | 0 | 0.522507 | 1.35852 | 1.35852 | 0 | 0.522507 | 0.522507 | 1.35852 | 0.522507 | 1.35852 | 1.35852 | 1.35852 | 0.522507 | 0.522507 | 0.0156752 | 2.6 | 0.0407555 | 0.27 | 9.61 | 0.522507 | 0.0407555 | 0.0407555 | 1.10501 | 2.87 | 12.21 | 0.27 | 9.61 | 0.18735 | 2.44 | 36.68 | 1.35852 | 1.35852 | 0.078 | 0.0407555
T3 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T3 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Extradossat_170 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_170 | 13.6121 (kgCO₂) | 235.593 | 0 | 0.868161 | 0 | 0 | 0 | 1.5 | 1.28314 | 1.30224 | 0 | 1.5 | 1.5 | 1.28314 | 1.5 | 1.30224 | 1.31544 | 1.33454 | 1.5 | 1.5 | 0.04467 | 0.868161 | 0.0387808 | 2.872 | 12.212 | 1.5 | 0.0387808 | 0.0397497 | 3.06 | 3.74016 | 13.0802 | 2.872 | 12.212 | 0.115385 | 2.44 | 34.9027 | 1.30224 | 1.30224 | 0.0260448 | 0.0387808
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.5359 (kgCO₂) | 355.429 | 0 | 1.44693 | 0 | 0.220168 | 0.220168 | 1.5 | 1.95023 | 1.95023 | 0.00660503 | 1.5 | 0.957 | 2.17039 | 0.957 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.02871 | 1.44693 | 0.0585068 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.160526 | 2.44 | 52.6561 | 1.95023 | 2.17039 | 0.0434079 | 0.0651118 | ArchiCADProperties - ID of Connected Openings: OP - 004
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T3_Enva_140 | T3 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 17.7957 (kgCO₂) | 308.002 | 0 | 2.6 | 2.6 | 0 | 0 | 0.65 | 1.69 | 1.69 | 0 | 0.65 | 0.65 | 1.69 | 0.65 | 1.69 | 1.69 | 1.69 | 0.65 | 0.65 | 0.0195 | 2.6 | 0.0507 | 0.27 | 9.61 | 0.65 | 0.0507 | 0.0507 | 1.36 | 2.87 | 12.21 | 0.27 | 9.61 | 0.195 | 2.44 | 45.63 | 1.69 | 1.69 | 0.078 | 0.0507
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 34.54 (kgCO₂) | 597.807 | 0 | 2.6 | 1.45847 | 0.619852 | 0.619852 | 1.5 | 3.28015 | 3.28015 | 0.0185956 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.0984045 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.22971 | 2.44 | 88.564 | 3.28015 | 3.9 | 0.078 | 0.117 | ArchiCADProperties - ID of Connected Openings: OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 39.5908 (kgCO₂) | 685.225 | 0 | 2.6 | 0 | 0 | 0 | 1.468 | 3.73559 | 3.78404 | 0 | 1.468 | 1.468 | 3.73559 | 1.468 | 3.78404 | 3.8168 | 3.8168 | 1.468 | 1.468 | 0.04404 | 2.6 | 0.112794 | 0.27 | 9.61 | 1.468 | 0.112794 | 0.114504 | 2.996 | 2.87 | 12.21 | 0.27 | 9.61 | 0.177303 | 2.44 | 101.515 | 3.78404 | 3.78404 | 0.078 | 0.112794 | ArchiCADProperties - ID of Connected Openings: OP - 006
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 39.5932 (kgCO₂) | 685.267 | 0 | 2.6 | 2.13347 | 0.13996 | 0.13996 | 1.5 | 3.76004 | 3.76004 | 0.00419881 | 1.5 | 1.5 | 3.9 | 1.5 | 3.9 | 3.9 | 3.9 | 1.5 | 1.5 | 0.045 | 2.6 | 0.112801 | 0.27 | 9.61 | 1.5 | 0.117 | 0.117 | 3.06 | 2.87 | 12.21 | 0.27 | 9.61 | 0.237 | 2.44 | 101.521 | 3.76004 | 3.9 | 0.078 | 0.117 | ArchiCADProperties - ID of Connected Openings: OP - 004
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 36.5363 (kgCO₂) | 632.359 | 0 | 1.44693 | 1.44693 | 0 | 0 | 2.398 | 3.46973 | 3.46973 | 0 | 2.398 | 2.398 | 3.46973 | 2.398 | 3.46973 | 3.46973 | 3.46973 | 2.398 | 2.398 | 0.07194 | 1.44693 | 0.104092 | 2.872 | 12.212 | 2.398 | 0.104092 | 0.104092 | 4.856 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.230696 | 2.44 | 93.6828 | 3.46973 | 3.46973 | 0.0434079 | 0.104092
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 1 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 21.5734 (kgCO₂) | 373.385 | 0 | 1.44693 | 0 | 0.12164 | 0.12164 | 1.5 | 2.04875 | 2.04875 | 0.00364919 | 1.5 | 1.5 | 2.17039 | 1.5 | 2.17039 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.036 | 1.44693 | 0.0614626 | 2.872 | 12.212 | 1.5 | 0.0651118 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.167816 | 2.44 | 55.3163 | 2.04875 | 2.17039 | 0.0434079 | 0.0651118 | ArchiCADProperties - ID of Connected Openings: OP - 004
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T4_Enva_220 | T4 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Lateral | Enva_220 | 38.57 (kgCO₂) | 667.557 | 0 | 2.6 | 2.6 | 0 | 0 | 1.40879 | 3.66286 | 3.66286 | 0 | 1.40879 | 1.40879 | 3.66286 | 1.40879 | 3.66286 | 3.66286 | 3.66286 | 1.40879 | 1.40879 | 0.0422638 | 2.6 | 0.109886 | 1.71425 | 11.0543 | 1.40879 | 0.109886 | 0.109886 | 2.87759 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.240528 | 2.6 | 98.8973 | 3.66286 | 3.66286 | 0.078 | 0.109886
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 37.8394 (kgCO₂) | 654.913 | 0 | 2.6 | 2.6 | 0 | 0 | 1.38211 | 3.59349 | 3.59349 | 0 | 1.38211 | 1.38211 | 3.59349 | 1.38211 | 3.59349 | 3.59349 | 3.59349 | 1.38211 | 1.38211 | 0.0414633 | 2.6 | 0.107805 | 1.71425 | 11.0543 | 1.38211 | 0.107805 | 0.107805 | 2.82422 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.238927 | 2.6 | 97.0242 | 3.59349 | 3.59349 | 0.078 | 0.107805
T4 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T4 | Nau Lateral | Wood - Pine Grained Horizontal blank | 0 | T2_Extradossat_110 | T2 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Lateral | Extradossat_110 | 33.1274 (kgCO₂) | 573.359 | 0 | 2.6 | 0 | 0 | 0 | 1.13 | 3.146 | 3.146 | 0 | 1.13 | 1.13 | 3.146 | 1.13 | 3.146 | 3.146 | 3.146 | 1.13 | 1.13 | 0.0363 | 2.6 | 0.09438 | 1.71425 | 11.0543 | 1.21 | 0.09438 | 0.09438 | 2.32 | 4.31425 | 13.6543 | 1.71425 | 11.0543 | 0.1506 | 2.6 | 84.942 | 3.146 | 3.146 | 0.078 | 0.09438
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 16.494 (kgCO₂) | 285.473 | 0 | 1.90552 | 1.68298 | 0 | 0 | 0.873 | 1.56639 | 1.56638 | 0 | 0.873 | 0.873 | 1.56639 | 0.873 | 1.56638 | 1.56639 | 1.56638 | 0.873 | 0.873 | 0.02619 | 2.08767 | 0.0469915 | 2.87 | 12.21 | 0.873 | 0.0469915 | 0.0469915 | 1.806 | 4.77552 | 14.1155 | 2.87 | 12.21 | 0.160873 | 2.44 | 42.2924 | 1.56639 | 1.56639 | 0.0626302 | 0.0469915
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 14.4431 (kgCO₂) | 249.976 | 0 | 1.68242 | 1.45988 | 0 | 0 | 0.873 | 1.37162 | 1.37161 | 0 | 0.873 | 0.873 | 1.37162 | 0.873 | 1.37161 | 1.37162 | 1.37161 | 0.873 | 0.873 | 0.02619 | 2.08567 | 0.0411484 | 2.872 | 12.212 | 0.873 | 0.0411484 | 0.0411484 | 1.806 | 4.55442 | 13.8944 | 2.872 | 12.212 | 0.147486 | 2.44 | 37.0335 | 1.37162 | 1.37162 | 0.0625702 | 0.0411484
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 22.6956 (kgCO₂) | 392.809 | 0 | 1.44693 | 0 | 0 | 0 | 1.5 | 2.15533 | 2.15533 | 0 | 1.5 | 1.5 | 2.15533 | 1.5 | 2.15533 | 2.17039 | 2.17039 | 1.5 | 1.5 | 0.0440741 | 1.44693 | 0.0646598 | 2.872 | 12.212 | 1.5 | 0.0646598 | 0.0651118 | 3.06 | 4.31893 | 13.6589 | 2.872 | 12.212 | 0.161247 | 2.44 | 58.1939 | 2.15533 | 2.17039 | 0.0434079 | 0.0651118
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 18.597 (kgCO₂) | 321.872 | 0 | 2.128 | 1.9061 | 0 | 0 | 0.875321 | 1.76611 | 1.76609 | 0 | 0.875321 | 0.875321 | 1.76611 | 0.875321 | 1.76609 | 1.76611 | 1.76609 | 0.875321 | 0.875321 | 0.0262596 | 2.14706 | 0.052983 | 2.87 | 12.21 | 0.875321 | 0.052983 | 0.052983 | 1.81064 | 4.998 | 14.338 | 2.87 | 12.21 | 0.174345 | 2.44 | 47.6847 | 1.76611 | 1.76611 | 0.0644117 | 0.052983
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 14.4151 (kgCO₂) | 249.493 | 0 | 1.67938 | 1.45684 | 0 | 0 | 0.873 | 1.36895 | 1.36897 | 0 | 0.873 | 0.873 | 1.36895 | 0.873 | 1.36897 | 1.36895 | 1.36897 | 0.873 | 0.873 | 0.02619 | 2.08567 | 0.0410688 | 2.872 | 12.212 | 0.873 | 0.0410688 | 0.0410688 | 1.806 | 4.55138 | 13.8914 | 2.872 | 12.212 | 0.147304 | 2.44 | 36.9619 | 1.36897 | 1.36897 | 0.0625702 | 0.0410688
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 18.5691 (kgCO₂) | 321.388 | 0 | 2.12619 | 1.90306 | 0 | 0 | 0.875321 | 1.76344 | 1.76345 | 0 | 0.875321 | 0.875321 | 1.76344 | 0.875321 | 1.76345 | 1.76344 | 1.76345 | 0.875321 | 0.875321 | 0.0262596 | 2.14706 | 0.0529033 | 2.87 | 12.21 | 0.875321 | 0.0529033 | 0.0529033 | 1.81064 | 4.99619 | 14.3362 | 2.87 | 12.21 | 0.174236 | 2.44 | 47.613 | 1.76345 | 1.76345 | 0.0644117 | 0.0529033
T1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T1_Enva_140 | T1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca sobre perfileria metàl·lica | Nau Santa Eulalia | Enva_140 | 16.4661 (kgCO₂) | 284.99 | 0 | 1.90249 | 1.67994 | 0 | 0 | 0.873 | 1.56372 | 1.56374 | 0 | 0.873 | 0.873 | 1.56372 | 0.873 | 1.56374 | 1.56372 | 1.56374 | 0.873 | 0.873 | 0.02619 | 2.08767 | 0.0469119 | 2.87 | 12.21 | 0.873 | 0.0469119 | 0.0469119 | 1.806 | 4.77249 | 14.1125 | 2.87 | 12.21 | 0.16069 | 2.44 | 42.2207 | 1.56374 | 1.56374 | 0.0626302 | 0.0469119
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Espai de treball; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 35.3998 (kgCO₂) | 612.688 | 0 | 2.6 | 2.6 | 0 | 0 | 1.293 | 3.3618 | 3.3618 | 0 | 1.293 | 1.293 | 3.3618 | 1.293 | 3.3618 | 3.3618 | 3.3618 | 1.293 | 1.293 | 0.03879 | 2.6 | 0.100854 | 0.27 | 9.61 | 1.293 | 0.100854 | 0.100854 | 2.646 | 2.87 | 12.21 | 0.27 | 9.61 | 0.23358 | 2.44 | 90.7686 | 3.3618 | 3.3618 | 0.078 | 0.100854
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.4467 (kgCO₂) | 353.886 | 0 | 2.6 | 1.22251 | 0.712839 | 0.712839 | 1.021 | 1.94176 | 1.94176 | 0.0213852 | 1.021 | 1.021 | 2.6546 | 1.021 | 2.6546 | 2.6546 | 2.6546 | 1.021 | 1.021 | 0.03063 | 2.6 | 0.0582528 | 0.27 | 9.61 | 1.021 | 0.079638 | 0.079638 | 2.102 | 2.87 | 12.21 | 0.27 | 9.61 | 0.143451 | 2.44 | 52.4275 | 1.94176 | 2.6546 | 0.078 | 0.079638 | ArchiCADProperties - ID of Connected Openings: OP - 013; OP - 016
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 33.9487 (kgCO₂) | 587.574 | 0 | 2.6 | 2.6 | 0 | 0 | 1.24 | 3.224 | 3.224 | 0 | 1.24 | 1.24 | 3.224 | 1.24 | 3.224 | 3.224 | 3.224 | 1.24 | 1.24 | 0.0372 | 2.6 | 0.09672 | 0.27 | 9.61 | 1.24 | 0.09672 | 0.09672 | 2.54 | 2.87 | 12.21 | 0.27 | 9.61 | 0.2304 | 2.44 | 87.048 | 3.224 | 3.224 | 0.078 | 0.09672
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.5237 (kgCO₂) | 355.217 | 0 | 2.6 | 1.22422 | 0.710734 | 0.710734 | 1.023 | 1.94907 | 1.94907 | 0.021322 | 1.023 | 1.023 | 2.6598 | 1.023 | 2.6598 | 2.6598 | 2.6598 | 1.023 | 1.023 | 0.03069 | 2.6 | 0.058472 | 0.27 | 9.61 | 1.023 | 0.079794 | 0.079794 | 2.106 | 2.87 | 12.21 | 0.27 | 9.61 | 0.143721 | 2.44 | 52.6248 | 1.94907 | 2.6598 | 0.078 | 0.079794 | ArchiCADProperties - ID of Connected Openings: OP - 014; OP - 015
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 35.1006 (kgCO₂) | 607.51 | 0 | 2.6 | 2.6 | 0 | 0 | 1.28207 | 3.33339 | 3.33339 | 0 | 1.28207 | 1.28207 | 3.33339 | 1.28207 | 3.33339 | 3.33339 | 3.33339 | 1.28207 | 1.28207 | 0.0384622 | 2.6 | 0.100002 | 0.27 | 9.61 | 1.28207 | 0.100002 | 0.100002 | 2.62415 | 2.87 | 12.21 | 0.27 | 9.61 | 0.232924 | 2.44 | 90.0015 | 3.33339 | 3.33339 | 0.078 | 0.100002
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 29.1965 (kgCO₂) | 505.323 | 0 | 2.6 | 2.6 | 0 | 0 | 1.06642 | 2.77269 | 2.77269 | -9.57567e-16 | 1.06642 | 1.06642 | 2.77269 | 1.06642 | 2.77269 | 2.77269 | 2.77269 | 1.06642 | 1.06642 | 0.0319926 | 2.6 | 0.0831808 | 0.27 | 9.61 | 1.06642 | 0.0831808 | 0.0831808 | 2.19284 | 2.87 | 12.21 | 0.27 | 9.61 | 0.219985 | 2.44 | 74.8627 | 2.77269 | 2.77269 | 0.078 | 0.0831808 | ArchiCADProperties - ID of Connected Openings: OP - 005; OP - 006
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 23.4702 (kgCO₂) | 406.214 | 0 | 2.6 | 1.22157 | 1.50731 | 1.50731 | 1.437 | 2.22889 | 2.22889 | 0.0452194 | 1.437 | 1.437 | 3.7362 | 1.437 | 3.7362 | 3.7362 | 3.7362 | 1.437 | 1.437 | 0.04311 | 2.6 | 0.0668666 | 0.27 | 9.61 | 1.437 | 0.112086 | 0.112086 | 2.934 | 2.87 | 12.21 | 0.27 | 9.61 | 0.168062 | 2.44 | 60.1799 | 2.22889 | 3.7362 | 0.078 | 0.112086 | ArchiCADProperties - ID of Connected Openings: OP - 005; OP - 005
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 3 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 23.8234 (kgCO₂) | 412.328 | 0 | 2.6 | 1.22157 | 1.51017 | 1.51017 | 1.451 | 2.26243 | 2.26243 | 0.0453051 | 1.451 | 1.451 | 3.7726 | 1.451 | 3.7726 | 3.7726 | 3.7726 | 1.451 | 1.451 | 0.04353 | 2.6 | 0.0678729 | 0.27 | 9.61 | 1.451 | 0.113178 | 0.113178 | 2.962 | 2.87 | 12.21 | 0.27 | 9.61 | 0.16884 | 2.44 | 61.0856 | 2.26243 | 3.7726 | 0.078 | 0.113178 | ArchiCADProperties - ID of Connected Openings: OP - 005; OP - 006; OP - 008
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 35.7085 (kgCO₂) | 618.031 | 0 | 2.6 | 2.6 | 0 | 0 | 1.30428 | 3.39112 | 3.39112 | 0 | 1.30428 | 1.30428 | 3.39112 | 1.30428 | 3.39112 | 3.39112 | 3.39112 | 1.30428 | 1.30428 | 0.0391283 | 2.6 | 0.101733 | 0.27 | 9.61 | 1.30428 | 0.101733 | 0.101733 | 2.66855 | 2.87 | 12.21 | 0.27 | 9.61 | 0.234257 | 2.44 | 91.5601 | 3.39112 | 3.39112 | 0.078 | 0.101733
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.4971 (kgCO₂) | 354.758 | 0 | 2.6 | 1.22251 | 0.713253 | 0.713253 | 1.023 | 1.94655 | 1.94655 | 0.0213976 | 1.023 | 1.023 | 2.6598 | 1.023 | 2.6598 | 2.6598 | 2.6598 | 1.023 | 1.023 | 0.03069 | 2.6 | 0.0583964 | 0.27 | 9.61 | 1.023 | 0.079794 | 0.079794 | 2.106 | 2.87 | 12.21 | 0.27 | 9.61 | 0.14367 | 2.44 | 52.5568 | 1.94655 | 2.6598 | 0.078 | 0.079794 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Espai d'atenció; Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 34.0856 (kgCO₂) | 589.943 | 0 | 2.6 | 2.6 | 0 | 0 | 1.245 | 3.237 | 3.237 | 0 | 1.245 | 1.245 | 3.237 | 1.245 | 3.237 | 3.237 | 3.237 | 1.245 | 1.245 | 0.03735 | 2.6 | 0.09711 | 0.27 | 9.61 | 1.245 | 0.09711 | 0.09711 | 2.55 | 2.87 | 12.21 | 0.27 | 9.61 | 0.2307 | 2.44 | 87.399 | 3.237 | 3.237 | 0.078 | 0.09711
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 3 | F1_Extradossat_190 | F1 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 23.4811 (kgCO₂) | 406.403 | 0 | 2.6 | 1.22251 | 1.50628 | 1.50628 | 1.437 | 2.22992 | 2.22992 | 0.0451884 | 1.437 | 1.437 | 3.7362 | 1.437 | 3.7362 | 3.7362 | 3.7362 | 1.437 | 1.437 | 0.04311 | 2.6 | 0.0668976 | 0.27 | 9.61 | 1.437 | 0.112086 | 0.112086 | 2.934 | 2.87 | 12.21 | 0.27 | 9.61 | 0.16809 | 2.44 | 60.2079 | 2.22992 | 3.7362 | 0.078 | 0.112086 | ArchiCADProperties - ID of Connected Openings: OP - 010; OP - 011; OP - 012
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 23.4941 (kgCO₂) | 406.629 | 0 | 2.6 | 1.21967 | 1.51284 | 1.51284 | 1.44 | 2.23116 | 2.23116 | 0.0453851 | 1.44 | 1.44 | 3.744 | 1.44 | 3.744 | 3.744 | 3.744 | 1.44 | 1.44 | 0.0432 | 2.6 | 0.0669349 | 0.27 | 9.61 | 1.44 | 0.11232 | 0.11232 | 2.94 | 2.87 | 12.21 | 0.27 | 9.61 | 0.1267 | 2.44 | 60.2414 | 2.23116 | 3.744 | 0.078 | 0.11232 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 005
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 2 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 20.4652 (kgCO₂) | 354.205 | 0 | 2.6 | 1.22251 | 0.71109 | 0.71109 | 1.021 | 1.94351 | 1.94351 | 0.0213327 | 1.021 | 1.021 | 2.6546 | 1.021 | 2.6546 | 2.6546 | 2.6546 | 1.021 | 1.021 | 0.03063 | 2.6 | 0.0583053 | 0.27 | 9.61 | 1.021 | 0.079638 | 0.079638 | 2.102 | 2.87 | 12.21 | 0.27 | 9.61 | 0.143451 | 2.44 | 52.4748 | 1.94351 | 2.6546 | 0.078 | 0.079638 | ArchiCADProperties - ID of Connected Openings: OP - 004; OP - 004
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 29.4115 (kgCO₂) | 509.045 | 0 | 2.6 | 1.105 | 0 | 0 | 1.305 | 2.79311 | 2.79311 | 0 | 1.305 | 1.305 | 2.79311 | 1.305 | 2.79311 | 3.393 | 3.393 | 1.305 | 1.305 | 0.03915 | 2.6 | 0.0837934 | 0.27 | 9.61 | 1.305 | 0.0837934 | 0.10179 | 2.67 | 2.87 | 12.21 | 0.27 | 9.61 | 0.2343 | 2.44 | 75.4141 | 2.79313 | 3.393 | 0.078 | 0.10179
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 28.4675 (kgCO₂) | 492.706 | 0 | 2.6 | 2.6 | 0 | 0 | 1.03979 | 2.70346 | 2.70346 | 0 | 1.03979 | 1.03979 | 2.70346 | 1.03979 | 2.70346 | 2.70346 | 2.70346 | 1.03979 | 1.03979 | 0.0311938 | 2.6 | 0.0811039 | 0.27 | 9.61 | 1.03979 | 0.0811039 | 0.0811039 | 2.13959 | 2.87 | 12.21 | 0.27 | 9.61 | 0.218388 | 2.44 | 72.9935 | 2.70346 | 2.70346 | 0.078 | 0.0811039
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 19.8731 (kgCO₂) | 343.958 | 0 | 1.447 | 1.447 | 0 | 0 | 1.30428 | 1.88729 | 1.88729 | 0 | 1.30428 | 1.30428 | 1.88729 | 1.30428 | 1.88729 | 1.88729 | 1.88729 | 1.30428 | 1.30428 | 0.0391283 | 1.447 | 0.0566186 | 2.872 | 12.212 | 1.30428 | 0.0566186 | 0.0566186 | 2.66855 | 4.319 | 13.659 | 2.872 | 12.212 | 0.165077 | 2.44 | 50.9567 | 1.88729 | 1.88729 | 0.04341 | 0.0566186
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 27.8686 (kgCO₂) | 482.34 | 0 | 2.6 | 2.6 | 0 | 0 | 1.01792 | 2.64659 | 2.64659 | 0 | 1.01792 | 1.01792 | 2.64659 | 1.01792 | 2.64659 | 2.64659 | 2.64659 | 1.01792 | 1.01792 | 0.0305375 | 2.6 | 0.0793976 | 0.27 | 9.61 | 1.01792 | 0.0793976 | 0.0793976 | 2.09584 | 2.87 | 12.21 | 0.27 | 9.61 | 0.217075 | 2.44 | 71.4578 | 2.64659 | 2.64659 | 0.078 | 0.0793976
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 19.8842 (kgCO₂) | 344.149 | 0 | 1.447 | 1.447 | 0 | 0 | 1.305 | 1.88833 | 1.88833 | 0 | 1.305 | 1.305 | 1.88833 | 1.305 | 1.88833 | 1.88833 | 1.88833 | 1.305 | 1.305 | 0.03915 | 1.447 | 0.0566501 | 2.872 | 12.212 | 1.305 | 0.0566501 | 0.0566501 | 2.67 | 4.319 | 13.659 | 2.872 | 12.212 | 0.16512 | 2.44 | 50.985 | 1.88833 | 1.88833 | 0.04341 | 0.0566501
F1 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | F1 | Nau Santa Eulàlia; Sala de reunions | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 27.7065 (kgCO₂) | 479.536 | 0 | 2.6 | 2.6 | 0 | 0 | 1.012 | 2.6312 | 2.6312 | 0 | 1.012 | 1.012 | 2.6312 | 1.012 | 2.6312 | 2.6312 | 2.6312 | 1.012 | 1.012 | 0.03036 | 2.6 | 0.078936 | 0.27 | 9.61 | 1.012 | 0.078936 | 0.078936 | 2.084 | 2.87 | 12.21 | 0.27 | 9.61 | 0.21672 | 2.44 | 71.0424 | 2.6312 | 2.6312 | 0.078 | 0.078936
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia; Sala de reunions | Wood - Pine Grained Horizontal blank | 0 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 15.4198 (kgCO₂) | 266.88 | 0 | 1.447 | 1.447 | 0 | 0 | 1.012 | 1.46436 | 1.46436 | 0 | 1.012 | 1.012 | 1.46436 | 1.012 | 1.46436 | 1.46436 | 1.46436 | 1.012 | 1.012 | 0.03036 | 1.447 | 0.0439309 | 2.872 | 12.212 | 1.012 | 0.0439309 | 0.0439309 | 2.084 | 4.319 | 13.659 | 2.872 | 12.212 | 0.14754 | 2.44 | 39.5378 | 1.46436 | 1.46436 | 0.04341 | 0.0439309
T6 | Outside Face | Wood - Pine Grained Horizontal blank | Wood - Pine Grained Horizontal blank | T6 | Nau Santa Eulàlia | Wood - Pine Grained Horizontal blank | 4 | T6_Extradossat_190 | T6 | Envà de cartró guix tipus Glasroc amb aïllament de llana de roca fixat mecànimacament | Nau Santa Eulalia | Extradossat_190 | 12.3581 (kgCO₂) | 213.89 | 0 | 1.447 | 0 | 0.306671 | 0.306671 | 1.023 | 1.17361 | 1.17361 | 0.00920012 | 1.023 | 0.572155 | 1.48028 | 0.572155 | 1.48028 | 1.48028 | 1.48028 | 1.023 | 1.023 | 0.0104736 | 1.447 | 0.0352083 | 2.872 | 12.212 | 1.023 | 0.0444084 | 0.0444084 | 2.106 | 4.319 | 13.659 | 2.872 | 12.212 | 0.100696 | 2.44 | 31.6875 | 1.17361 | 1.48028 | 0.04341 | 0.0444084 | ArchiCADProperties - ID of Connected Openings: OP - 017; OP - 018; OP - 019; OP - 014
