Properties of the parts of a building model (IFC2X3), part 35 of 99

# IfcBuildingElementProxy: Rhino_Object_1276, Object_1276
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1276_; 109.AMB.CodiTipus: Object_1276; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1276 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23163 m; Elevation to 1st Reference Level: 1.23163 m; Elevation to 2nd Reference Level: 1.23163 m; Elevation to Sea Level: 10.5716 m; Elevation to Linked/Home Story: 1.23163 m; Home Offset: 1.23163 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35171 m; Top Elevation To Home Story: 1.35171 m; Top Elevation To Project Zero: 1.35171 m; Top Elevation To Sea Level: 10.6917 m; Top Elevation To Second Reference Level: 1.35171 m; Bottom Elevation To First Reference Level: 1.23163 m; Bottom Elevation To Home Story: 1.23163 m; Bottom Elevation To Project Zero: 1.23163 m; Bottom Elevation To Sea Level: 10.5716 m; Bottom Elevation To Second Reference Level: 1.23163 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 10.5716 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1277, Object_1277
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1277; Hotlink and Element ID: Object_1277; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1277; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1277; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1277 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1277_; 109.AMB.CodiTipus: Object_1277; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_1277 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23171 m; Elevation to 1st Reference Level: 1.23171 m; Elevation to 2nd Reference Level: 1.23171 m; Elevation to Sea Level: 10.5717 m; Elevation to Linked/Home Story: 1.23171 m; Home Offset: 1.23171 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35179 m; Top Elevation To Home Story: 1.35179 m; Top Elevation To Project Zero: 1.35179 m; Top Elevation To Sea Level: 10.6918 m; Top Elevation To Second Reference Level: 1.35179 m; Bottom Elevation To First Reference Level: 1.23171 m; Bottom Elevation To Home Story: 1.23171 m; Bottom Elevation To Project Zero: 1.23171 m; Bottom Elevation To Sea Level: 10.5717 m; Bottom Elevation To Second Reference Level: 1.23171 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 10.5717 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2

# IfcBuildingElementProxy: Rhino_Object_1278, Object_1278
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1278; Hotlink and Element ID: Object_1278; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1278; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1278; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1278 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1278_; 109.AMB.CodiTipus: Object_1278; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23179 m; Elevation to 1st Reference Level: 1.23179 m; Elevation to 2nd Reference Level: 1.23179 m; Elevation to Sea Level: 10.5718 m; Elevation to Linked/Home Story: 1.23179 m; Home Offset: 1.23179 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35187 m; Top Elevation To Home Story: 1.35187 m; Top Elevation To Project Zero: 1.35187 m; Top Elevation To Sea Level: 10.6919 m; Top Elevation To Second Reference Level: 1.35187 m; Bottom Elevation To First Reference Level: 1.23179 m; Bottom Elevation To Home Story: 1.23179 m; Bottom Elevation To Project Zero: 1.23179 m; Bottom Elevation To Sea Level: 10.5718 m; Bottom Elevation To Second Reference Level: 1.23179 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 10.5718 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1278 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1279, Object_1279
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1279; Hotlink and Element ID: Object_1279; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1279; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1279; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1279 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1279_; 109.AMB.CodiTipus: Object_1279; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23187 m; Elevation to 1st Reference Level: 1.23187 m; Elevation to 2nd Reference Level: 1.23187 m; Elevation to Sea Level: 10.5719 m; Elevation to Linked/Home Story: 1.23187 m; Home Offset: 1.23187 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35195 m; Top Elevation To Home Story: 1.35195 m; Top Elevation To Project Zero: 1.35195 m; Top Elevation To Sea Level: 10.6919 m; Top Elevation To Second Reference Level: 1.35195 m; Bottom Elevation To First Reference Level: 1.23187 m; Bottom Elevation To Home Story: 1.23187 m; Bottom Elevation To Project Zero: 1.23187 m; Bottom Elevation To Sea Level: 10.5719 m; Bottom Elevation To Second Reference Level: 1.23187 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 10.5719 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1279 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_128, Object_128
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_128; Hotlink and Element ID: Object_128; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_128; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_128; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_128 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_128_; 109.AMB.CodiTipus: Object_128; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
AC_Equantity_Rhino_Object_128 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426575 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1280, Object_1280
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1280; Hotlink and Element ID: Object_1280; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1280; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1280; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1280 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1280_; 109.AMB.CodiTipus: Object_1280; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23195 m; Elevation to 1st Reference Level: 1.23195 m; Elevation to 2nd Reference Level: 1.23195 m; Elevation to Sea Level: 10.5719 m; Elevation to Linked/Home Story: 1.23195 m; Home Offset: 1.23195 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35203 m; Top Elevation To Home Story: 1.35203 m; Top Elevation To Project Zero: 1.35203 m; Top Elevation To Sea Level: 10.692 m; Top Elevation To Second Reference Level: 1.35203 m; Bottom Elevation To First Reference Level: 1.23195 m; Bottom Elevation To Home Story: 1.23195 m; Bottom Elevation To Project Zero: 1.23195 m; Bottom Elevation To Sea Level: 10.5719 m; Bottom Elevation To Second Reference Level: 1.23195 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 10.5719 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1280 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1281, Object_1281
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1281; Hotlink and Element ID: Object_1281; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1281; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1281; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1281 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1281_; 109.AMB.CodiTipus: Object_1281; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23203 m; Elevation to 1st Reference Level: 1.23203 m; Elevation to 2nd Reference Level: 1.23203 m; Elevation to Sea Level: 10.572 m; Elevation to Linked/Home Story: 1.23203 m; Home Offset: 1.23203 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35211 m; Top Elevation To Home Story: 1.35211 m; Top Elevation To Project Zero: 1.35211 m; Top Elevation To Sea Level: 10.6921 m; Top Elevation To Second Reference Level: 1.35211 m; Bottom Elevation To First Reference Level: 1.23203 m; Bottom Elevation To Home Story: 1.23203 m; Bottom Elevation To Project Zero: 1.23203 m; Bottom Elevation To Sea Level: 10.572 m; Bottom Elevation To Second Reference Level: 1.23203 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 10.572 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1281 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1282, Object_1282
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1282; Hotlink and Element ID: Object_1282; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1282; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1282; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1282 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1282_; 109.AMB.CodiTipus: Object_1282; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.2321 m; Elevation to 1st Reference Level: 1.2321 m; Elevation to 2nd Reference Level: 1.2321 m; Elevation to Sea Level: 10.5721 m; Elevation to Linked/Home Story: 1.2321 m; Home Offset: 1.2321 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35219 m; Top Elevation To Home Story: 1.35219 m; Top Elevation To Project Zero: 1.35219 m; Top Elevation To Sea Level: 10.6922 m; Top Elevation To Second Reference Level: 1.35219 m; Bottom Elevation To First Reference Level: 1.2321 m; Bottom Elevation To Home Story: 1.2321 m; Bottom Elevation To Project Zero: 1.2321 m; Bottom Elevation To Sea Level: 10.5721 m; Bottom Elevation To Second Reference Level: 1.2321 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 10.5721 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1282 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1283, Object_1283
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1283; Hotlink and Element ID: Object_1283; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1283; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1283; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1283 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1283_; 109.AMB.CodiTipus: Object_1283; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23218 m; Elevation to 1st Reference Level: 1.23218 m; Elevation to 2nd Reference Level: 1.23218 m; Elevation to Sea Level: 10.5722 m; Elevation to Linked/Home Story: 1.23218 m; Home Offset: 1.23218 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35226 m; Top Elevation To Home Story: 1.35226 m; Top Elevation To Project Zero: 1.35226 m; Top Elevation To Sea Level: 10.6923 m; Top Elevation To Second Reference Level: 1.35226 m; Bottom Elevation To First Reference Level: 1.23218 m; Bottom Elevation To Home Story: 1.23218 m; Bottom Elevation To Project Zero: 1.23218 m; Bottom Elevation To Sea Level: 10.5722 m; Bottom Elevation To Second Reference Level: 1.23218 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579782 m; Survey Coordinate Z: 10.5722 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Equantity_Rhino_Object_1283 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1284, Object_1284
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1284 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1284; Hotlink and Element ID: Object_1284; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1284; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1284; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1284_; 109.AMB.CodiTipus: Object_1284; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1284 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23226 m; Elevation to 1st Reference Level: 1.23226 m; Elevation to 2nd Reference Level: 1.23226 m; Elevation to Sea Level: 10.5723 m; Elevation to Linked/Home Story: 1.23226 m; Home Offset: 1.23226 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35234 m; Top Elevation To Home Story: 1.35234 m; Top Elevation To Project Zero: 1.35234 m; Top Elevation To Sea Level: 10.6923 m; Top Elevation To Second Reference Level: 1.35234 m; Bottom Elevation To First Reference Level: 1.23226 m; Bottom Elevation To Home Story: 1.23226 m; Bottom Elevation To Project Zero: 1.23226 m; Bottom Elevation To Sea Level: 10.5723 m; Bottom Elevation To Second Reference Level: 1.23226 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5723 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1285, Object_1285
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1285; Hotlink and Element ID: Object_1285; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1285; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1285; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1285 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23234 m; Elevation to 1st Reference Level: 1.23234 m; Elevation to 2nd Reference Level: 1.23234 m; Elevation to Sea Level: 10.5723 m; Elevation to Linked/Home Story: 1.23234 m; Home Offset: 1.23234 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35242 m; Top Elevation To Home Story: 1.35242 m; Top Elevation To Project Zero: 1.35242 m; Top Elevation To Sea Level: 10.6924 m; Top Elevation To Second Reference Level: 1.35242 m; Bottom Elevation To First Reference Level: 1.23234 m; Bottom Elevation To Home Story: 1.23234 m; Bottom Elevation To Project Zero: 1.23234 m; Bottom Elevation To Sea Level: 10.5723 m; Bottom Elevation To Second Reference Level: 1.23234 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5723 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1285_; 109.AMB.CodiTipus: Object_1285; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Equantity_Rhino_Object_1285 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m

# IfcBuildingElementProxy: Rhino_Object_1286, Object_1286
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1286; Hotlink and Element ID: Object_1286; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1286; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1286; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1286 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1286_; 109.AMB.CodiTipus: Object_1286; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23242 m; Elevation to 1st Reference Level: 1.23242 m; Elevation to 2nd Reference Level: 1.23242 m; Elevation to Sea Level: 10.5724 m; Elevation to Linked/Home Story: 1.23242 m; Home Offset: 1.23242 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.3525 m; Top Elevation To Home Story: 1.3525 m; Top Elevation To Project Zero: 1.3525 m; Top Elevation To Sea Level: 10.6925 m; Top Elevation To Second Reference Level: 1.3525 m; Bottom Elevation To First Reference Level: 1.23242 m; Bottom Elevation To Home Story: 1.23242 m; Bottom Elevation To Project Zero: 1.23242 m; Bottom Elevation To Sea Level: 10.5724 m; Bottom Elevation To Second Reference Level: 1.23242 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5724 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1286 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1287, Object_1287
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1287; Hotlink and Element ID: Object_1287; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1287; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1287; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1287 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.2325 m; Elevation to 1st Reference Level: 1.2325 m; Elevation to 2nd Reference Level: 1.2325 m; Elevation to Sea Level: 10.5725 m; Elevation to Linked/Home Story: 1.2325 m; Home Offset: 1.2325 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35258 m; Top Elevation To Home Story: 1.35258 m; Top Elevation To Project Zero: 1.35258 m; Top Elevation To Sea Level: 10.6926 m; Top Elevation To Second Reference Level: 1.35258 m; Bottom Elevation To First Reference Level: 1.2325 m; Bottom Elevation To Home Story: 1.2325 m; Bottom Elevation To Project Zero: 1.2325 m; Bottom Elevation To Sea Level: 10.5725 m; Bottom Elevation To Second Reference Level: 1.2325 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5725 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1287 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1287_; 109.AMB.CodiTipus: Object_1287; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1288, Object_1288
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1288 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1288; Hotlink and Element ID: Object_1288; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1288; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1288; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1288_; 109.AMB.CodiTipus: Object_1288; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23258 m; Elevation to 1st Reference Level: 1.23258 m; Elevation to 2nd Reference Level: 1.23258 m; Elevation to Sea Level: 10.5726 m; Elevation to Linked/Home Story: 1.23258 m; Home Offset: 1.23258 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35266 m; Top Elevation To Home Story: 1.35266 m; Top Elevation To Project Zero: 1.35266 m; Top Elevation To Sea Level: 10.6927 m; Top Elevation To Second Reference Level: 1.35266 m; Bottom Elevation To First Reference Level: 1.23258 m; Bottom Elevation To Home Story: 1.23258 m; Bottom Elevation To Project Zero: 1.23258 m; Bottom Elevation To Sea Level: 10.5726 m; Bottom Elevation To Second Reference Level: 1.23258 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5726 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1288 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3

# IfcBuildingElementProxy: Rhino_Object_1289, Object_1289
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5006 deg; Surface: Brick - Aged Natural; Element ID: Object_1289; Hotlink and Element ID: Object_1289; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1289; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1289; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1289 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 0; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1289_; 109.AMB.CodiTipus: Object_1289; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.207088 m; Area: 0.0231988 m2; Height: 0.120086 m; Volume (Net): 0.00120379 m3; Width: 0.112024 m; Elevation to Project Zero: 1.23266 m; Elevation to 1st Reference Level: 1.23266 m; Elevation to 2nd Reference Level: 1.23266 m; Elevation to Sea Level: 10.5727 m; Elevation to Linked/Home Story: 1.23266 m; Home Offset: 1.23266 m; Surface Area: 0.0782073 m2; Top Elevation To First Reference Level: 1.35274 m; Top Elevation To Home Story: 1.35274 m; Top Elevation To Project Zero: 1.35274 m; Top Elevation To Sea Level: 10.6927 m; Top Elevation To Second Reference Level: 1.35274 m; Bottom Elevation To First Reference Level: 1.23266 m; Bottom Elevation To Home Story: 1.23266 m; Bottom Elevation To Project Zero: 1.23266 m; Bottom Elevation To Sea Level: 10.5727 m; Bottom Elevation To Second Reference Level: 1.23266 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579781 m; Survey Coordinate Z: 10.5727 m; Top Surface Area (Net): 0.0231988 m2; Bottom Surface Area (Net): 0.0782073 m2
AC_Equantity_Rhino_Object_1289 - Dimension 1: 0.207088 m; Dimension 2: 0.112024 m; Height: 0.120086 m; Bottom Level: -5.03309e-12 m; Top Level: 0.120086 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112024 m; 503.AMB.Altura: 0.120086 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00120379 m3; Component, Component Volume (Gross): 0.00120379 m3
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez

# IfcBuildingElementProxy: Rhino_Object_129, Object_129
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_129 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_129; Hotlink and Element ID: Object_129; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_129; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_129; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
