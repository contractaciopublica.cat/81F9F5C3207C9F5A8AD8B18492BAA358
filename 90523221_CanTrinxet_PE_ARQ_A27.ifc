Properties of the parts of a building model (IFC2X3), part 53 of 99

# IfcBuildingElementProxy: Rhino_Object_1544, Object_1544
AC_Pset_Rhino_Object_1544 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1544_; 109.AMB.CodiTipus: Object_1544; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15015 m; Area: 0.0147983 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.0985568 m; Elevation to Project Zero: 4.19492 m; Elevation to 1st Reference Level: 4.19492 m; Elevation to 2nd Reference Level: 4.19492 m; Elevation to Sea Level: 13.5349 m; Elevation to Linked/Home Story: 4.19492 m; Home Offset: 4.19492 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25242 m; Top Elevation To Home Story: 4.25242 m; Top Elevation To Project Zero: 4.25242 m; Top Elevation To Sea Level: 13.5924 m; Top Elevation To Second Reference Level: 4.25242 m; Bottom Elevation To First Reference Level: 4.19492 m; Bottom Elevation To Home Story: 4.19492 m; Bottom Elevation To Project Zero: 4.19492 m; Bottom Elevation To Sea Level: 13.5349 m; Bottom Elevation To Second Reference Level: 4.19492 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.5349 m; Top Surface Area (Net): 0.0147983 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1544 - Dimension 1: 0.15015 m; Dimension 2: 0.0985568 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0985568 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1545, Object_1545
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1545; Hotlink and Element ID: Object_1545; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1545; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1545; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1545 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1545_; 109.AMB.CodiTipus: Object_1545; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.10463 m; Area: 0.00898444 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0858688 m; Elevation to Project Zero: 3.97018 m; Elevation to 1st Reference Level: 3.97018 m; Elevation to 2nd Reference Level: 3.97018 m; Elevation to Sea Level: 13.3102 m; Elevation to Linked/Home Story: 3.97018 m; Home Offset: 3.97018 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19492 m; Top Elevation To Home Story: 4.19492 m; Top Elevation To Project Zero: 4.19492 m; Top Elevation To Sea Level: 13.5349 m; Top Elevation To Second Reference Level: 4.19492 m; Bottom Elevation To First Reference Level: 3.97018 m; Bottom Elevation To Home Story: 3.97018 m; Bottom Elevation To Project Zero: 3.97018 m; Bottom Elevation To Sea Level: 13.3102 m; Bottom Elevation To Second Reference Level: 3.97018 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.3102 m; Top Surface Area (Net): 0.00898444 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1545 - Dimension 1: 0.10463 m; Dimension 2: 0.0858688 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0858688 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3

# IfcBuildingElementProxy: Rhino_Object_1546, Object_1546
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADQuantities - Length (A): 0.147744 m; Area: 0.00866213 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0586292 m; Elevation to Project Zero: 3.92949 m; Elevation to 1st Reference Level: 3.92949 m; Elevation to 2nd Reference Level: 3.92949 m; Elevation to Sea Level: 13.2695 m; Elevation to Linked/Home Story: 3.92949 m; Home Offset: 3.92949 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97018 m; Top Elevation To Home Story: 3.97018 m; Top Elevation To Project Zero: 3.97018 m; Top Elevation To Sea Level: 13.3102 m; Top Elevation To Second Reference Level: 3.97018 m; Bottom Elevation To First Reference Level: 3.92949 m; Bottom Elevation To Home Story: 3.92949 m; Bottom Elevation To Project Zero: 3.92949 m; Bottom Elevation To Sea Level: 13.2695 m; Bottom Elevation To Second Reference Level: 3.92949 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.2695 m; Top Surface Area (Net): 0.00866213 m2; Bottom Surface Area (Net): 0.0303692 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1546_; 109.AMB.CodiTipus: Object_1546; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1546; Hotlink and Element ID: Object_1546; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1546; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1546; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1546 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
AC_Equantity_Rhino_Object_1546 - Dimension 1: 0.147744 m; Dimension 2: 0.0586292 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0586292 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1547, Object_1547
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1547; Hotlink and Element ID: Object_1547; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1547; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1547; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1547 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1547_; 109.AMB.CodiTipus: Object_1547; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.0941367 m; Area: 0.00334263 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0355082 m; Elevation to Project Zero: 3.87199 m; Elevation to 1st Reference Level: 3.87199 m; Elevation to 2nd Reference Level: 3.87199 m; Elevation to Sea Level: 13.212 m; Elevation to Linked/Home Story: 3.87199 m; Home Offset: 3.87199 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92949 m; Top Elevation To Home Story: 3.92949 m; Top Elevation To Project Zero: 3.92949 m; Top Elevation To Sea Level: 13.2695 m; Top Elevation To Second Reference Level: 3.92949 m; Bottom Elevation To First Reference Level: 3.87199 m; Bottom Elevation To Home Story: 3.87199 m; Bottom Elevation To Project Zero: 3.87199 m; Bottom Elevation To Sea Level: 13.212 m; Bottom Elevation To Second Reference Level: 3.87199 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.212 m; Top Surface Area (Net): 0.00334263 m2; Bottom Surface Area (Net): 0.0196375 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.0355082 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
AC_Equantity_Rhino_Object_1547 - Dimension 1: 0.0941367 m; Dimension 2: 0.0355082 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m

# IfcBuildingElementProxy: Rhino_Object_1548, Object_1548
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1548 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1548; Hotlink and Element ID: Object_1548; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1548; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1548; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1548_; 109.AMB.CodiTipus: Object_1548; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216263 m; Area: 0.0243264 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112485 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30992 m; Top Elevation To Home Story: 4.30992 m; Top Elevation To Project Zero: 4.30992 m; Top Elevation To Sea Level: 13.6499 m; Top Elevation To Second Reference Level: 4.30992 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0243264 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1548 - Dimension 1: 0.216263 m; Dimension 2: 0.112485 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112485 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1549, Object_1549
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1549 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1549_; 109.AMB.CodiTipus: Object_1549; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15015 m; Area: 0.0147983 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.0985568 m; Elevation to Project Zero: 4.19492 m; Elevation to 1st Reference Level: 4.19492 m; Elevation to 2nd Reference Level: 4.19492 m; Elevation to Sea Level: 13.5349 m; Elevation to Linked/Home Story: 4.19492 m; Home Offset: 4.19492 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25242 m; Top Elevation To Home Story: 4.25242 m; Top Elevation To Project Zero: 4.25242 m; Top Elevation To Sea Level: 13.5924 m; Top Elevation To Second Reference Level: 4.25242 m; Bottom Elevation To First Reference Level: 4.19492 m; Bottom Elevation To Home Story: 4.19492 m; Bottom Elevation To Project Zero: 4.19492 m; Bottom Elevation To Sea Level: 13.5349 m; Bottom Elevation To Second Reference Level: 4.19492 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.5349 m; Top Surface Area (Net): 0.0147983 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1549 - Dimension 1: 0.15015 m; Dimension 2: 0.0985568 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0985568 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1549; Hotlink and Element ID: Object_1549; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1549; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1549; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_155, Object_155
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.4446 deg; Surface: Brick - Aged Natural; Element ID: Object_155; Hotlink and Element ID: Object_155; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_155; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_155; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_155 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_155_; 109.AMB.CodiTipus: Object_155; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.206945 m; Area: 0.0231358 m2; Height: 0.06 m; Volume (Net): 0.000601882 m3; Width: 0.111797 m; Elevation to Project Zero: 4.3098 m; Elevation to 1st Reference Level: 4.3098 m; Elevation to 2nd Reference Level: 4.3098 m; Elevation to Sea Level: 13.6498 m; Elevation to Linked/Home Story: 4.3098 m; Home Offset: 4.3098 m; Surface Area: 0.0491345 m2; Top Elevation To First Reference Level: 4.3698 m; Top Elevation To Home Story: 4.3698 m; Top Elevation To Project Zero: 4.3698 m; Top Elevation To Sea Level: 13.7098 m; Top Elevation To Second Reference Level: 4.3698 m; Bottom Elevation To First Reference Level: 4.3098 m; Bottom Elevation To Home Story: 4.3098 m; Bottom Elevation To Project Zero: 4.3098 m; Bottom Elevation To Sea Level: 13.6498 m; Bottom Elevation To Second Reference Level: 4.3098 m; Survey Coordinate X: 426569 m; Survey Coordinate Y: 4579787 m; Survey Coordinate Z: 13.6498 m; Top Surface Area (Net): 0.0231358 m2; Bottom Surface Area (Net): 0.0491345 m2
AC_Equantity_Rhino_Object_155 - Dimension 1: 0.206945 m; Dimension 2: 0.111797 m; Height: 0.06 m; Bottom Level: 0 m; Top Level: 0.06 m
5 AMB.Geometria - 502.AMB.Amplada: 0.111797 m; 503.AMB.Altura: 0.06 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000601882 m3; Component, Component Volume (Gross): 0.000601882 m3

# IfcBuildingElementProxy: Rhino_Object_1550, Object_1550
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1550; Hotlink and Element ID: Object_1550; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1550; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1550; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1550 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1550_; 109.AMB.CodiTipus: Object_1550; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.10463 m; Area: 0.00898444 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0858688 m; Elevation to Project Zero: 3.97018 m; Elevation to 1st Reference Level: 3.97018 m; Elevation to 2nd Reference Level: 3.97018 m; Elevation to Sea Level: 13.3102 m; Elevation to Linked/Home Story: 3.97018 m; Home Offset: 3.97018 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19492 m; Top Elevation To Home Story: 4.19492 m; Top Elevation To Project Zero: 4.19492 m; Top Elevation To Sea Level: 13.5349 m; Top Elevation To Second Reference Level: 4.19492 m; Bottom Elevation To First Reference Level: 3.97018 m; Bottom Elevation To Home Story: 3.97018 m; Bottom Elevation To Project Zero: 3.97018 m; Bottom Elevation To Sea Level: 13.3102 m; Bottom Elevation To Second Reference Level: 3.97018 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.3102 m; Top Surface Area (Net): 0.00898444 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1550 - Dimension 1: 0.10463 m; Dimension 2: 0.0858688 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0858688 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3

# IfcBuildingElementProxy: Rhino_Object_1551, Object_1551
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1551; Hotlink and Element ID: Object_1551; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1551; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1551; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1551 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1551_; 109.AMB.CodiTipus: Object_1551; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147744 m; Area: 0.00866213 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0586292 m; Elevation to Project Zero: 3.92949 m; Elevation to 1st Reference Level: 3.92949 m; Elevation to 2nd Reference Level: 3.92949 m; Elevation to Sea Level: 13.2695 m; Elevation to Linked/Home Story: 3.92949 m; Home Offset: 3.92949 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97018 m; Top Elevation To Home Story: 3.97018 m; Top Elevation To Project Zero: 3.97018 m; Top Elevation To Sea Level: 13.3102 m; Top Elevation To Second Reference Level: 3.97018 m; Bottom Elevation To First Reference Level: 3.92949 m; Bottom Elevation To Home Story: 3.92949 m; Bottom Elevation To Project Zero: 3.92949 m; Bottom Elevation To Sea Level: 13.2695 m; Bottom Elevation To Second Reference Level: 3.92949 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.2695 m; Top Surface Area (Net): 0.00866213 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1551 - Dimension 1: 0.147744 m; Dimension 2: 0.0586292 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0586292 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00

# IfcBuildingElementProxy: Rhino_Object_1552, Object_1552
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1552; Hotlink and Element ID: Object_1552; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1552; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1552; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1552 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1552_; 109.AMB.CodiTipus: Object_1552; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.0941367 m; Area: 0.00334263 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0355082 m; Elevation to Project Zero: 3.87199 m; Elevation to 1st Reference Level: 3.87199 m; Elevation to 2nd Reference Level: 3.87199 m; Elevation to Sea Level: 13.212 m; Elevation to Linked/Home Story: 3.87199 m; Home Offset: 3.87199 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92949 m; Top Elevation To Home Story: 3.92949 m; Top Elevation To Project Zero: 3.92949 m; Top Elevation To Sea Level: 13.2695 m; Top Elevation To Second Reference Level: 3.92949 m; Bottom Elevation To First Reference Level: 3.87199 m; Bottom Elevation To Home Story: 3.87199 m; Bottom Elevation To Project Zero: 3.87199 m; Bottom Elevation To Sea Level: 13.212 m; Bottom Elevation To Second Reference Level: 3.87199 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.212 m; Top Surface Area (Net): 0.00334263 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1552 - Dimension 1: 0.0941367 m; Dimension 2: 0.0355082 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0355082 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1553, Object_1553
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1553; Hotlink and Element ID: Object_1553; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1553; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1553; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1553 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1553_; 109.AMB.CodiTipus: Object_1553; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216263 m; Area: 0.0243264 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112485 m; Elevation to Project Zero: 4.25242 m; Elevation to 1st Reference Level: 4.25242 m; Elevation to 2nd Reference Level: 4.25242 m; Elevation to Sea Level: 13.5924 m; Elevation to Linked/Home Story: 4.25242 m; Home Offset: 4.25242 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30992 m; Top Elevation To Home Story: 4.30992 m; Top Elevation To Project Zero: 4.30992 m; Top Elevation To Sea Level: 13.6499 m; Top Elevation To Second Reference Level: 4.30992 m; Bottom Elevation To First Reference Level: 4.25242 m; Bottom Elevation To Home Story: 4.25242 m; Bottom Elevation To Project Zero: 4.25242 m; Bottom Elevation To Sea Level: 13.5924 m; Bottom Elevation To Second Reference Level: 4.25242 m; Survey Coordinate X: 426573 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.5924 m; Top Surface Area (Net): 0.0243264 m2; Bottom Surface Area (Net): 0.0778487 m2
AC_Equantity_Rhino_Object_1553 - Dimension 1: 0.216263 m; Dimension 2: 0.112485 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.112485 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1554, Object_1554
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1554 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1554; Hotlink and Element ID: Object_1554; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1554; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1554; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1554_; 109.AMB.CodiTipus: Object_1554; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15015 m; Area: 0.0147983 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.0985568 m; Elevation to Project Zero: 4.19492 m; Elevation to 1st Reference Level: 4.19492 m; Elevation to 2nd Reference Level: 4.19492 m; Elevation to Sea Level: 13.5349 m; Elevation to Linked/Home Story: 4.19492 m; Home Offset: 4.19492 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25242 m; Top Elevation To Home Story: 4.25242 m; Top Elevation To Project Zero: 4.25242 m; Top Elevation To Sea Level: 13.5924 m; Top Elevation To Second Reference Level: 4.25242 m; Bottom Elevation To First Reference Level: 4.19492 m; Bottom Elevation To Home Story: 4.19492 m; Bottom Elevation To Project Zero: 4.19492 m; Bottom Elevation To Sea Level: 13.5349 m; Bottom Elevation To Second Reference Level: 4.19492 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.5349 m; Top Surface Area (Net): 0.0147983 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1554 - Dimension 1: 0.15015 m; Dimension 2: 0.0985568 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0985568 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1555, Object_1555
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1555; Hotlink and Element ID: Object_1555; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1555; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1555; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1555 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.10463 m; Area: 0.00898444 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0858688 m; Elevation to Project Zero: 3.97018 m; Elevation to 1st Reference Level: 3.97018 m; Elevation to 2nd Reference Level: 3.97018 m; Elevation to Sea Level: 13.3102 m; Elevation to Linked/Home Story: 3.97018 m; Home Offset: 3.97018 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19492 m; Top Elevation To Home Story: 4.19492 m; Top Elevation To Project Zero: 4.19492 m; Top Elevation To Sea Level: 13.5349 m; Top Elevation To Second Reference Level: 4.19492 m; Bottom Elevation To First Reference Level: 3.97018 m; Bottom Elevation To Home Story: 3.97018 m; Bottom Elevation To Project Zero: 3.97018 m; Bottom Elevation To Sea Level: 13.3102 m; Bottom Elevation To Second Reference Level: 3.97018 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.3102 m; Top Surface Area (Net): 0.00898444 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1555 - Dimension 1: 0.10463 m; Dimension 2: 0.0858688 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0858688 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1555_; 109.AMB.CodiTipus: Object_1555; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1556, Object_1556
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1556; Hotlink and Element ID: Object_1556; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1556; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1556; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1556 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1556_; 109.AMB.CodiTipus: Object_1556; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147744 m; Area: 0.00866213 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0586292 m; Elevation to Project Zero: 3.92949 m; Elevation to 1st Reference Level: 3.92949 m; Elevation to 2nd Reference Level: 3.92949 m; Elevation to Sea Level: 13.2695 m; Elevation to Linked/Home Story: 3.92949 m; Home Offset: 3.92949 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97018 m; Top Elevation To Home Story: 3.97018 m; Top Elevation To Project Zero: 3.97018 m; Top Elevation To Sea Level: 13.3102 m; Top Elevation To Second Reference Level: 3.97018 m; Bottom Elevation To First Reference Level: 3.92949 m; Bottom Elevation To Home Story: 3.92949 m; Bottom Elevation To Project Zero: 3.92949 m; Bottom Elevation To Sea Level: 13.2695 m; Bottom Elevation To Second Reference Level: 3.92949 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.2695 m; Top Surface Area (Net): 0.00866213 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1556 - Dimension 1: 0.147744 m; Dimension 2: 0.0586292 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0586292 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3

# IfcBuildingElementProxy: Rhino_Object_1557, Object_1557
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1557; Hotlink and Element ID: Object_1557; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1557; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1557; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1557_; 109.AMB.CodiTipus: Object_1557; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941367 m; Area: 0.00334263 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0355082 m; Elevation to Project Zero: 3.87199 m; Elevation to 1st Reference Level: 3.87199 m; Elevation to 2nd Reference Level: 3.87199 m; Elevation to Sea Level: 13.212 m; Elevation to Linked/Home Story: 3.87199 m; Home Offset: 3.87199 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92949 m; Top Elevation To Home Story: 3.92949 m; Top Elevation To Project Zero: 3.92949 m; Top Elevation To Sea Level: 13.2695 m; Top Elevation To Second Reference Level: 3.92949 m; Bottom Elevation To First Reference Level: 3.87199 m; Bottom Elevation To Home Story: 3.87199 m; Bottom Elevation To Project Zero: 3.87199 m; Bottom Elevation To Sea Level: 13.212 m; Bottom Elevation To Second Reference Level: 3.87199 m; Survey Coordinate X: 426574 m; Survey Coordinate Y: 4579795 m; Survey Coordinate Z: 13.212 m; Top Surface Area (Net): 0.00334263 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1557 - Dimension 1: 0.0941367 m; Dimension 2: 0.0355082 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0355082 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
AC_Pset_Rhino_Object_1557 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg

# IfcBuildingElementProxy: Rhino_Object_1558, Object_1558
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.7081 deg; Surface: Brick - Aged Natural; Element ID: Object_1558; Hotlink and Element ID: Object_1558; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1558; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1558; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1558 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
