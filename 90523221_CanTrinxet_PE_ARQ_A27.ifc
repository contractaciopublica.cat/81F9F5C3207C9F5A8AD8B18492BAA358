Properties of the parts of a building model (IFC2X3), part 64 of 99

# IfcBuildingElementProxy: Rhino_Object_1703, Object_1703
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1703; Hotlink and Element ID: Object_1703; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1703; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1703; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1703 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1703_; 109.AMB.CodiTipus: Object_1703; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1703 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1704, Object_1704
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1704; Hotlink and Element ID: Object_1704; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1704; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1704; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1704 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1704_; 109.AMB.CodiTipus: Object_1704; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1704 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3

# IfcBuildingElementProxy: Rhino_Object_1705, Object_1705
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1705; Hotlink and Element ID: Object_1705; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1705; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1705; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1705 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1705_; 109.AMB.CodiTipus: Object_1705; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1705 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426552 m; Survey Coordinate Y: 4579789 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2

# IfcBuildingElementProxy: Rhino_Object_1706, Object_1706
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1706 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1706_; 109.AMB.CodiTipus: Object_1706; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
AC_Pset_Rhino_Object_1706 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1706; Hotlink and Element ID: Object_1706; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1706; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1706; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model

# IfcBuildingElementProxy: Rhino_Object_1707, Object_1707
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1707; Hotlink and Element ID: Object_1707; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1707; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1707; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1707 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1707_; 109.AMB.CodiTipus: Object_1707; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
AC_Equantity_Rhino_Object_1707 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m

# IfcBuildingElementProxy: Rhino_Object_1708, Object_1708
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1708; Hotlink and Element ID: Object_1708; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1708; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1708; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1708 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1708_; 109.AMB.CodiTipus: Object_1708; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
AC_Equantity_Rhino_Object_1708 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1709, Object_1709
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1709; Hotlink and Element ID: Object_1709; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1709; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1709; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1709 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1709_; 109.AMB.CodiTipus: Object_1709; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
AC_Equantity_Rhino_Object_1709 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3

# IfcBuildingElementProxy: Rhino_Object_1710, Object_1710
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1710; Hotlink and Element ID: Object_1710; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1710; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1710; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1710_; 109.AMB.CodiTipus: Object_1710; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Pset_Rhino_Object_1710 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426551 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
AC_Equantity_Rhino_Object_1710 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3

# IfcBuildingElementProxy: Rhino_Object_1711, Object_1711
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1711; Hotlink and Element ID: Object_1711; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1711; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1711; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1711 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1711_; 109.AMB.CodiTipus: Object_1711; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1711 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3

# IfcBuildingElementProxy: Rhino_Object_1712, Object_1712
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1712; Hotlink and Element ID: Object_1712; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1712; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1712; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1712_; 109.AMB.CodiTipus: Object_1712; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Pset_Rhino_Object_1712 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1712 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
Pset_BuildingElementProxyCommon - Status: EXISTING
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1713, Object_1713
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1713; Hotlink and Element ID: Object_1713; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1713; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1713; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1713 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1713_; 109.AMB.CodiTipus: Object_1713; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
ArchiCADQuantities - Length (A): 0.147831 m; Area: 0.0087113 m2; Height: 0.0406903 m; Volume (Net): 0.000295004 m3; Width: 0.0589275 m; Elevation to Project Zero: 3.92933 m; Elevation to 1st Reference Level: 3.92933 m; Elevation to 2nd Reference Level: 3.92933 m; Elevation to Sea Level: 13.2693 m; Elevation to Linked/Home Story: 3.92933 m; Home Offset: 3.92933 m; Surface Area: 0.0303692 m2; Top Elevation To First Reference Level: 3.97002 m; Top Elevation To Home Story: 3.97002 m; Top Elevation To Project Zero: 3.97002 m; Top Elevation To Sea Level: 13.31 m; Top Elevation To Second Reference Level: 3.97002 m; Bottom Elevation To First Reference Level: 3.92933 m; Bottom Elevation To Home Story: 3.92933 m; Bottom Elevation To Project Zero: 3.92933 m; Bottom Elevation To Sea Level: 13.2693 m; Bottom Elevation To Second Reference Level: 3.92933 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.2693 m; Top Surface Area (Net): 0.0087113 m2; Bottom Surface Area (Net): 0.0303692 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
5 AMB.Geometria - 502.AMB.Amplada: 0.0589275 m; 503.AMB.Altura: 0.0406903 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000295004 m3; Component, Component Volume (Gross): 0.000295004 m3
AC_Equantity_Rhino_Object_1713 - Dimension 1: 0.147831 m; Dimension 2: 0.0589275 m; Height: 0.0406903 m; Bottom Level: -3.24185e-14 m; Top Level: 0.0406903 m

# IfcBuildingElementProxy: Rhino_Object_1714, Object_1714
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1714; Hotlink and Element ID: Object_1714; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1714; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1714; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1714 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1714_; 109.AMB.CodiTipus: Object_1714; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
AC_Equantity_Rhino_Object_1714 - Dimension 1: 0.104785 m; Dimension 2: 0.0860687 m; Height: 0.224737 m; Bottom Level: 0 m; Top Level: 0.224737 m
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.104785 m; Area: 0.00901872 m2; Height: 0.224737 m; Volume (Net): 0.0017979 m3; Width: 0.0860687 m; Elevation to Project Zero: 3.97002 m; Elevation to 1st Reference Level: 3.97002 m; Elevation to 2nd Reference Level: 3.97002 m; Elevation to Sea Level: 13.31 m; Elevation to Linked/Home Story: 3.97002 m; Home Offset: 3.97002 m; Surface Area: 0.0969053 m2; Top Elevation To First Reference Level: 4.19475 m; Top Elevation To Home Story: 4.19475 m; Top Elevation To Project Zero: 4.19475 m; Top Elevation To Sea Level: 13.5348 m; Top Elevation To Second Reference Level: 4.19475 m; Bottom Elevation To First Reference Level: 3.97002 m; Bottom Elevation To Home Story: 3.97002 m; Bottom Elevation To Project Zero: 3.97002 m; Bottom Elevation To Sea Level: 13.31 m; Bottom Elevation To Second Reference Level: 3.97002 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.31 m; Top Surface Area (Net): 0.00901872 m2; Bottom Surface Area (Net): 0.0969053 m2
Component Quantities - Component, Component Volume (Net): 0.0017979 m3; Component, Component Volume (Gross): 0.0017979 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.0860687 m; 503.AMB.Altura: 0.224737 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1715, Object_1715
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1715 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1715; Hotlink and Element ID: Object_1715; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1715; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1715; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1715_; 109.AMB.CodiTipus: Object_1715; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
Pset_BuildingElementProxyCommon - Status: EXISTING
ArchiCADQuantities - Length (A): 0.15032 m; Area: 0.0148592 m2; Height: 0.0575 m; Volume (Net): 0.000750375 m3; Width: 0.09885 m; Elevation to Project Zero: 4.19475 m; Elevation to 1st Reference Level: 4.19475 m; Elevation to 2nd Reference Level: 4.19475 m; Elevation to Sea Level: 13.5348 m; Elevation to Linked/Home Story: 4.19475 m; Home Offset: 4.19475 m; Surface Area: 0.053125 m2; Top Elevation To First Reference Level: 4.25225 m; Top Elevation To Home Story: 4.25225 m; Top Elevation To Project Zero: 4.25225 m; Top Elevation To Sea Level: 13.5923 m; Top Elevation To Second Reference Level: 4.25225 m; Bottom Elevation To First Reference Level: 4.19475 m; Bottom Elevation To Home Story: 4.19475 m; Bottom Elevation To Project Zero: 4.19475 m; Bottom Elevation To Sea Level: 13.5348 m; Bottom Elevation To Second Reference Level: 4.19475 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.5348 m; Top Surface Area (Net): 0.0148592 m2; Bottom Surface Area (Net): 0.053125 m2
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
AC_Equantity_Rhino_Object_1715 - Dimension 1: 0.15032 m; Dimension 2: 0.09885 m; Height: 0.0575 m; Bottom Level: -3.19744e-14 m; Top Level: 0.0575 m
Component Quantities - Component, Component Volume (Net): 0.000750375 m3; Component, Component Volume (Gross): 0.000750375 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.09885 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m

# IfcBuildingElementProxy: Rhino_Object_1716, Object_1716
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
AC_Pset_Rhino_Object_1716 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1716; Hotlink and Element ID: Object_1716; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1716; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1716; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
Component Quantities - Component, Component Volume (Net): 0.00121113 m3; Component, Component Volume (Gross): 0.00121113 m3
5 AMB.Geometria - 502.AMB.Amplada: 0.112915 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
AC_Equantity_Rhino_Object_1716 - Dimension 1: 0.216446 m; Dimension 2: 0.112915 m; Height: 0.0575 m; Bottom Level: -6.65246e-12 m; Top Level: 0.0575 m
ArchiCADQuantities - Length (A): 0.216446 m; Area: 0.0244401 m2; Height: 0.0575 m; Volume (Net): 0.00121113 m3; Width: 0.112915 m; Elevation to Project Zero: 4.25225 m; Elevation to 1st Reference Level: 4.25225 m; Elevation to 2nd Reference Level: 4.25225 m; Elevation to Sea Level: 13.5923 m; Elevation to Linked/Home Story: 4.25225 m; Home Offset: 4.25225 m; Surface Area: 0.0778487 m2; Top Elevation To First Reference Level: 4.30975 m; Top Elevation To Home Story: 4.30975 m; Top Elevation To Project Zero: 4.30975 m; Top Elevation To Sea Level: 13.6498 m; Top Elevation To Second Reference Level: 4.30975 m; Bottom Elevation To First Reference Level: 4.25225 m; Bottom Elevation To Home Story: 4.25225 m; Bottom Elevation To Project Zero: 4.25225 m; Bottom Elevation To Sea Level: 13.5923 m; Bottom Elevation To Second Reference Level: 4.25225 m; Survey Coordinate X: 426549 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.5923 m; Top Surface Area (Net): 0.0244401 m2; Bottom Surface Area (Net): 0.0778487 m2
Pset_BuildingElementProxyCommon - Status: EXISTING
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1716_; 109.AMB.CodiTipus: Object_1716; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències

# IfcBuildingElementProxy: Rhino_Object_1717, Object_1717
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1717; Hotlink and Element ID: Object_1717; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1717; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1717; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
AC_Pset_Rhino_Object_1717 - Show 2D Hotspots in 3D: no; Contour Pen: 2D Elements - General; Fill Type: Air Space; Fill Pen: General - General; Fill Background Pen: Window Background; Show Face Edges (rh_show_edges_2d): no; Hotspots on Bounding Box: no; Overhead Fill Type: Air Space; Floor Plan Display ID: 1; Show Projection ID: 0; Overhead Lines: 21; Show Face Edges (rh_show_edges_3d): no; Smooth Edges: yes; Show Hotlines: yes; Surface: Rhino - 005; Cut Plane Projected: no; Import plugin id: Rhino In 26.0.0.6002 INT FULL; Edge Settings on UI: no; Segmentation Slider on UI: yes; UI Page ID: 1; Converted Smoothness: 4; Cost: 0; Group Type (FM_Type): Others; Group Type (iFMType): 25; Object Weight: 0; Object Weight Unit: kg
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÓ DE DIVERSES NAUS A CAN TRINXET, A L’HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: PE; 007.AMB.ModelDisciplina: ARQ; 008.AMB.Adreca: Carrer de Santa Eulàlia 212- 216, 08902 l’Hospitalet de Ll.; 009.AMB.Municipi: L’Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 arquitectos; 011.AMB.AutorProjecte2: L.Solsona; 012.AMB.AutorProjecte3: E.Fernàndez
GENERAL PROPERTIES - AUX_104.AMB.ClassificacioCodiCateg: 00
1 AMB.Identificacio - 103.AMB.Classificacio: 00.20 Preexistències; 104.AMB.ClassificacioCodi: 00.20; 105.AMB.ClassificacioDescripcio: Preexistències; 107.AMB.NomTipus: Object_1717_; 109.AMB.CodiTipus: Object_1717; 115.AMB.Nivell: planta baixa; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Preexistències; 120.AMB.FaseEnderroc: Preexistències
ArchiCADQuantities - Length (A): 0.0941878 m; Area: 0.00336239 m2; Height: 0.0575 m; Volume (Net): 0.000159562 m3; Width: 0.0356988 m; Elevation to Project Zero: 3.87183 m; Elevation to 1st Reference Level: 3.87183 m; Elevation to 2nd Reference Level: 3.87183 m; Elevation to Sea Level: 13.2118 m; Elevation to Linked/Home Story: 3.87183 m; Home Offset: 3.87183 m; Surface Area: 0.0196375 m2; Top Elevation To First Reference Level: 3.92933 m; Top Elevation To Home Story: 3.92933 m; Top Elevation To Project Zero: 3.92933 m; Top Elevation To Sea Level: 13.2693 m; Top Elevation To Second Reference Level: 3.92933 m; Bottom Elevation To First Reference Level: 3.87183 m; Bottom Elevation To Home Story: 3.87183 m; Bottom Elevation To Project Zero: 3.87183 m; Bottom Elevation To Sea Level: 13.2118 m; Bottom Elevation To Second Reference Level: 3.87183 m; Survey Coordinate X: 426550 m; Survey Coordinate Y: 4579788 m; Survey Coordinate Z: 13.2118 m; Top Surface Area (Net): 0.00336239 m2; Bottom Surface Area (Net): 0.0196375 m2
AC_Equantity_Rhino_Object_1717 - Dimension 1: 0.0941878 m; Dimension 2: 0.0356988 m; Height: 0.0575 m; Bottom Level: 0 m; Top Level: 0.0575 m
5 AMB.Geometria - 502.AMB.Amplada: 0.0356988 m; 503.AMB.Altura: 0.0575 m; 506.AMB.Profunditat: 0 m
Component Quantities - Component, Component Volume (Net): 0.000159562 m3; Component, Component Volume (Gross): 0.000159562 m3
Pset_BuildingElementProxyCommon - Status: EXISTING

# IfcBuildingElementProxy: Rhino_Object_1718, Object_1718
In: planta baixa
Classification: 00.20 Preexistències (GuBIMclass CA)
ArchiCADProperties - Rotation Angle: 13.5297 deg; Surface: Brick - Aged Natural; Element ID: Object_1718; Hotlink and Element ID: Object_1718; Layer: 00_ORNAMENTOS; Library Part Name: Rhino_Object_1718; Building Material / Composite / Profile / Fill: Background; Fill Type: Background; Colliding Zones: Espai públic; Nau Santa Eulàlia; Locked: no; Home Story Name: planta baixa; Home Story Number: 0; Element Type: Object; Parent ID: Object_1718; Surfaces (All): Brick - Aged Natural; Design Option Name: Main Model; Design Option Set Name: Main Model; Position: Undefined; Renovation Status: Existing; Structural Function: Undefined; Show On Renovation Filter: All Relevant Filters; Design Option Status: Main Model; Design Option Set: Main Model
