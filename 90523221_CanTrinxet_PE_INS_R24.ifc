Properties of the parts of a building model (IFC2X3), part 6 of 10

# IfcFlowFitting: L3J_COLZE_SOLDAT:COLZE_FRIGORÍFIQUES (177)
Name (L3J_COLZE_SOLDAT:COLZE_FRIGORÍFIQUES:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
4949251 | L3J_3_CALEF_RET | Nau Lateral Sud | 10 mmø-10 mmø | 0.00000644035 | L3J_3_CALEF_RET 17
4949373 | L3J_3_CALEF_RET | Nau Lateral Sud | 10 mmø-10 mmø | 0.00000644035 | L3J_3_CALEF_RET 17
4949397 | L3J_3_CALEF_RET | Nau Lateral Sud | 10 mmø-10 mmø | 0.00000644035 | L3J_3_CALEF_RET 17
4949433 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 23
4949646 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 23
4949904 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000400256 | L3J_3_CALEF_IMP 23
4949906 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 23
4949967 | L3J_3_CALEF_RET | Nau Lateral Sud | 10 mmø-10 mmø | 0.00000641669 | L3J_3_CALEF_RET 17
4949974 | L3J_3_CALEF_RET | Nau Lateral Sud | 10 mmø-10 mmø | 0.00000644068 | L3J_3_CALEF_RET 17
4950149 | L3J_3_CALEF_IMP | Nau Lateral Sud | 16 mmø-16 mmø | 0.0000139784 | L3J_3_CALEF_IMP 25
4950151 | L3J_3_CALEF_IMP | Nau Lateral Sud | 16 mmø-16 mmø | 0.0000139784 | L3J_3_CALEF_IMP 25
4950185 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 24
4950187 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 24
4950308 | L3J_3_CALEF_IMP | Nau Lateral Sud | 16 mmø-16 mmø | 0.0000139784 | L3J_3_CALEF_IMP 25
4950587 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 24; L3J_3_CALEF_RET 19
4950591 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 24
4950601 | L3J_3_CALEF_IMP | Nau Lateral Sud | 13 mmø-13 mmø | 0.00000973089 | L3J_3_CALEF_IMP 25

# IfcFlowFitting: L3J_CREU:GENERIC, L3J_CREU:GENERIC:3821437
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: ELE
Classification: 50.20.20.20 Uniformat (Uniformat); Group: L3J_4_SAN_FECAL 3
Pset_DistributionFlowElementCommon - Reference: L3J_CREU:GENERIC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: GENERIC; 112.AMB.Servei: L3J_4_SAN_FECAL; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 200 mmø-200 mmø-200 mmø-200 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.0253546 m3

# IfcFlowFitting: L3J_TE:GENERIC (13)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM-PEX
Classification: 50.10.20.30 Uniformat (Uniformat); Group: L3J_2_AFS 1
Pset_DistributionFlowElementCommon - Reference: L3J_TE:GENERIC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: GENERIC; 112.AMB.Servei: L3J_2_AFS; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (L3J_TE:GENERIC:...) | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3)
2976404 | Nau Santa Eulalia | 25 mmø-25 mmø-25 mmø | 0.0000441423
3019940 | Nau Santa Eulalia | 16 mmø-16 mmø-16 mmø | 0.0000169575
3769793 | Nau Santa Eulalia | 20 mmø-20 mmø-20 mmø | 0.0000240538
3991555 | Nau Santa Eulalia | 16 mmø-16 mmø-16 mmø | 0.0000169575
3991753 | Nau Santa Eulalia | 20 mmø-20 mmø-20 mmø | 0.0000240538
3993844 | Nau Santa Eulalia | 20 mmø-20 mmø-20 mmø | 0.0000240538
4011830 | Nau Santa Eulalia | 25 mmø-25 mmø-25 mmø | 0.0000441423
4059591 | Nau Santa Eulalia | 20 mmø-20 mmø-20 mmø | 0.0000240538
4059679 | Nau Santa Eulalia | 25 mmø-25 mmø-25 mmø | 0.0000441423
4060368 | Nau Santa Eulalia | 25 mmø-25 mmø-25 mmø | 0.0000441423
4064706 | Annex | 25 mmø-25 mmø-25 mmø | 0.0000441423
4065302 | Annex | 20 mmø-20 mmø-20 mmø | 0.0000240538
5117439 | Nau Santa Eulalia | 20 mmø-20 mmø-20 mmø | 0.0000240538

# IfcFlowFitting: L3J_TE:GENERIC_BIES, L3J_TE:GENERIC_BIES:3904548
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.50; 105.AMB.ClassificacioDescripcio: Canalitzacions d'extinció d'incendis; 109.AMB.CodiTipus: PCI-CBIE
Classification: 50.50.10.50 Uniformat (Uniformat); Group: L3J_6_PCI - HUMIDA 3
Pset_DistributionFlowElementCommon - Reference: L3J_TE:GENERIC_BIES; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: GENERIC_BIES; 112.AMB.Servei: L3J_6_PCI - HUMIDA; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 40 mmø-40 mmø-40 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000110376 m3

# IfcFlowFitting: L3J_TRANSICIO:FONTANERIA_AFS (35)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM-PEX
Classification: 50.10.20.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_TRANSICIO:FONTANERIA_AFS; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: FONTANERIA_AFS; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (L3J_TRANSICIO:FONTANERIA_AFS:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3349338 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-16 mmø | 0.00085321 | 0.00000322346 | L3J_2_AFS 1
3349340 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-16 mmø | 0.00085321 | 0.00000322346 | L3J_2_AFS 1
3356023 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-20 mmø | 0.000934648 | 0.00000362261 | L3J_2_AFS 1
3356059 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-20 mmø | 0.000934648 | 0.00000362261 | L3J_2_AFS 1
3356061 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-20 mmø | 0.000934648 | 0.00000362261 | L3J_2_AFS 1
3356067 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-20 mmø | 0.000934648 | 0.00000362261 | L3J_2_AFS 1
3356069 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-20 mmø | 0.000934648 | 0.00000362261 | L3J_2_AFS 1
3985687 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-20 mmø | 0.00103808 | 0.00000416093 | L3J_2_AFS 1
4009657 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-25 mmø | 0.00120135 | 0.00000518906 | L3J_2_AFS 1
4009892 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-25 mmø | 0.00120135 | 0.00000519137 | L3J_2_AFS 1
4012177 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-25 mmø | 0.00120131 | 0.00000518906 | L3J_2_AFS 1
4012179 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-25 mmø | 0.00120135 | 0.00000518906 | L3J_2_AFS 1
4013151 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-25 mmø | 0.00120135 | 0.00000518906 | L3J_2_AFS 1
4013359 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-16 mmø | 0.000597971 | 0.00000185568 | L3J_2_AFS 1
4013361 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø-16 mmø | 0.000598087 | 0.00000185568 | L3J_2_ACS 1
4013363 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-20 mmø | 0.00103808 | 0.00000416093 | L3J_2_AFS 1
4013397 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-16 mmø | 0.00095678 | 0.00000372424 | L3J_2_AFS 1
4058562 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-20 mmø | 0.00103808 | 0.00000414798 | L3J_2_AFS 1
4058892 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-25 mmø | 0.00120135 | 0.00000518906 | L3J_2_AFS 1
4058894 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-25 mmø | 0.00120135 | 0.00000518906 | L3J_2_AFS 1
4059523 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-16 mmø | 0.000597935 | 0.00000184965 | L3J_2_AFS 1
4059643 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-25 mmø | 0.00120135 | 0.00000518906 | L3J_2_AFS 1
4060906 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-16 mmø | 0.000597935 | 0.00000185568 | L3J_2_AFS 1
4060908 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø-16 mmø | 0.000597935 | 0.00000185568 | L3J_2_ACS 2
4061062 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-16 mmø | 0.00095678 | 0.00000372424 | L3J_2_AFS 1
4061469 | L3J_2_AFS | Nau Santa Eulalia | 27 mmø-25 mmø | 0.00120135 | 0.00000519137 | L3J_2_AFS 1
4064605 | L3J_2_AFS | Annex | 32 mmø-27 mmø | 0.00153015 | 0.00000730874 | L3J_2_AFS 1
4065304 | L3J_2_AFS | Annex | 20 mmø-16 mmø | 0.000597935 | 0.00000184965 | L3J_2_AFS 1
4065353 | L3J_2_AFS | Annex | 20 mmø-16 mmø | 0.000597935 | 0.00000185568 | L3J_2_AFS 1
4065747 | L3J_2_AFS | Annex | 27 mmø-20 mmø | 0.00103808 | 0.00000414798 | L3J_2_AFS 1
4065815 | L3J_2_AFS | Annex | 27 mmø-20 mmø | 0.00103808 | 0.00000414798 | L3J_2_AFS 1
4066094 | L3J_2_AFS | Annex | 27 mmø-25 mmø | 0.00120579 | 0.00000518906 | L3J_2_AFS 1
4066096 | L3J_2_AFS | Annex | 25 mmø-20 mmø | 0.000934648 | 0.00000362261 | L3J_2_AFS 1
4066098 | L3J_2_AFS | Annex | 27 mmø-25 mmø | 0.00120135 | 0.00000518906 | L3J_2_AFS 1
4066100 | L3J_2_AFS | Annex | 27 mmø-25 mmø | 0.00120135 | 0.00000518906 | L3J_2_AFS 1

# IfcFlowFitting: L3J_TRANSICIO_SOLDADA:CLIMA_REDUCTOR_FRIGORÍFIQUES (27)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.10; 105.AMB.ClassificacioDescripcio: Línies frigorífiques; 109.AMB.CodiTipus: CLI-TCRA
Classification: 50.30.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_TRANSICIO_SOLDADA:CLIMA_REDUCTOR_FRIGORÍFIQUES; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: CLIMA_REDUCTOR_FRIGORÍFIQUES; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (L3J_TRANSICIO_SOLDADA:CLIMA_REDUCTOR_FRIGORÍFIQUES:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3718486 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 49 mmø-46 mmø | 0.00519531 | 0.000049888 | L3J_3_CALEF_IMP 8
3718602 | L3J_3_CALEF_RET | Nau Santa Eulalia | 59 mmø-56 mmø | 0.00520225 | 0.0000499971 | L3J_3_CALEF_RET 3
3718771 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 39 mmø-30 mmø | 0.00441681 | 0.0000395027 | L3J_3_CALEF_IMP 10
3719698 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 59 mmø-56 mmø | 0.00519416 | 0.0000499275 | L3J_3_CALEF_IMP 11
3727119 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 42 mmø-30 mmø | 0.00492133 | 0.0000460342 | L3J_3_CALEF_IMP 18
3728336 | L3J_3_CALEF_RET | Nau Santa Eulalia | 59 mmø-56 mmø | 0.00520225 | 0.0000499971 | L3J_3_CALEF_RET 16
3728573 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 59 mmø-56 mmø | 0.00519416 | 0.0000499275 | L3J_3_CALEF_IMP 17
3729704 | L3J_3_CALEF_RET | Nau Santa Eulalia | 36 mmø-33 mmø | 0.00431081 | 0.0000382832 | L3J_3_CALEF_RET 2
3729706 | L3J_3_CALEF_RET | Nau Santa Eulalia | 36 mmø-33 mmø | 0.00431081 | 0.0000382832 | L3J_3_CALEF_RET 2
3734703 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-26 mmø | 0.00310845 | 0.0000242324 | L3J_3_CALEF_IMP 2
3734705 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-26 mmø | 0.00310845 | 0.0000242324 | L3J_3_CALEF_IMP 2
3734707 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-26 mmø | 0.00310845 | 0.0000242324 | L3J_3_CALEF_IMP 2
3743008 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 30 mmø-26 mmø | 0.00273951 | 0.0000205483 | L3J_3_CALEF_IMP 4
3743013 | L3J_3_CALEF_RET | Nau Santa Eulalia | 36 mmø-33 mmø | 0.00431081 | 0.0000382832 | L3J_3_CALEF_RET 4
3746539 | L3J_3_CALEF_RET | Nau Santa Eulalia | 43 mmø-40 mmø | 0.00346821 | 0.0000282001 | L3J_3_CALEF_RET 6
3755665 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-26 mmø | 0.00310845 | 0.0000242324 | L3J_3_CALEF_IMP 1
3755669 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-26 mmø | 0.00310845 | 0.0000242324 | L3J_3_CALEF_IMP 1
3756865 | L3J_3_CALEF_RET | Nau Santa Eulalia | 36 mmø-33 mmø | 0.00431081 | 0.0000382832 | L3J_3_CALEF_RET 1
3756867 | L3J_3_CALEF_RET | Nau Santa Eulalia | 36 mmø-33 mmø | 0.00431081 | 0.0000382832 | L3J_3_CALEF_RET 1
3756869 | L3J_3_CALEF_RET | Nau Santa Eulalia | 36 mmø-33 mmø | 0.00431081 | 0.0000382832 | L3J_3_CALEF_RET 1
4948561 | L3J_3_CALEF_RET | Nau Lateral Sud | 16 mmø-13 mmø | 0.00431081 | 0.0000382832 | L3J_3_CALEF_RET 15
4948564 | L3J_3_CALEF_IMP | Nau Lateral Sud | 10 mmø-6 mmø | 0.00267298 | 0.0000199116 | L3J_3_CALEF_IMP 22
4949862 | L3J_3_CALEF_IMP | Nau Lateral Sud | 10 mmø-6 mmø | 0.00273947 | 0.0000205483 | L3J_3_CALEF_IMP 23
4949985 | L3J_3_CALEF_RET | Nau Lateral Sud | 13 mmø-10 mmø | 0.00346592 | 0.0000280825 | L3J_3_CALEF_RET 17
4949987 | L3J_3_CALEF_RET | Nau Lateral Sud | 16 mmø-10 mmø | 0.00393285 | 0.0000336359 | L3J_3_CALEF_RET 17
4950124 | L3J_3_CALEF_IMP | Nau Lateral Sud | 16 mmø-10 mmø | 0.00393519 | 0.0000335424 | L3J_3_CALEF_RET 18; L3J_3_CALEF_IMP 25
4950603 | L3J_3_CALEF_IMP | Nau Lateral Sud | 16 mmø-13 mmø | 0.00431081 | 0.0000382832 | L3J_3_CALEF_IMP 25

# IfcFlowFitting: M_Codo - PVC - Serie 40:COLZE_SANEJAMENT_RESIDUAL_POLIPROPILE (19)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN-PPR
Classification: 50.20.20.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo - PVC - Serie 40:COLZE_SANEJAMENT_RESIDUAL_POLIPROPILE; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: COLZE_SANEJAMENT_RESIDUAL_POLIPROPILE; 112.AMB.Servei: L3J_4_SAN_FECAL; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
Name (M_Codo - PVC - Serie 40:COLZE_SANEJAMENT_RESIDUAL_POLIPROPILE:...) | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3664467 | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 1 (2)
3664471 | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 1 (2)
3669851 | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 1 (2)
3669855 | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 1 (2)
3670160 | 25 mmø-25 mmø | 0.000100996 | L3J_4_SAN_FECAL 1 (2)
3670557 | 32 mmø-32 mmø | 0.000212092 | L3J_4_SAN_FECAL 1 (2)
3670618 | 32 mmø-32 mmø | 0.000211561 | L3J_4_SAN_FECAL 1 (2)
3670620 | 32 mmø-32 mmø | 0.000211561 | L3J_4_SAN_FECAL 1 (2)
3671178 | 50 mmø-50 mmø | 0.000415116 | L3J_4_SAN_FECAL 1 (2)
3671571 | 50 mmø-50 mmø | 0.000414596 | L3J_4_SAN_FECAL 1 (2)
3672037 | 25 mmø-25 mmø | 0.0000980434 | L3J_4_SAN_FECAL 1 (2)
3672041 | 25 mmø-25 mmø | 0.000103228 | L3J_4_SAN_FECAL 1 (2)
4947978 | 25 mmø-25 mmø | 0.0000998835 | L3J_4_SAN_FECAL 1 (2)
4947989 | 25 mmø-25 mmø | 0.000103175 | L3J_4_SAN_FECAL 1 (2)
4948024 | 25 mmø-25 mmø | 0.0000994964 | L3J_4_SAN_FECAL 1 (2)
4948031 | 25 mmø-25 mmø | 0.0000996887 | L3J_4_SAN_FECAL 1 (2)
5208928 | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 1
5208937 | 25 mmø-25 mmø | 0.0000992284 | L3J_4_SAN_FECAL 1
5209410 | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 1

# IfcFlowFitting: M_Codo - PVC - Serie 40:COLZE_SANEJAMENT_RESIDUAL_PVC_SOTERRAT (146)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN-PVC
Classification: 50.20.20.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo - PVC - Serie 40:COLZE_SANEJAMENT_RESIDUAL_PVC_SOTERRAT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: COLZE_SANEJAMENT_RESIDUAL_PVC_SOTERRAT; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Codo - PVC - Serie 40:COLZE_SANEJAMENT_RESIDUAL_PVC_SOTERRAT:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
2969474 | L3J_4_SAN_FECAL | Annex | 40 mmø-40 mmø | 0.000289424 | L3J_4_SAN_FECAL 3
2974810 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.000415875 | L3J_4_SAN_FECAL 3
3255333 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000997046 | L3J_4_SAN_FECAL 3
3285840 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 3
3285941 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 3
3286012 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000997165 | L3J_4_SAN_FECAL 3
3287140 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 3
3455180 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 3
3455782 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 3
3490274 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 3
3490878 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000997673 | L3J_4_SAN_FECAL 3
3491982 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000997769 | L3J_4_SAN_FECAL 3
3493086 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 3
3658852 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 125 mmø-125 mmø | 0.0047075 | L3J_4_SAN_PLUVIAL 6
3658902 | L3J_4_SAN_PLUVIAL | Nau lateral | 125 mmø-125 mmø | 0.00398922 | L3J_4_SAN_PLUVIAL 6
3659324 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 110 mmø-110 mmø | 0.0028427 | L3J_4_SAN_PLUVIAL 6
3659343 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 110 mmø-110 mmø | 0.0033628 | L3J_4_SAN_PLUVIAL 6
3659873 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 110 mmø-110 mmø | 0.0033628 | L3J_4_SAN_PLUVIAL 6
3659877 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 110 mmø-110 mmø | 0.0033628 | L3J_4_SAN_PLUVIAL 6
3660769 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 90 mmø-90 mmø | 0.00168686 | L3J_4_SAN_PLUVIAL 6
3662613 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00398923 | L3J_4_SAN_PLUVIAL 6
3662617 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00398922 | L3J_4_SAN_PLUVIAL 6
3663056 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 90 mmø-90 mmø | 0.00168612 | L3J_4_SAN_PLUVIAL 6
3663063 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 90 mmø-90 mmø | 0.00199617 | L3J_4_SAN_PLUVIAL 6
3663292 | L3J_4_SAN_FECAL | Nau Lateral Sud | 50 mmø-50 mmø | 0.000414596 | L3J_4_SAN_FECAL 1 (2)
3663465 | L3J_4_SAN_FECAL | Nau Lateral Sud | 50 mmø-50 mmø | 0.000415867 | L3J_4_SAN_FECAL 1 (2)
3676953 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_FECAL 3
3676970 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.00335286 | L3J_4_SAN_FECAL 3
3678626 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 3
3679049 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.000100996 | L3J_4_SAN_FECAL 3
3679062 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000998426 | L3J_4_SAN_FECAL 3
3679066 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.000101219 | L3J_4_SAN_FECAL 3
3679227 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.000406063 | L3J_4_SAN_FECAL 3
3679883 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.000095435 | L3J_4_SAN_FECAL 3
3679897 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 3
3680293 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.000414596 | L3J_4_SAN_FECAL 3
3680295 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-90 mmø | 0.00199517 | L3J_4_SAN_FECAL 3
3682795 | L3J_4_SAN_FECAL | Annex | 125 mmø-125 mmø | 0.00398922 | L3J_4_SAN_FECAL 3
3682814 | L3J_4_SAN_FECAL | Annex | 125 mmø-125 mmø | 0.00398922 | L3J_4_SAN_FECAL 3
3683152 | L3J_4_SAN_FECAL | Annex | 40 mmø-40 mmø | 0.000288678 | L3J_4_SAN_FECAL 3
3683844 | L3J_4_SAN_FECAL | Capella | 125 mmø-125 mmø | 0.0047075 | L3J_4_SAN_FECAL 3
3683894 | L3J_4_SAN_FECAL | Capella | 90 mmø-90 mmø | 0.00168612 | L3J_4_SAN_FECAL 3
3683904 | L3J_4_SAN_FECAL | Capella | 90 mmø-90 mmø | 0.00168614 | L3J_4_SAN_FECAL 3
3683981 | L3J_4_SAN_FECAL | Capella | 90 mmø-90 mmø | 0.00198933 | L3J_4_SAN_FECAL 3
3683983 | L3J_4_SAN_FECAL | Annex | 40 mmø-40 mmø | 0.000288678 | L3J_4_SAN_FECAL 3
3684970 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.000413317 | L3J_4_SAN_FECAL 3
3684975 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-125 mmø | 0.00398923 | L3J_4_SAN_FECAL 3
3685624 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-90 mmø | 0.00168612 | L3J_4_SAN_FECAL 3
3686084 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-125 mmø | 0.00470741 | L3J_4_SAN_FECAL 3
3686131 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-90 mmø | 0.00168613 | L3J_4_SAN_FECAL 3
3686141 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-90 mmø | 0.00168613 | L3J_4_SAN_FECAL 3
3686188 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-90 mmø | 0.00198933 | L3J_4_SAN_FECAL 3
3686193 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.000415875 | L3J_4_SAN_FECAL 3
3686237 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.00284146 | L3J_4_SAN_FECAL 3
3686247 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.00284146 | L3J_4_SAN_FECAL 3
3686623 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.00284146 | L3J_4_SAN_FECAL 3
3686663 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.00335286 | L3J_4_SAN_FECAL 3
3687694 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.00335286 | L3J_4_SAN_FECAL 3
3690547 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-90 mmø | 0.00168613 | L3J_4_SAN_FECAL 3
3690673 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 40 mmø-40 mmø | 0.000287925 | L3J_4_SAN_FECAL 3
3690678 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-90 mmø | 0.00200077 | L3J_4_SAN_FECAL 3
3691421 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000994991 | L3J_4_SAN_FECAL 3
3691516 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.000103227 | L3J_4_SAN_FECAL 3
3691937 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000980452 | L3J_4_SAN_FECAL 3
3691942 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.000101013 | L3J_4_SAN_FECAL 3
3692661 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.000101429 | L3J_4_SAN_FECAL 3
3692665 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000992793 | L3J_4_SAN_FECAL 3
3694368 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.000414596 | L3J_4_SAN_FECAL 3
3694527 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 32 mmø-32 mmø | 0.000177504 | L3J_4_SAN_FECAL 3
3694698 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 32 mmø-32 mmø | 0.000211561 | L3J_4_SAN_FECAL 3
3695052 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 3
3765918 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 3
3765923 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 3
3765993 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 32 mmø-32 mmø | 0.00021156 | L3J_4_SAN_FECAL 3
3766570 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000996969 | L3J_4_SAN_FECAL 3
3766575 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.000101279 | L3J_4_SAN_FECAL 3
3766578 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.000101291 | L3J_4_SAN_FECAL 3
3767063 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000995953 | L3J_4_SAN_FECAL 3
3767073 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000997785 | L3J_4_SAN_FECAL 3
3767173 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.000099765 | L3J_4_SAN_FECAL 3
3767233 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000997658 | L3J_4_SAN_FECAL 3
3767510 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 3
3786085 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.000413317 | L3J_4_SAN_FECAL 3
3786090 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.000415875 | L3J_4_SAN_FECAL 3
3789247 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00398924 | L3J_4_SAN_PLUVIAL 8
3789286 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.00335286 | L3J_4_SAN_PLUVIAL 8
3824805 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00405366 | L3J_4_SAN_PLUVIAL 6
3824809 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00405458 | L3J_4_SAN_PLUVIAL 6
3825624 | L3J_4_SAN_PLUVIAL |  | 160 mmø-160 mmø | 0.0099401 | L3J_4_SAN_PLUVIAL 1
3826168 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_PLUVIAL 8
3826293 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00507127 | L3J_4_SAN_PLUVIAL 8
3826297 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00507127 | L3J_4_SAN_PLUVIAL 8
3868677 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000994992 | L3J_4_SAN_FECAL 3
3868688 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 3
3868690 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000994244 | L3J_4_SAN_FECAL 3
3905394 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.00335291 | L3J_4_SAN_PLUVIAL 8
4559378 | L3J_4_SAN_FECAL |  | 200 mmø-200 mmø | 0.0154146 | L3J_4_SAN_FECAL 3
4560530 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_FECAL 3
5051642 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 125 mmø-125 mmø | 0.0047075 | L3J_4_SAN_PLUVIAL 3
5051647 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_PLUVIAL 3
5052026 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.0033628 | L3J_4_SAN_PLUVIAL 3
5052149 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.0033628 | L3J_4_SAN_PLUVIAL 3
5052541 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 160 mmø-160 mmø | 0.00918369 | L3J_4_SAN_PLUVIAL 3
5056325 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.0033628 | L3J_4_SAN_PLUVIAL 3
5056330 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.0033628 | L3J_4_SAN_PLUVIAL 3
5056701 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.003352 | L3J_4_SAN_PLUVIAL 3
5056706 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_PLUVIAL 3
5059561 | L3J_4_SAN_FECAL |  | 160 mmø-160 mmø | 0.00778185 | L3J_4_SAN_FECAL 3
5059750 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_FECAL 3
5059757 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-125 mmø | 0.00470154 | L3J_4_SAN_FECAL 3
5059824 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_FECAL 3
5059859 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_FECAL 3
5059961 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.00398926 | L3J_4_SAN_FECAL 3
5060337 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_FECAL 3
5060431 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_FECAL 3
5061834 | L3J_4_SAN_FECAL |  | 200 mmø-200 mmø | 0.0154146 | L3J_4_SAN_FECAL 3
5110106 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 90 mmø-90 mmø | 0.00168612 | L3J_4_SAN_PLUVIAL 6
5117950 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.000407724 | L3J_4_SAN_FECAL 3
5117954 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.00041391 | L3J_4_SAN_FECAL 3
5209414 | L3J_4_SAN_FECAL | Nau Lateral Sud | 25 mmø-25 mmø | 0.00009977 | L3J_4_SAN_FECAL 1
5213151 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 110 mmø-110 mmø | 0.00335309 | L3J_4_SAN_PLUVIAL 3
5213157 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00404161 | L3J_4_SAN_PLUVIAL 3
5213410 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-50 mmø | 0.000413318 | L3J_4_SAN_FECAL 3
5213448 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_FECAL 3
5213506 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.0047075 | L3J_4_SAN_FECAL 3
5213729 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.0047075 | L3J_4_SAN_FECAL 3
5213832 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.0047075 | L3J_4_SAN_FECAL 3
5214018 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.0047075 | L3J_4_SAN_FECAL 3
5214152 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.0047075 | L3J_4_SAN_FECAL 3
5214480 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.0047075 | L3J_4_SAN_FECAL 3
5214535 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.00496125 | L3J_4_SAN_FECAL 3
5214604 | L3J_4_SAN_FECAL |  | 125 mmø-125 mmø | 0.0047075 | L3J_4_SAN_FECAL 3
5214777 | L3J_4_SAN_FECAL |  | 160 mmø-160 mmø | 0.00778188 | L3J_4_SAN_FECAL 3
5214851 | L3J_4_SAN_FECAL |  | 160 mmø-160 mmø | 0.00778185 | L3J_4_SAN_FECAL 3
5214890 | L3J_4_SAN_FECAL |  | 160 mmø-160 mmø | 0.00918165 | L3J_4_SAN_FECAL 3
5215005 | L3J_4_SAN_FECAL |  | 160 mmø-160 mmø | 0.00918359 | L3J_4_SAN_FECAL 3
5215126 | L3J_4_SAN_FECAL |  | 160 mmø-160 mmø | 0.00918369 | L3J_4_SAN_FECAL 3
5215200 | L3J_4_SAN_FECAL |  | 160 mmø-160 mmø | 0.00918369 | L3J_4_SAN_FECAL 3
5215291 | L3J_4_SAN_FECAL |  | 160 mmø-160 mmø | 0.00918371 | L3J_4_SAN_FECAL 3
5215383 | L3J_4_SAN_FECAL |  | 160 mmø-160 mmø | 0.00918369 | L3J_4_SAN_FECAL 3
5218132 | L3J_4_SAN_PLUVIAL | Nau lateral | 125 mmø-125 mmø | 0.00398925 | L3J_4_SAN_PLUVIAL 6
5218136 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.0050716 | L3J_4_SAN_PLUVIAL 6
5218822 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00402811 | L3J_4_SAN_PLUVIAL 6
5219578 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 110 mmø-110 mmø | 0.00360074 | L3J_4_SAN_PLUVIAL 6
5219588 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 110 mmø-110 mmø | 0.00360074 | L3J_4_SAN_PLUVIAL 6
5219592 | L3J_4_SAN_PLUVIAL |  | 125 mmø-125 mmø | 0.00470709 | L3J_4_SAN_PLUVIAL 6

# IfcFlowFitting: M_Codo horizontal de canal:Electricitat (5)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.30.10; 105.AMB.ClassificacioDescripcio: Safates de distribució elèctrica; 109.AMB.CodiTipus: ELE-SMR
Classification: 50.60.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo horizontal de canal:Electricitat; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Electricitat; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 504.AMB.Gruix: 0.00254 m
Name (M_Codo horizontal de canal:Electricitat:...) | 509.AMB.Volum (m3)
3239399 | 0.00671223
3240899 | 0.00671223
3246464 | 0.00671223
5167129 | 0.00435618
5167345 | 0.00435618

# IfcFlowFitting: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_AP (31)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_AP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CURVA_REC_CLIMA_FIBRA_AP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_AP:...) | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3459996 | Nau Santa Eulalia | 250 mmx200 mm-250 mmx200 mm | 0.00294366 | Mecánica L3J_3_VENT_APORT_AIRE 2
3460012 | Nau Santa Eulalia | 250 mmx200 mm-250 mmx200 mm | 0.00294372 | Mecánica L3J_3_VENT_APORT_AIRE 2
3471010 | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_VENT_APORT_AIRE 3
3471013 | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_VENT_APORT_AIRE 3
3471705 | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_VENT_APORT_AIRE 3
3471707 | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_VENT_APORT_AIRE 3
3482437 | Nau Santa Eulalia | 450 mmx150 mm-450 mmx150 mm | 0.0251328 | Mecánica L3J_3_VENT_APORT_AIRE 3
3485594 | Nau Santa Eulalia | 450 mmx150 mm-450 mmx150 mm | 0.0251328 | Mecánica L3J_3_VENT_APORT_AIRE 3
3486012 | Nau Santa Eulalia | 200 mmx150 mm-200 mmx150 mm | 0.0035341 | Mecánica L3J_3_VENT_APORT_AIRE 7
3514040 | Nau Santa Eulalia | 200 mmx200 mm-200 mmx200 mm | 0.00530115 | Mecánica L3J_3_VENT_APORT_AIRE 2
3514043 | Nau Santa Eulalia | 200 mmx200 mm-200 mmx200 mm | 0.00530115 | Mecánica L3J_3_VENT_APORT_AIRE 2
3515403 | Nau Santa Eulalia | 250 mmx200 mm-250 mmx200 mm | 0.00629527 | Mecánica L3J_3_VENT_APORT_AIRE 2
3515801 | Nau Santa Eulalia | 200 mmx250 mm-200 mmx250 mm | 0.00353435 | Mecánica L3J_3_VENT_APORT_AIRE 2
3515834 | Nau Santa Eulalia | 250 mmx200 mm-250 mmx200 mm | 0.00629475 | Mecánica L3J_3_VENT_APORT_AIRE 2
3515836 | Nau Santa Eulalia | 200 mmx250 mm-200 mmx250 mm | 0.00353435 | Mecánica L3J_3_VENT_APORT_AIRE 2
3528894 | Nau Lateral Sud | 350 mmx350 mm-350 mmx350 mm | 0.0424114 | Mecánica L3J_3_VENT_APORT_AIRE 1
3638440 | Nau Lateral Sud | 200 mmx250 mm-200 mmx250 mm | 0.00263737 | Mecánica L3J_3_VENT_APORT_AIRE 1
3638444 | Nau Lateral Sud | 200 mmx250 mm-200 mmx250 mm | 0.00263737 | Mecánica L3J_3_VENT_APORT_AIRE 1
3638603 | Nau Lateral Sud | 250 mmx200 mm-250 mmx200 mm | 0.00329996 | Mecánica L3J_3_VENT_APORT_AIRE 1
3639114 | Nau Lateral Sud | 250 mmx200 mm-250 mmx200 mm | 0.00612502 | Mecánica L3J_3_VENT_APORT_AIRE 1
3641788 | Nau Lateral Sud | 350 mmx350 mm-350 mmx350 mm | 0.0424114 | Mecánica L3J_3_VENT_APORT_AIRE 1
3641914 | Nau Lateral Sud | 200 mmx250 mm-200 mmx250 mm | 0.00706881 | Mecánica L3J_3_VENT_APORT_AIRE 1
3656930 | Nau Lateral Sud | 350 mmx250 mm-350 mmx250 mm | 0.0282628 | Mecánica L3J_3_VENT_APORT_AIRE 1
3716694 | Nau Santa Eulalia | 250 mmx400 mm-250 mmx400 mm | 0.0109955 | Mecánica L3J_3_VENT_APORT_AIRE 3
3717441 | Nau Santa Eulalia | 250 mmx400 mm-250 mmx400 mm | 0.0109955 | Mecánica L3J_3_VENT_APORT_AIRE 3
3722801 | Nau Santa Eulalia | 350 mmx350 mm-350 mmx350 mm | 0.0254987 | Mecánica L3J_3_VENT_APORT_AIRE 2
3758383 | Nau Santa Eulalia | 350 mmx350 mm-350 mmx350 mm | 0.0254985 | Mecánica L3J_3_VENT_APORT_AIRE 2
3764050 | Nau Santa Eulalia | 300 mmx250 mm-300 mmx250 mm | 0.0196348 | Mecánica L3J_3_VENT_APORT_AIRE 2
3868134 | Nau Santa Eulalia | 150 mmx200 mm-150 mmx200 mm | 0.00235613 | Mecánica L3J_3_VENT_APORT_AIRE 3
3868135 | Nau Santa Eulalia | 150 mmx200 mm-150 mmx200 mm | 0.00235613 | Mecánica L3J_3_VENT_APORT_AIRE 7
4541555 | Nau Lateral Sud | 350 mmx250 mm-350 mmx250 mm | 0.0281254 | Mecánica L3J_3_VENT_APORT_AIRE 1

# IfcFlowFitting: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_EXT (21)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CURVA_REC_CLIMA_FIBRA_EXT; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_EXT:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3163586 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx400 mm-150 mmx400 mm | 0.00549763 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3165194 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx350 mm-150 mmx350 mm | 0.00471226 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3256877 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx200 mm-150 mmx200 mm | 0.00235613 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3342404 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Lateral Sud | 250 mmx350 mm-250 mmx350 mm | 0.0188495 | Mechanical L3J_VENTILACIÓ_CTE_HS3 1
3446393 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx400 mm-150 mmx400 mm | 0.00549763 | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
3446432 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 350 mmx150 mm-350 mmx150 mm | 0.0141371 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3447715 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx350 mm-150 mmx350 mm | 0.000748741 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3447846 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx400 mm-150 mmx400 mm | 0.00462478 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3447955 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 350 mmx150 mm-350 mmx150 mm | 0.00598627 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3447956 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 350 mmx150 mm-350 mmx150 mm | 0.00598627 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3465680 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx300 mm-150 mmx300 mm | 0.00392688 | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
3465869 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 200 mmx150 mm-200 mmx150 mm | 0.0035341 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3466249 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx300 mm-150 mmx300 mm | 0.00392688 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3466467 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx300 mm-150 mmx300 mm | 0.00392688 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3466816 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx300 mm-150 mmx300 mm | 0.00392688 | Mecánica L3J_VENTILACIÓ_CTE_HS3 9
3876895 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Santa Eulalia | 150 mmx400 mm-150 mmx400 mm | 0.00549763 | Mecánica L3J_3_VENT_RETORN_AIRE 1; Mecánica L3J_VENTILACIÓ_CTE_HS3 14
4542128 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Lateral Sud | 200 mmx250 mm-200 mmx250 mm | 0.00706819 | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
4542481 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Lateral Sud | 250 mmx200 mm-250 mmx200 mm | 0.00930734 | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
4542700 | L3J_3_VENTILACIÓ_CTE_HS3 | Nau Lateral Sud | 200 mmx250 mm-200 mmx250 mm | 0.00706819 | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
4792847 | L3J_3_VENT_RETORN_AIRE | Nau Santa Eulalia | 400 mmx150 mm-400 mmx150 mm | 0.00962115 | Mecánica L3J_3_VENT_RETORN_AIRE 1
4792851 | L3J_3_VENT_RETORN_AIRE | Nau Santa Eulalia | 400 mmx150 mm-400 mmx150 mm | 0.00962115 | Mecánica L3J_3_VENT_RETORN_AIRE 1

# IfcFlowFitting: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_IMP (33)
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CURVA_REC_CLIMA_FIBRA_IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 119.AMB.FaseCreacio: Obra
Name (M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_IMP:...) | In | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3163972 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-350 mmx250 mm | 0.0282743 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3262619 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx200 mm-350 mmx200 mm | 0.0212057 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3431691 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx300 mm-200 mmx300 mm | 0.00140997 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3432065 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm-300 mmx200 mm | 0.0147261 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3438370 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx300 mm-150 mmx300 mm | 0.000623951 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3438416 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx300 mm-150 mmx300 mm | 0.000623951 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3438428 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm-300 mmx150 mm | 0.0098174 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3438429 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm-300 mmx150 mm | 0.0098174 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3438526 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm-300 mmx150 mm | 0.0098174 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3445611 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-350 mmx250 mm | 0.0282743 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3461629 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm-200 mmx200 mm | 0.00431171 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3461632 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm-200 mmx200 mm | 0.00431171 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3475136 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm-200 mmx200 mm | 0.00530115 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3475529 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm-200 mmx200 mm | 0.00165581 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3475540 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm-200 mmx200 mm | 0.00165581 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3483136 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-350 mmx250 mm | 0.0282743 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3483531 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-350 mmx250 mm | 0.0282743 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3483917 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx350 mm-250 mmx350 mm | 0.00942468 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3483921 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx350 mm-250 mmx350 mm | 0.00942468 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3655277 | PLANTA COBERTA | PLANTA COBERTA | Nau Lateral Sud | 350 mmx550 mm-350 mmx550 mm | 0.0251345 | Mecánica L3J_3_CLIMA_IMP_AIRE 10
3867432 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm-300 mmx200 mm | 0.0147261 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3867520 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm-300 mmx200 mm | 0.0147261 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3867705 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx300 mm-200 mmx300 mm | 0.00637161 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3867708 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx300 mm-200 mmx300 mm | 0.00637161 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
4954955 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx200 mm-450 mmx200 mm | 0.0377007 | Mecánica L3J_3_CLIMA_IMP_AIRE 11
4957059 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx450 mm-200 mmx450 mm | 0.0146177 | Mecánica L3J_3_CLIMA_IMP_AIRE 11
4957280 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx350 mm-250 mmx350 mm | 0.0188495 | Mecánica L3J_3_CLIMA_IMP_AIRE 8
4957284 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx350 mm-250 mmx350 mm | 0.0188495 | Mecánica L3J_3_CLIMA_IMP_AIRE 8
5251243 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx300 mm-250 mmx300 mm | 0.000206976 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
5251529 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx200 mm-350 mmx200 mm | 0.0212016 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
5253341 | PLANTA COBERTA | PLANTA COBERTA | Nau Lateral Sud | 350 mmx550 mm-350 mmx550 mm | 0.0251345 | Mecánica L3J_3_CLIMA_IMP_AIRE 10
5257811 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-350 mmx250 mm | 0.0282743 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
5257813 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx350 mm-250 mmx350 mm | 0.0186482 | Mecánica L3J_3_CLIMA_IMP_AIRE 6

# IfcFlowFitting: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_RET (42)
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.40 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_RET; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CURVA_REC_CLIMA_FIBRA_RET; 112.AMB.Servei: L3J_3_CLIMA_RET_AIRE; 119.AMB.FaseCreacio: Obra
Name (M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_FIBRA_RET:...) | In | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3143471 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 450 mmx150 mm-450 mmx150 mm | 0.0251328 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3147327 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 450 mmx150 mm-450 mmx150 mm | 0.0251328 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3147361 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3155820 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3163835 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3163923 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm-450 mmx150 mm | 0.0251328 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3164795 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx350 mm-200 mmx350 mm | 0.00530152 | Mecánica L3J_3_CLIMA_RET_AIRE 10
3259553 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3259570 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3259618 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3428076 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm-300 mmx200 mm | 0.0147261 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3445696 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx350 mm-200 mmx350 mm | 0.00530152 | Mecánica L3J_3_CLIMA_RET_AIRE 10
3447314 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx400 mm-150 mmx400 mm | 0.00462418 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3447322 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm-300 mmx200 mm | 0.0062357 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3447369 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx300 mm-200 mmx300 mm | 0.00140389 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3447371 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm-300 mmx200 mm | 0.0062357 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3479607 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3482223 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3485466 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3656695 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm-400 mmx300 mm | 0.0481766 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3656718 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm-400 mmx300 mm | 0.0482287 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3666571 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 300 mmx400 mm-300 mmx400 mm | 0.0343609 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3666917 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 300 mmx400 mm-300 mmx400 mm | 0.0343609 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3684231 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 300 mmx400 mm-300 mmx400 mm | 0.0343609 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3760801 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx600 mm-200 mmx600 mm | 0.0194375 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3760804 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx600 mm-200 mmx600 mm | 0.0194375 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3864928 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx400 mm-150 mmx400 mm | 0.00549763 | Mecánica L3J_3_CLIMA_RET_AIRE 11
3865789 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 10
3865792 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx200 mm-350 mmx200 mm | 0.0212057 | Mecánica L3J_3_CLIMA_RET_AIRE 10
3866887 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx250 mm-150 mmx250 mm | 0.00314151 | Mecánica L3J_3_CLIMA_RET_AIRE 6
3871830 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-350 mmx250 mm | 0.0282743 | Mecánica L3J_3_CLIMA_RET_AIRE 12
4541623 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 300 mmx400 mm-300 mmx400 mm | 0.0343609 | Mecánica L3J_3_CLIMA_RET_AIRE 1
4541690 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm-400 mmx300 mm | 0.0479753 | Mecánica L3J_3_CLIMA_RET_AIRE 1
4541818 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm-400 mmx300 mm | 0.0481056 | Mecánica L3J_3_CLIMA_RET_AIRE 1
4541900 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 300 mmx400 mm-300 mmx400 mm | 0.0343609 | Mecánica L3J_3_CLIMA_RET_AIRE 1
4792836 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm | 0.00628301 | Mecánica L3J_3_CLIMA_RET_AIRE 3
4792841 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm-450 mmx150 mm | 0.0125663 | Mecánica L3J_3_CLIMA_RET_AIRE 3
4792844 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm-450 mmx150 mm | 0.0125663 | Mecánica L3J_3_CLIMA_RET_AIRE 3
4954893 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx200 mm-450 mmx200 mm | 0.0376992 | Mecánica L3J_3_CLIMA_RET_AIRE 12
4956046 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx350 mm-250 mmx350 mm | 0.0188495 | Mecánica L3J_3_CLIMA_RET_AIRE 12
4956050 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx350 mm-250 mmx350 mm | 0.0188495 | Mecánica L3J_3_CLIMA_RET_AIRE 12
4956053 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-350 mmx250 mm | 0.0273132 | Mecánica L3J_3_CLIMA_RET_AIRE 12

# IfcFlowFitting: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_XAPA_AP (2)
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.10 Uniformat (Uniformat); Group: Mecánica L3J_3_VENT_APORT_AIRE 5
Pset_DistributionFlowElementCommon - Reference: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_XAPA_AP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CURVA_REC_CLIMA_XAPA_AP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 410 mmx410 mm-410 mmx410 mm
5 AMB.Geometria - 509.AMB.Volum: 0.0424114 m3
Name (M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_XAPA_AP:...)
3722139
3722760

# IfcFlowFitting: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_XAPA_EXT (11)
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_XAPA_EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CURVA_REC_CLIMA_XAPA_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 119.AMB.FaseCreacio: Obra
Name (M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_XAPA_EXT:...) | In | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3342266 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 410 mmx310 mm-410 mmx310 mm | 0.0282525 | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
3528455 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 310 mmx410 mm-310 mmx410 mm | 0.0188495 | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
3715070 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 200 mmx350 mm-200 mmx350 mm | 0.0219911 | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
3715146 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 300 mmx300 mm-300 mmx300 mm | 0.0424114 | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
3721642 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 410 mmx410 mm-410 mmx410 mm | 0.0424114 | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
3722505 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 410 mmx410 mm-410 mmx410 mm | 0.0424111 | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
3722509 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 410 mmx410 mm-410 mmx410 mm | 0.0424114 | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
3874266 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 310 mmx460 mm-310 mmx460 mm | 0.0219911 | Mecánica L3J_VENTILACIÓ_CTE_HS3 13
3874440 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 310 mmx460 mm-310 mmx460 mm | 0.0219911 | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
3874504 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 310 mmx460 mm-310 mmx460 mm | 0.0219911 | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
3874526 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 460 mmx310 mm-460 mmx310 mm | 0.0384777 | Mecánica L3J_VENTILACIÓ_CTE_HS3 5

# IfcFlowFitting: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_XAPA_IMP (5)
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.30 Uniformat (Uniformat); Group: Mecánica L3J_3_VENT_APORT_AIRE 6
Pset_DistributionFlowElementCommon - Reference: M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_XAPA_IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CURVA_REC_CLIMA_XAPA_IMP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
Name (M_Codo rectangular - Radio:L3J_CURVA_REC_CLIMA_XAPA_IMP:...) | 242.AMB.Mida | 509.AMB.Volum (m3)
3715433 | 310 mmx460 mm-310 mmx460 mm | 0.0219911
3716948 | 460 mmx310 mm-460 mmx310 mm | 0.0291216
3717100 | 310 mmx460 mm-310 mmx460 mm | 0.0219911
3717138 | 460 mmx310 mm-460 mmx310 mm | 0.038495
3717140 | 460 mmx310 mm-460 mmx310 mm | 0.0291136

# IfcFlowFitting: M_Codo redondo:L3J_CODO_CIRC_EXT (10)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo redondo:L3J_CODO_CIRC_EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CODO_CIRC_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 100 mmø-100 mmø
Name (M_Codo redondo:L3J_CODO_CIRC_EXT:...) | 117.AMB.Localitzacio | 509.AMB.Volum (m3) | Group
3020633 | Nau Santa Eulalia | 0.00185049 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
3306803 | Nau Santa Eulalia | 0.00185049 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
3770835 | Nau Santa Eulalia | 0.00185049 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3771315 | Nau Santa Eulalia | 0.000925234 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
3771582 | Nau Santa Eulalia | 0.00185049 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3771683 | Nau Santa Eulalia | 0.000925234 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
3771810 | Nau Santa Eulalia | 0.00185049 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
4968915 | Nau Santa Eulalia | 0.00185049 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
4968917 | Nau Santa Eulalia | 0.00185049 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
4968959 | Annex | 0.00185049 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1

# IfcFlowFitting: M_Codo vertical exterior de canal:Norma (3)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.30.10; 105.AMB.ClassificacioDescripcio: Safates de distribució elèctrica; 109.AMB.CodiTipus: ELE-SMR
Classification: 50.60.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo vertical exterior de canal:Norma; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Norma; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 504.AMB.Gruix: 0.00254 m
Name (M_Codo vertical exterior de canal:Norma:...) | 509.AMB.Volum (m3)
3246497 | 0.00561795
5167346 | 0.00561795
5167733 | 0.0051066

# IfcFlowFitting: M_Codo vertical interior de canal:Norma (5)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.30.10; 105.AMB.ClassificacioDescripcio: Safates de distribució elèctrica; 109.AMB.CodiTipus: ELE-SMR
Classification: 50.60.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Codo vertical interior de canal:Norma; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Norma; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 504.AMB.Gruix: 0.00254 m
Name (M_Codo vertical interior de canal:Norma:...) | 509.AMB.Volum (m3)
3245233 | 0.00473484
3246470 | 0.00461003
3246500 | 0.00510541
5167334 | 0.00561795
5167757 | 0.00448352

# IfcFlowFitting: M_Reductor - PVC - Serie 40 - DWV:REDUCTOR_SANEJAMENT_RESIDUAL_POLIPROPILE (4)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN-PPR
Classification: 50.20.20.20 Uniformat (Uniformat); Group: L3J_4_SAN_FECAL 1 (2)
Pset_DistributionFlowElementCommon - Reference: M_Reductor - PVC - Serie 40 - DWV:REDUCTOR_SANEJAMENT_RESIDUAL_POLIPROPILE; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: REDUCTOR_SANEJAMENT_RESIDUAL_POLIPROPILE; 112.AMB.Servei: L3J_4_SAN_FECAL; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
Name (M_Reductor - PVC - Serie 40 - DWV:REDUCTOR_SANEJAMENT_RESIDUAL_POLIPROPILE:...) | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3)
3663742 | 25 mmø-25 mmø | 0.00305898 | 0.0000395465
3670547 | 32 mmø-25 mmø | 0.00404348 | 0.000057458
3671576 | 50 mmø-32 mmø | 0.0079128 | 0.00013837
3671947 | 50 mmø-25 mmø | 0.00721608 | 0.000124656

# IfcFlowFitting: M_Reductor - PVC - Serie 40 - DWV:REDUCTOR_SANEJAMENT_RESIDUAL_PVC_SOTERRAT (63)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN-PVCS
Classification: 50.20.20.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Reductor - PVC - Serie 40 - DWV:REDUCTOR_SANEJAMENT_RESIDUAL_PVC_SOTERRAT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: REDUCTOR_SANEJAMENT_RESIDUAL_PVC_SOTERRAT; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Reductor - PVC - Serie 40 - DWV:REDUCTOR_SANEJAMENT_RESIDUAL_PVC_SOTERRAT:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3254771 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00305938 | 0.0000395467 | L3J_4_SAN_FECAL 3
3285547 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00305898 | 0.0000395465 | L3J_4_SAN_FECAL 3
3455157 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00305898 | 0.0000395465 | L3J_4_SAN_FECAL 3
3490213 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00305898 | 0.0000395465 | L3J_4_SAN_FECAL 3
3491798 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 32 mmø-25 mmø | 0.00404348 | 0.000057458 | L3J_4_SAN_FECAL 3
3491985 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 32 mmø-25 mmø | 0.00401352 | 0.0000569039 | L3J_4_SAN_FECAL 3
3493113 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00305898 | 0.0000395465 | L3J_4_SAN_FECAL 3
3661272 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 125 mmø-110 mmø | 0.0514647 | 0.00212102 | L3J_4_SAN_PLUVIAL 6
3663294 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 110 mmø-50 mmø | 0.0298219 | 0.00111336 | L3J_4_SAN_PLUVIAL 6
3676972 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-110 mmø | 0.0514647 | 0.00212102 | L3J_4_SAN_FECAL 3
3679517 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-25 mmø | 0.00721608 | 0.000124658 | L3J_4_SAN_FECAL 3
3679519 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-25 mmø | 0.00721608 | 0.000124656 | L3J_4_SAN_FECAL 3
3679895 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-25 mmø | 0.00721608 | 0.000124656 | L3J_4_SAN_FECAL 3
3683925 | L3J_4_SAN_FECAL | Capella | 125 mmø-90 mmø | 0.0461134 | 0.00184281 | L3J_4_SAN_FECAL 3
3683985 | L3J_4_SAN_FECAL | Annex | 90 mmø-40 mmø | 0.0200978 | 0.00063074 | L3J_4_SAN_FECAL 3
3684972 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-50 mmø | 0.0364867 | 0.00155243 | L3J_4_SAN_FECAL 3
3685592 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-50 mmø | 0.02199 | 0.000674987 | L3J_4_SAN_FECAL 3
3686102 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-110 mmø | 0.0514647 | 0.00212102 | L3J_4_SAN_FECAL 3
3686215 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-90 mmø | 0.0461134 | 0.00184281 | L3J_4_SAN_FECAL 3
