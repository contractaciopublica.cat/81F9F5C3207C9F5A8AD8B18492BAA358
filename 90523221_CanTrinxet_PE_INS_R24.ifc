Properties of the parts of a building model (IFC2X3), part 10 of 10

# IfcFlowSegment: Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_RET (74)
Name (Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_RET:...) | In | Length (m) = 501.AMB.Longitud (m) | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 502.AMB.Amplada (m) | 503.AMB.Altura (m) | 507.AMB.Area (m2) | Group
3135138 | PLANTA COBERTA | 0.832862 | PLANTA COBERTA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.832862 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3135200 | PLANTA COBERTA | 4.7075 | PLANTA COBERTA | Nau Santa Eulalia | 150 mmx450 mm | 0.1 | 0.4 | 4.7075 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3135526 | PLANTA COBERTA | 2.4598 | PLANTA COBERTA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 2.4598 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3135630 | PLANTA COBERTA | 0.774768 | PLANTA COBERTA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.774768 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3135821 | PLANTA COBERTA | 4.7075 | PLANTA COBERTA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 4.7075 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3143893 | PLANTA BAIXA | 1.00931 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 1.00931 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3143914 | PLANTA BAIXA | 4.7075 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 4.7075 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3147293 | PLANTA BAIXA | 4.24447 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 4.24447 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3148056 | PLANTA BAIXA | 1.01201 | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx150 mm | 0.2 | 0.1 | 0.607209 | Mecánica L3J_3_CLIMA_RET_AIRE 6
3148084 | PLANTA BAIXA | 4.6275 | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx150 mm | 0.2 | 0.1 | 2.7765 | Mecánica L3J_3_CLIMA_RET_AIRE 6
3163739 | PLANTA BAIXA | 0.793898 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.793898 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3163755 | PLANTA BAIXA | 4.25609 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 4.25609 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3163935 | PLANTA BAIXA | 3.08633 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 3.08633 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3164766 | PLANTA BAIXA | 0.952871 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx200 mm | 0.3 | 0.15 | 0.857584 | Mecánica L3J_3_CLIMA_RET_AIRE 10
3167355 | PLANTA BAIXA | 0.0460863 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx200 mm | 0.3 | 0.15 | 0.0414777 | Mecánica L3J_3_CLIMA_RET_AIRE 10
3169689 | PLANTA BAIXA | 0.54859 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx250 mm | 0.25 | 0.2 | 0.493731 | Mecánica L3J_3_CLIMA_RET_AIRE 11
3169777 | PLANTA BAIXA | 4.69116 | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm | 0.35 | 0.1 | 4.22204 | Mecánica L3J_3_CLIMA_RET_AIRE 11
3259459 | PLANTA BAIXA | 0.730014 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.730014 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3259563 | PLANTA BAIXA | 0.263026 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.263026 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3259574 | PLANTA BAIXA | 0.0222581 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.0222581 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3427762 | PLANTA BAIXA | 0.153556 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.122845 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3427776 | PLANTA BAIXA | 0.519935 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.415948 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3439225 | PLANTA BAIXA | 0.0771011 | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm | 0.85 | 0.27 | 0.172707 | Mecánica L3J_3_CLIMA_RET_AIRE 11
3439552 | PLANTA BAIXA | 4.46437 | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm | 0.35 | 0.1 | 4.01793 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3439597 | PLANTA BAIXA | 2.05663 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 1.6453 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3439665 | PLANTA BAIXA | 0.139276 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.111421 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3446747 | PLANTA BAIXA | 1.62072 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 1.29657 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3447281 | PLANTA BAIXA | 0.532735 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.426188 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3480163 | PLANTA BAIXA | 0.312817 | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm | 0.1 | 0.4 | 0.312817 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3482314 | PLANTA BAIXA | 0.0525753 | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm | 0.85 | 0.27 | 0.117769 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3482316 | PLANTA BAIXA | 0.207717 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.207717 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3484189 | PLANTA BAIXA | 1.49778 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 1.49778 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3485377 | PLANTA BAIXA | 0.109843 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.109843 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3485427 | PLANTA BAIXA | 0.3128 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.3128 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3487374 | PLANTA BAIXA | 0.0231104 | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm | 0.85 | 0.27 | 0.0517674 | Mecánica L3J_3_CLIMA_RET_AIRE 6
3633991 | P0_NL | 0.176523 | P0_NL | Nau Lateral Sud | 350 mmx250 mm | 0.3 | 0.2 | 0.176523 | Mecánica L3J_3_CLIMA_RET_AIRE 2
3639460 | P0_NL | 0.216617 | P0_NL | Nau Lateral Sud | 950 mmx320 mm | 0.9 | 0.269974 | 0.506872 | Mecánica L3J_3_CLIMA_RET_AIRE 2
3639838 | P0_NL | 0.0864778 | P0_NL | Nau Lateral Sud | 350 mmx250 mm | 0.3 | 0.2 | 0.0864778 | Mecánica L3J_3_CLIMA_RET_AIRE 2
3655601 | PLANTA COBERTA | 0.215971 | PLANTA COBERTA | Nau Lateral Sud | 450 mmx400 mm | 0.4 | 0.35 | 0.323957 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3655637 | PLANTA COBERTA | 0.270615 | PLANTA COBERTA | Nau Lateral Sud | 1300 mmx410 mm | 1.25 | 0.36 | 0.871381 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3656366 | PLANTA BAIXA | 1.70987 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 2.05185 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3656384 | PLANTA BAIXA | 0.755026 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 0.906031 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3656543 | PLANTA COBERTA | 0.347387 | PLANTA COBERTA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 0.416864 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3666562 | PLANTA BAIXA | 1.80322 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 2.16386 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3666910 | PLANTA BAIXA | 0.921022 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 1.10523 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3666964 | PLANTA BAIXA | 2.97 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 3.564 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3759127 | PLANTA BAIXA | 0.171093 | PLANTA BAIXA | Nau Santa Eulalia | 600 mmx200 mm | 0.55 | 0.15 | 0.239531 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3760103 | PLANTA BAIXA | 0.0762235 | PLANTA BAIXA | Nau Santa Eulalia | 600 mmx200 mm | 0.55 | 0.15 | 0.106713 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3760178 | PLANTA BAIXA | 0.370195 | PLANTA BAIXA | Nau Santa Eulalia | 600 mmx200 mm | 0.55 | 0.15 | 0.518273 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3760673 | PLANTA BAIXA | 0.0249998 | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm | 0.85 | 0.27 | 0.0559994 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3866773 | PLANTA BAIXA | 1.22697 | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx150 mm | 0.2 | 0.1 | 0.736181 | Mecánica L3J_3_CLIMA_RET_AIRE 6
3870947 | PLANTA BAIXA | 0.751807 | PLANTA BAIXA | Nau Santa Eulalia | 600 mmx200 mm | 0.55 | 0.15 | 1.05253 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3871630 | PLANTA COBERTA | 0.0767808 | PLANTA COBERTA | Nau Santa Eulalia | 950 mmx250 mm | 0.9 | 0.2 | 0.168918 | Mecánica L3J_3_CLIMA_RET_AIRE 12
3871716 | PLANTA BAIXA | 0.225 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.225 | Mecánica L3J_3_CLIMA_RET_AIRE 12
4541589 | PLANTA BAIXA | 0.259563 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 0.311476 | Mecánica L3J_3_CLIMA_RET_AIRE 1
4541607 | PLANTA BAIXA | 1.03493 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 1.24192 | Mecánica L3J_3_CLIMA_RET_AIRE 1
4541613 | PLANTA BAIXA | 0.721485 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 0.865782 | Mecánica L3J_3_CLIMA_RET_AIRE 1
4541679 | PLANTA BAIXA | 4.88763 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 5.86516 | Mecánica L3J_3_CLIMA_RET_AIRE 1
4541811 | PLANTA BAIXA | 0.216853 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 0.260223 | Mecánica L3J_3_CLIMA_RET_AIRE 1
4541899 | PLANTA BAIXA | 5.93278 | PLANTA BAIXA | Nau Lateral Sud | 400 mmx300 mm | 0.35 | 0.25 | 7.11933 | Mecánica L3J_3_CLIMA_RET_AIRE 1
4792839 | PLANTA BAIXA | 0.737237 | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm | 0.1 | 0.4 | 0.737237 | Mecánica L3J_3_CLIMA_RET_AIRE 3
4792840 | PLANTA BAIXA | 0.295266 | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm | 0.1 | 0.4 | 0.295266 | Mecánica L3J_3_CLIMA_RET_AIRE 3
4954898 | PLANTA BAIXA | 4.09516 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx200 mm | 0.4 | 0.15 | 4.50468 | Mecánica L3J_3_CLIMA_RET_AIRE 12
4956042 | PLANTA BAIXA | 1.16964 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 1.16964 | Mecánica L3J_3_CLIMA_RET_AIRE 12
4956043 | PLANTA BAIXA | 0.0248367 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.0248367 | Mecánica L3J_3_CLIMA_RET_AIRE 12
4956044 | PLANTA BAIXA | 0.0274682 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.0274682 | Mecánica L3J_3_CLIMA_RET_AIRE 12
4956045 | PLANTA BAIXA | 0.467168 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx450 mm | 0.15 | 0.4 | 0.513885 | Mecánica L3J_3_CLIMA_RET_AIRE 12

# IfcFlowSegment: Rectangular Duct:L3J_COND_REC_CLIMA_XAPA_AP (10)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Rectangular Duct:L3J_COND_REC_CLIMA_XAPA_AP; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_REC_CLIMA_XAPA_AP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 119.AMB.FaseCreacio: Obra
Name (Rectangular Duct:L3J_COND_REC_CLIMA_XAPA_AP:...) | In | Length (m) = 501.AMB.Longitud (m) | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 502.AMB.Amplada (m) | 503.AMB.Altura (m) | 507.AMB.Area (m2) | Group
3528200 | P0_NL | 0.611128 | P0_NL | Nau Lateral Sud | 410 mmx410 mm | 0.3 | 0.3 | 0.733353 | Mecánica L3J_3_VENT_APORT_AIRE 1
3713920 | PLANTA COBERTA | 0.0920263 | PLANTA COBERTA | Nau Santa Eulalia | 460 mmx310 mm | 0.35 | 0.2 | 0.101229 | Mecánica L3J_3_VENT_APORT_AIRE 6
3715965 | PLANTA COBERTA | 0.204 | PLANTA COBERTA | Nau Santa Eulalia | 310 mmx460 mm | 0.2 | 0.35 | 0.2244 | Mecánica L3J_3_VENT_APORT_AIRE 6
3716598 | PLANTA COBERTA | 0.79346 | PLANTA COBERTA | Nau Santa Eulalia | 460 mmx310 mm | 0.35 | 0.2 | 0.872806 | Mecánica L3J_3_VENT_APORT_AIRE 6
3716741 | PLANTA COBERTA | 0.188567 | PLANTA COBERTA | Nau Santa Eulalia | 460 mmx310 mm | 0.35 | 0.2 | 0.207424 | Mecánica L3J_3_VENT_APORT_AIRE 6
3716952 | PLANTA COBERTA | 0.443251 | PLANTA COBERTA | Nau Santa Eulalia | 460 mmx310 mm | 0.35 | 0.2 | 0.487576 | Mecánica L3J_3_VENT_APORT_AIRE 6
3717082 | PLANTA COBERTA | 0.331146 | PLANTA COBERTA | Nau Santa Eulalia | 460 mmx310 mm | 0.35 | 0.2 | 0.364261 | Mecánica L3J_3_VENT_APORT_AIRE 6
3722082 | PLANTA COBERTA | 0.259171 | PLANTA COBERTA | Nau Santa Eulalia | 410 mmx410 mm | 0.3 | 0.3 | 0.311006 | Mecánica L3J_3_VENT_APORT_AIRE 5
3722138 | PLANTA COBERTA | 0.214 | PLANTA COBERTA | Nau Santa Eulalia | 410 mmx410 mm | 0.3 | 0.3 | 0.2568 | Mecánica L3J_3_VENT_APORT_AIRE 5
3722963 | PLANTA COBERTA | 0.675203 | PLANTA COBERTA | Nau Santa Eulalia | 410 mmx410 mm | 0.3 | 0.3 | 0.810243 | Mecánica L3J_3_VENT_APORT_AIRE 5

# IfcFlowSegment: Rectangular Duct:L3J_COND_REC_CLIMA_XAPA_EXT (16)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Rectangular Duct:L3J_COND_REC_CLIMA_XAPA_EXT; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_REC_CLIMA_XAPA_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 119.AMB.FaseCreacio: Obra
Name (Rectangular Duct:L3J_COND_REC_CLIMA_XAPA_EXT:...) | In | Length (m) = 501.AMB.Longitud (m) | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 502.AMB.Amplada (m) | 503.AMB.Altura (m) | 507.AMB.Area (m2) | Group
3342064 | PLANTA BAIXA | 0.405181 | PLANTA BAIXA | Nau Lateral Sud | 410 mmx310 mm | 0.3 | 0.2 | 0.405181 | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
3528223 | P0_NL | 0.153691 | P0_NL | Nau Lateral Sud | 410 mmx410 mm | 0.3 | 0.3 | 0.184429 | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
3713695 | PLANTA COBERTA | 0.33279 | PLANTA COBERTA | Nau Santa Eulalia | 350 mmx200 mm | 0.35 | 0.2 | 0.366069 | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
3713890 | PLANTA COBERTA | 0.0898517 | PLANTA COBERTA | Nau Santa Eulalia | 460 mmx310 mm | 0.35 | 0.2 | 0.0988369 | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
3714321 | PLANTA COBERTA | 1.32998 | PLANTA COBERTA | Nau Santa Eulalia | 460 mmx310 mm | 0.35 | 0.2 | 1.46298 | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
3715063 | PLANTA COBERTA | 0.6 | PLANTA COBERTA | Nau Santa Eulalia | 350 mmx200 mm | 0.35 | 0.2 | 0.66 | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
3715139 | PLANTA COBERTA | 0.201967 | PLANTA COBERTA | Nau Santa Eulalia | 300 mmx300 mm | 0.3 | 0.3 | 0.24236 | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
3715141 | PLANTA COBERTA | 0.257412 | PLANTA COBERTA | Nau Santa Eulalia | 410 mmx410 mm | 0.3 | 0.3 | 0.308894 | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
3715145 | PLANTA COBERTA | 0.5 | PLANTA COBERTA | Nau Santa Eulalia | 300 mmx300 mm | 0.3 | 0.3 | 0.6 | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
3721641 | PLANTA COBERTA | 0.214 | PLANTA COBERTA | Nau Santa Eulalia | 410 mmx410 mm | 0.3 | 0.3 | 0.2568 | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
3722483 | PLANTA COBERTA | 0.24053 | PLANTA COBERTA | Nau Santa Eulalia | 410 mmx410 mm | 0.3 | 0.3 | 0.288636 | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
3722988 | PLANTA COBERTA | 1.31417 | PLANTA COBERTA | Nau Santa Eulalia | 410 mmx410 mm | 0.3 | 0.3 | 1.57701 | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
3874447 | PLANTA COBERTA | 0.573518 | PLANTA COBERTA | Nau Santa Eulalia | 460 mmx310 mm | 0.35 | 0.2 | 0.63087 | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
3874449 | PLANTA COBERTA | 0.192594 | PLANTA COBERTA | Nau Santa Eulalia | 460 mmx310 mm | 0.35 | 0.2 | 0.211853 | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
5255558 | PLANTA BAIXA | 0.170205 | PLANTA BAIXA | Nau Lateral Sud | 410 mmx310 mm | 0.3 | 0.2 | 0.170205 | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
5258277 | PLANTA BAIXA | 2.34165 | PLANTA BAIXA | Nau Lateral Sud | 410 mmx310 mm | 0.3 | 0.2 | 2.34165 | Mecánica L3J_VENTILACIÓ_CTE_HS3 8

# IfcFlowSegment: Round Duct:L3J_COND_CIRC_EXT (22)
In: PLANTA BAIXA
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-CCG
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Round Duct:L3J_COND_CIRC_EXT; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_CIRC_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 100 mmø
5 AMB.Geometria - 505.AMB.Diametre: 0.1 m
Name (Round Duct:L3J_COND_CIRC_EXT:...) | Length (m) = 501.AMB.Longitud (m) | 117.AMB.Localitzacio | 507.AMB.Area (m2) | Group
3016984 | 0.218411 | Annex | 0.0686157 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1
3017006 | 0.395 | Annex | 0.124093 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1
3020435 | 1.13 | Nau Santa Eulalia | 0.355 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
3020542 | 1.22232 | Nau Santa Eulalia | 0.384004 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
3020577 | 0.0530852 | Nau Santa Eulalia | 0.0166772 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
3020589 | 0.67545 | Nau Santa Eulalia | 0.212199 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
3020630 | 0.29 | Nau Santa Eulalia | 0.0911062 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
3306781 | 0.856921 | Nau Santa Eulalia | 0.26921 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
3306791 | 0.061051 | Nau Santa Eulalia | 0.0191797 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
3306897 | 0.465671 | Nau Santa Eulalia | 0.146295 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
3306905 | 0.177359 | Nau Santa Eulalia | 0.055719 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
3363240 | 0.149645 | Annex | 0.0470123 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
3673663 | 0.175 | Nau Santa Eulalia | 0.0549779 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
3770598 | 0.0944233 | Nau Santa Eulalia | 0.0296639 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3770868 | 0.441472 | Nau Santa Eulalia | 0.138693 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3770879 | 0.296373 | Nau Santa Eulalia | 0.0931084 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3771288 | 0.020807 | Nau Santa Eulalia | 0.00653671 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
3771298 | 0.135736 | Nau Santa Eulalia | 0.0426427 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
3771339 | 1.325 | Nau Santa Eulalia | 0.416261 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
3771566 | 0.413316 | Nau Santa Eulalia | 0.129847 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3771574 | 0.29 | Nau Santa Eulalia | 0.0911062 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3771669 | 0.208081 | Nau Santa Eulalia | 0.0653705 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3

# IfcFlowSegment: Round Duct:L3J_COND_CIRC_XAPA_IMP (5)
In: PLANTA BAIXA
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-CCG
Classification: 50.30.40.30 Uniformat (Uniformat); Group: Mecánica L3J_3_CLIMA_IMP_AIRE 10
Pset_DistributionFlowElementCommon - Reference: Round Duct:L3J_COND_CIRC_XAPA_IMP; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_CIRC_XAPA_IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
Name (Round Duct:L3J_COND_CIRC_XAPA_IMP:...) | Length (m) = 501.AMB.Longitud (m) | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m)
3388084 | 1.66002 | 450 mmø | 2.34679 | 0.45
3388181 | 5.00493 | 350 mmø | 5.50321 | 0.35
3388208 | 5.00254 | 350 mmø | 5.50058 | 0.35
3388340 | 1.67882 | 450 mmø | 2.37337 | 0.45
3388382 | 5.00333 | 350 mmø | 5.50145 | 0.35

# IfcFlowTerminal: L3J_ARNE-S_ATTACHMENT:ARPS02S (10)
In: PLANTA BAIXA
Type - Material: Galvanised steel Light grey
Type - Pset_ManufacturerTypeInformation - Manufacturer: Urbidermis
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.10; 105.AMB.ClassificacioDescripcio: Il·luminació exterior; 109.AMB.CodiTipus: LLU
Classification: 50.60.50.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_ARNE-S_ATTACHMENT:ARPS02S; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: ARPS02S; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.164269 m2; 509.AMB.Volum: 0.00232946 m3
Name (L3J_ARNE-S_ATTACHMENT:ARPS02S:...)
5183965
5183969
5183972
5183975
5183978
5183981
5183984
5183987
5183990
5183993

# IfcFlowTerminal: L3J_ARNE-S_LUMINAIRE GEOMETRY:ARNE-S_LUMINAIRE GEOMETRY (10)
Type - Material: <Unnamed>, Glass, Galvanised steel Light grey
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.10; 105.AMB.ClassificacioDescripcio: Il·luminació exterior; 109.AMB.CodiTipus: LLU
Classification: 50.60.50.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_ARNE-S_LUMINAIRE GEOMETRY:ARNE-S_LUMINAIRE GEOMETRY; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: ARNE-S_LUMINAIRE GEOMETRY; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.120563 m2; 509.AMB.Volum: 0.00339388 m3
Name (L3J_ARNE-S_LUMINAIRE GEOMETRY:ARNE-S_LUMINAIRE GEOMETRY:...) | In
5183968 | 1.5_nau
5183971 | 1.5_nau
5183974 | 1.5_nau
5183977 | 1.5_nau
5183980 | 1.5_nau
5183983 | 1.5_nau
5183986 | P2
5183989 | PLANTA COBERTA
5183992 | PLANTA COBERTA
5183995 | P2

# IfcFlowTerminal: L3J_BUNERA:L3J_BUNERA (4)
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.60; 105.AMB.ClassificacioDescripcio: Terminals de drenatge; 109.AMB.CodiTipus: SAN-BS
Classification: 50.20.20.60 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_BUNERA:L3J_BUNERA; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_BUNERA; 112.AMB.Servei: L3J_4_SAN_PLUVIAL; 115.AMB.Nivell: PLANTA COBERTA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.124389 m2; 509.AMB.Volum: 0.00178895 m3
Name (L3J_BUNERA:L3J_BUNERA:...) | 117.AMB.Localitzacio | Group
3291359 | Nau Santa Eulalia | L3J_4_SAN_PLUVIAL 3
3296902 | Nau Lateral Sud | L3J_4_SAN_PLUVIAL 6
3297445 | Nau Lateral Sud | L3J_4_SAN_PLUVIAL 6
5052655 | Nau Santa Eulalia | L3J_4_SAN_PLUVIAL 3

# IfcFlowTerminal: L3J_CENTRAL_INTRUSIO:GENERAL, L3J_CENTRAL_INTRUSIO:GENERAL:4893763
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.80.10.20; 105.AMB.ClassificacioDescripcio: Centraletes de seguretat; 109.AMB.CodiTipus: INT-CEN
Classification: 50.80.10.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_CENTRAL_INTRUSIO:GENERAL; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: GENERAL; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.12 m2; 509.AMB.Volum: 0.0045 m3

# IfcFlowTerminal: L3J_DET-VOLUM:L3J_DET-VOLUM (13)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.80.20.10; 105.AMB.ClassificacioDescripcio: Detectors anti-intrusió; 109.AMB.CodiTipus: COM-01
Classification: 50.80.20.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_DET-VOLUM:L3J_DET-VOLUM; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_DET-VOLUM; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.029 m2; 509.AMB.Volum: 0.0006 m3
Name (L3J_DET-VOLUM:L3J_DET-VOLUM:...) | 117.AMB.Localitzacio
5099847 | Nau Santa Eulalia
5099849 | Nau Santa Eulalia
5099850 | Nau Santa Eulalia
5099851 | Nau Santa Eulalia
5099852 | Nau Santa Eulalia
5099853 | Nau Santa Eulalia
5099854 | Nau Santa Eulalia
5099855 | Nau Santa Eulalia
5107591 | Nau Lateral Sud
5107594 | Nau Lateral Sud
5107597 | Nau Lateral Sud
5107673 | Nau Lateral Sud
5191295 | Nau Santa Eulalia

# IfcFlowTerminal: L3J_DETECTOR-MAGNETIC:L3J_DETECTOR-MAGNETIC (11)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.80.20.30; 105.AMB.ClassificacioDescripcio: Sensors anti-intrusió; 109.AMB.CodiTipus: COM-03
Classification: 50.80.20.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_DETECTOR-MAGNETIC:L3J_DETECTOR-MAGNETIC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_DETECTOR-MAGNETIC; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0025 m2; 509.AMB.Volum: 0.0000165 m3
Name (L3J_DETECTOR-MAGNETIC:L3J_DETECTOR-MAGNETIC:...) | 117.AMB.Localitzacio
3891329 | Nau Santa Eulalia
3892311 | Nau Santa Eulalia
3892340 | Nau Santa Eulalia
3892752 | Nau Santa Eulalia
3892786 | Nau Santa Eulalia
3898948 | Nau Santa Eulalia
3900153 | Nau Santa Eulalia
3900249 | Nau Santa Eulalia
3902025 | Nau Lateral Sud
3902054 | Nau Lateral Sud
3902239 | Nau Lateral Sud

# IfcFlowTerminal: L3J_DOWNLIGHT:PARA HORMIGON (7)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.20; 105.AMB.ClassificacioDescripcio: Il·luminació interior; 109.AMB.CodiTipus: LLU-INT
Classification: 50.60.50.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_DOWNLIGHT:PARA HORMIGON; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: PARA HORMIGON; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.647803 m2; 509.AMB.Volum: 0.120964 m3
Name (L3J_DOWNLIGHT:PARA HORMIGON:...)
3367359
3367376
3920811
3920812
3920896
3920920
3920930

# IfcFlowTerminal: L3J_DOWNLIGHT:PARA MADERA (9)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.20; 105.AMB.ClassificacioDescripcio: Il·luminació interior; 109.AMB.CodiTipus: LLU-INT
Classification: 50.60.50.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_DOWNLIGHT:PARA MADERA; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: PARA MADERA; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.647803 m2; 509.AMB.Volum: 0.119015 m3
Name (L3J_DOWNLIGHT:PARA MADERA:...)
3367397
3367404
3367411
3367414
4897242
4897250
4897281
5202159
5202226

# IfcFlowTerminal: L3J_EQUIP_AUTÒNOM_EMERGÈNCIA:DAISALUX_ZINER N20 2 (28)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.30; 105.AMB.ClassificacioDescripcio: Il·luminació d'emergència; 109.AMB.CodiTipus: LLU-INT
Classification: 50.60.50.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_EQUIP_AUTÒNOM_EMERGÈNCIA:DAISALUX_ZINER N20 2; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: DAISALUX_ZINER N20 2; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.085311 m2; 509.AMB.Volum: 0.00205425 m3
Name (L3J_EQUIP_AUTÒNOM_EMERGÈNCIA:DAISALUX_ZINER N20 2:...) | 117.AMB.Localitzacio
4834936 | Nau Santa Eulalia
4834946 | Nau Santa Eulalia
4834983 | Nau Santa Eulalia
4835147 | Nau Santa Eulalia
4835508 | Nau Santa Eulalia
4835542 | Nau Santa Eulalia
4835555 | Nau Santa Eulalia
4835700 | Nau Santa Eulalia
4835714 | Nau Santa Eulalia
4835916 | Nau Santa Eulalia
4845583 | Nau Santa Eulalia
4845896 | Nau Santa Eulalia
4845900 | Nau Santa Eulalia
4846667 | Nau Lateral Sud
4846676 | Nau Lateral Sud
4846842 | Nau Lateral Sud
4847249 | Annex
4847405 | Annex
4896946 | Nau Santa Eulalia
4896961 | Nau Santa Eulalia
4897044 | Nau Santa Eulalia
4897135 | Nau Santa Eulalia
4921820 | Nau Lateral Sud
4921826 | Nau Lateral Sud
5168239 | Nau Santa Eulalia
5219876 | Nau Santa Eulalia
5227917 | Nau Santa Eulalia
5260500 | Nau Santa Eulalia

# IfcFlowTerminal: L3J_Luminaria Inclinada:Luminaria Inclinada (92)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.20; 105.AMB.ClassificacioDescripcio: Il·luminació interior; 109.AMB.CodiTipus: LLU-INT
Classification: 50.60.50.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_Luminaria Inclinada:Luminaria Inclinada; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Luminaria Inclinada; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (L3J_Luminaria Inclinada:Luminaria Inclinada:...) | 117.AMB.Localitzacio | 503.AMB.Altura (m) | 507.AMB.Area (m2) | 509.AMB.Volum (m3)
3914915 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3919524 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3919532 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3919752 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3919766 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3919774 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3919788 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3919798 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3919814 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3919826 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920068 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920108 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920109 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920112 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920113 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920114 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920115 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920116 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920117 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920118 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920134 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920151 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920170 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920180 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920244 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920283 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920295 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920303 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920311 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920363 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920426 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920443 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920462 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920482 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920518 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920528 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3920566 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
3921632 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921681 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921689 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921697 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921811 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921824 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921839 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921840 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921848 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921849 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921867 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
3921868 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
4792864 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
4792865 | Nau Santa Eulalia | 0.0660152 | 0.122438 | 0.00298389
4792866 | Nau Santa Eulalia | 0.0627443 | 0.118611 | 0.00283604
4792867 | Nau Santa Eulalia | 0.0610395 | 0.116616 | 0.00275899
4792868 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
4792869 | Nau Santa Eulalia | 0.0586644 | 0.113837 | 0.00265163
4792870 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
4792871 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
4792872 | Nau Santa Eulalia | 0.064245 | 0.120367 | 0.00290388
4792878 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
4792880 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
4792881 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
4792882 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
4792883 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
4792884 | Nau Lateral Sud | 0.0677854 | 0.124509 | 0.0030639
5201126 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201134 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201144 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201154 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201323 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201333 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201343 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201353 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201563 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201564 | Nau Santa Eulalia | 0.0586644 | 0.113837 | 0.00265163
5201655 | Nau Santa Eulalia | 0.0586644 | 0.113837 | 0.00265163
5201664 | Nau Santa Eulalia | 0.0586644 | 0.113837 | 0.00265163
5201673 | Nau Santa Eulalia | 0.0586644 | 0.113837 | 0.00265163
5201684 | Nau Santa Eulalia | 0.0586644 | 0.113837 | 0.00265163
5201769 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201798 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201817 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201855 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201872 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201897 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201926 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201956 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201980 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201988 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5201998 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5202006 | Nau Santa Eulalia | 0.0677854 | 0.124509 | 0.0030639
5202304 | Annex | 0.0677854 | 0.124509 | 0.0030639
5202347 | Annex | 0.0677854 | 0.124509 | 0.0030639

# IfcFlowTerminal: L3J_PRESA DADES:NORMAL (14)
In: PLANTA BAIXA
Type - Material: Nuevo material por defecto
Type - Pset_ManufacturerTypeInformation - Manufacturer: JUNG
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.70.40.10; 105.AMB.ClassificacioDescripcio: Preses de telecomunicacions; 109.AMB.CodiTipus: COM-06
Classification: 50.70.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_PRESA DADES:NORMAL; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: NORMAL; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0161596 m2; 509.AMB.Volum: 0.000161159 m3
Name (L3J_PRESA DADES:NORMAL:...) | 117.AMB.Localitzacio
3195557 | Nau Santa Eulalia
3195563 | Nau Santa Eulalia
3715138 | Nau Santa Eulalia
3887919 | Nau Santa Eulalia
3890883 | Nau Santa Eulalia
3891255 | Nau Santa Eulalia
3900728 | Nau Santa Eulalia
5077999 | Nau Santa Eulalia
5088740 | Nau Santa Eulalia
5089058 | Nau Santa Eulalia
5089440 | Nau Santa Eulalia
5089506 | Nau Santa Eulalia
5089595 | Nau Santa Eulalia
5190923 | Nau Lateral Sud

# IfcFlowTerminal: L3J_PRESA_RJ_WIFI:EP73-PresaSenyalWIFI-SIMON82-EmissorTel (8)
In: PLANTA BAIXA
Type - Material: Nuevo material por defecto
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.70.50.20; 105.AMB.ClassificacioDescripcio: Emissors de telecomunicacions; 109.AMB.CodiTipus: COM-05
Classification: 50.70.50.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_PRESA_RJ_WIFI:EP73-PresaSenyalWIFI-SIMON82-EmissorTel; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: EP73-PresaSenyalWIFI-SIMON82-EmissorTel; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0161596 m2; 509.AMB.Volum: 0.000161159 m3
Name (L3J_PRESA_RJ_WIFI:EP73-PresaSenyalWIFI-SIMON82-EmissorTel:...) | 117.AMB.Localitzacio
4945627 | Nau Santa Eulalia
4945659 | Nau Santa Eulalia
4945678 | Annex
5075041 | Nau Santa Eulalia
5077903 | Nau Santa Eulalia
5089400 | Nau Santa Eulalia
5089546 | Nau Santa Eulalia
5089861 | Nau Lateral Sud

# IfcFlowTerminal: L3J_PROJECTOR_LLUM:BANYADOR PARET ERCO LIGHTSCAN (5)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.20; 105.AMB.ClassificacioDescripcio: Il·luminació interior; 109.AMB.CodiTipus: ENL-15
Classification: 50.60.50.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_PROJECTOR_LLUM:BANYADOR PARET ERCO LIGHTSCAN; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: BANYADOR PARET ERCO LIGHTSCAN; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.970109 m2; 509.AMB.Volum: 0.143443 m3
Name (L3J_PROJECTOR_LLUM:BANYADOR PARET ERCO LIGHTSCAN:...) | 117.AMB.Localitzacio
5140963
5140986
5140996 | Nau de Sta. Eulalia
5141006 | Nau de Sta. Eulalia
5141014 | Nau de Sta. Eulalia

# IfcFlowTerminal: L3J_RACK:600x600 (2)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.70.10.30; 105.AMB.ClassificacioDescripcio: Armaris RACK; 109.AMB.CodiTipus: COM-15
Classification: 50.70.10.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_RACK:600x600; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: 600x600; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 6.5804 m2; 509.AMB.Volum: 0.71748 m3
Name (L3J_RACK:600x600:...) | 117.AMB.Localitzacio
3100559 | Nau Santa Eulalia
3921906 | Nau Lateral Sud

# IfcFlowTerminal: L3J_REGLETA_ESTANCA:LuxMay Est Opal, L3J_REGLETA_ESTANCA:LuxMay Est Opal:4847459
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.10; 105.AMB.ClassificacioDescripcio: Il·luminació exterior; 109.AMB.CodiTipus: ENL-20
Classification: 50.60.50.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_REGLETA_ESTANCA:LuxMay Est Opal; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: LuxMay Est Opal; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.826919 m2; 509.AMB.Volum: 0.127901 m3

# IfcFlowTerminal: L3J_TARJETER:L3J_TARJETER (13)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.80.30.10; 105.AMB.ClassificacioDescripcio: Control de accessos; 109.AMB.CodiTipus: COM-21
Classification: 50.80.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_TARJETER:L3J_TARJETER; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TARJETER; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.035 m2; 509.AMB.Volum: 0.0003125 m3
Name (L3J_TARJETER:L3J_TARJETER:...) | 117.AMB.Localitzacio
3891447 | Nau Santa Eulalia
3892422 | Nau Santa Eulalia
3892483 | Nau Santa Eulalia
3892696 | Nau Santa Eulalia
3892898 | Nau Santa Eulalia
3899042 | Nau Santa Eulalia
3900331 | Nau Santa Eulalia
3900632 | Nau Santa Eulalia
3902405 | Nau Lateral Sud
3902412 | Nau Lateral Sud
5088807 | Nau Santa Eulalia
5088902 | Nau Santa Eulalia
5190987 | Nau Lateral Sud

# IfcFlowTerminal: L3J_TECLAT:L3J_TECLAT (5)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.80.10.20; 105.AMB.ClassificacioDescripcio: Centraletes de seguretat; 109.AMB.CodiTipus: COM-22
Classification: 50.80.10.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_TECLAT:L3J_TECLAT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TECLAT; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0203459 m2; 509.AMB.Volum: 0.000176814 m3
Name (L3J_TECLAT:L3J_TECLAT:...) | 117.AMB.Localitzacio
5107805 | Nau Lateral Sud
5107901 | Nau Santa Eulalia
5107976 | Nau Santa Eulalia
5108017 | Nau Santa Eulalia
5108023 | Annex

# IfcFlowTerminal: L3J_TROX_LVS_125:L3J_TROX_LVS_125 (6)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-UI
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_TROX_LVS_125:L3J_TROX_LVS_125; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TROX_LVS_125; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0415006 m2; 509.AMB.Volum: 0.000152981 m3
Name (L3J_TROX_LVS_125:L3J_TROX_LVS_125:...) | 117.AMB.Localitzacio | Group
3157516 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
3196707 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
3196718 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3198280 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
3363209 | Annex | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
3770335 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2

# IfcFlowTerminal: L3J_UPLIGHT:DOPO 3,5W 3000K (5)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.20; 105.AMB.ClassificacioDescripcio: Il·luminació interior; 109.AMB.CodiTipus: ENL-18
Classification: 50.60.50.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_UPLIGHT:DOPO 3,5W 3000K; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: DOPO 3,5W 3000K; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.624331 m2; 509.AMB.Volum: 0.120324 m3
Name (L3J_UPLIGHT:DOPO 3,5W 3000K:...)
5139985
5140925
5140935
5140945
5140953

# IfcFlowTerminal: MADEL_GRILLE_CIRCULAR DUCT_CMC:CMC 400x75 (12)
In: PLANTA BAIXA
Type - PredefinedType: GRILLE; Material: MADEL_M9016, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: MADEL
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.50.50; 105.AMB.ClassificacioDescripcio: Reixetes; 109.AMB.CodiTipus: CLI-CRG; 111.AMB.DescripcioTipus: The CMC series grilles are designed to be used in air-conditioning, ventilation, and heating. The grilles are placed directly in circular ducts. The direction of the blades can be altered, making it possible to graduate the extent, the height and the width of the air stream.
Classification: 50.30.50.50 Uniformat (Uniformat); Group: Mecánica L3J_3_CLIMA_IMP_AIRE 10
Pset_DistributionFlowElementCommon - Reference: MADEL_GRILLE_CIRCULAR DUCT_CMC:CMC 400x75; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: CMC 400x75; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.128686 m2; 509.AMB.Volum: 0.000945901 m3
Name (MADEL_GRILLE_CIRCULAR DUCT_CMC:CMC 400x75:...)
3389824
3389863
3389940
3390826
3391279
3391340
3391450
3391525
3391582
3391665
3391888
3392793

# IfcFlowTerminal: URBIDERMIS_ARNE-S_Wall:ARNE-S_Wall-S (10)
In: PLANTA BAIXA
Type - Material: Galvanised steel Light grey
Type - Pset_ManufacturerTypeInformation - Manufacturer: Urbidermis
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.50.10; 105.AMB.ClassificacioDescripcio: Il·luminació exterior; 109.AMB.CodiTipus: LLU-EXT
Classification: 50.60.50.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: URBIDERMIS_ARNE-S_Wall:ARNE-S_Wall-S; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: ARNE-S_Wall-S; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0168579 m2; 509.AMB.Volum: 0.0000472832 m3
Name (URBIDERMIS_ARNE-S_Wall:ARNE-S_Wall-S:...) | 117.AMB.Localitzacio
3934133 | Nau de Sta. Eulalia
3934234 | Nau Santa Eulalia
3934244 | Nau Santa Eulalia
3934262 | Nau Santa Eulalia
3934271 | Nau Santa Eulalia
3934281 | Nau Santa Eulalia
3934321 | Nau Lateral Sud
3934507
3934530
3934614 | Nau Lateral Sud

# IfcSystem: L3J_2_ACS (2)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_2_ACS
Name | 509.AMB.Volum (m3)
L3J_2_ACS 1 | 0.000127778
L3J_2_ACS 2 | 0.000208104

# IfcSystem: L3J_2_AFS (3)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_2_AFS
Name | 509.AMB.Volum (m3)
L3J_2_AFS 1 | 0.0884129
L3J_2_AFS 2 | 0.0000260847
AFS 3 | 0.00559378

# IfcSystem: L3J_3_CALEF_IMP (24)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_3_CALEF_IMP
Name | 509.AMB.Volum (m3)
L3J_3_CALEF_IMP 2 | 0.0017715
L3J_3_CALEF_IMP 1 | 0.00112847
L3J_3_CALEF_IMP 3 | 0.0002483
L3J_3_CALEF_IMP 13 | 0.000429857
L3J_3_CALEF_IMP 22 | 0.0000897628
L3J_3_CALEF_IMP 24 | 0.0000339917
L3J_3_CALEF_IMP 5 | 0.000149447
L3J_3_CALEF_IMP 4 | 0.000242666
L3J_3_CALEF_IMP 25 | 0.000467472
L3J_3_CALEF_IMP 16 | 0.0000957533
L3J_3_CALEF_IMP 18 | 0.00011841
L3J_3_CALEF_IMP 8 | 0.000328854
L3J_3_CALEF_IMP 10 | 0.000127668
L3J_3_CALEF_IMP 14 | 0.000279116
L3J_3_CALEF_IMP 11 | 0.000047372
L3J_3_CALEF_IMP 12 | 0.000773589
L3J_3_CALEF_IMP 19 | 0.000240199
L3J_3_CALEF_IMP 17 | 0.000901678
L3J_3_CALEF_IMP 20 | 0.0000169867
L3J_3_CALEF_IMP 9 | 0.000547315
L3J_3_CALEF_IMP 21 | 0.000192482
L3J_3_CALEF_IMP 6 | 0.000674514
L3J_3_CALEF_IMP 15 | 0.000360199
L3J_3_CALEF_IMP 23 | 0.000196593

# IfcSystem: L3J_3_CALEF_RET (18)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_3_CALEF_RET
Name | 509.AMB.Volum (m3)
L3J_3_CALEF_RET 2 | 0.00713912
L3J_3_CALEF_RET 1 | 0.00456186
L3J_3_CALEF_RET 5 | 0.0000669408
L3J_3_CALEF_RET 13 | 0.000117355
L3J_3_CALEF_RET 15 | 0.000320945
L3J_3_CALEF_RET 18
L3J_3_CALEF_RET 6
L3J_3_CALEF_RET 4 | 0.00101912
L3J_3_CALEF_RET 19 | 0.0000566649
L3J_3_CALEF_RET 14 | 0.000136041
L3J_3_CALEF_RET 9 | 0.000442715
L3J_3_CALEF_RET 3 | 0.0000191492
L3J_3_CALEF_RET 12 | 0.0011191
L3J_3_CALEF_RET 16 | 0.000646793
L3J_3_CALEF_RET 11 | 0.000246219
L3J_3_CALEF_RET 10 | 0.0000699019
L3J_3_CALEF_RET 7 | 0.0000902056
L3J_3_CALEF_RET 17 | 0.000437188

# IfcSystem: L3J_3_CLIMA_IMP_AIRE (11)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_3_CLIMA_IMP_AIRE
Name
Mecánica L3J_3_CLIMA_IMP_AIRE 4
Mecánica L3J_3_CLIMA_IMP_AIRE 2
Mecánica L3J_3_CLIMA_IMP_AIRE 1
Mecánica L3J_3_CLIMA_IMP_AIRE 5
Mecánica L3J_3_CLIMA_IMP_AIRE 8
Mecánica L3J_3_CLIMA_IMP_AIRE 10
Mecánica L3J_3_CLIMA_IMP_AIRE 6
Mecánica L3J_3_CLIMA_IMP_AIRE 7
Mecánica L3J_3_CLIMA_IMP_AIRE 3
Mecánica L3J_3_CLIMA_IMP_AIRE 9
Mecánica L3J_3_CLIMA_IMP_AIRE 11

# IfcSystem: L3J_3_CLIMA_RET_AIRE (11)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_3_CLIMA_RET_AIRE
Name
Mecánica L3J_3_CLIMA_RET_AIRE 9
Mecánica L3J_3_CLIMA_RET_AIRE 10
Mecánica L3J_3_CLIMA_RET_AIRE 11
Mecánica L3J_3_CLIMA_RET_AIRE 4
Mecánica L3J_3_CLIMA_RET_AIRE 3
Mecánica L3J_3_CLIMA_RET_AIRE 12
Mecánica L3J_3_CLIMA_RET_AIRE 1
Mecánica L3J_3_CLIMA_RET_AIRE 5
Mecánica L3J_3_CLIMA_RET_AIRE 6
Mecánica L3J_3_CLIMA_RET_AIRE 2
Mecánica L3J_3_CLIMA_RET_AIRE 7

# IfcSystem: L3J_3_VENTILACIÓ_CTE_HS3 (23)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_3_VENTILACIÓ_CTE_HS3
Name
Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1
Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Mecánica L3J_VENTILACIÓ_CTE_HS3 5
Mecánica L3J_VENTILACIÓ_CTE_HS3 3
Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Mecánica L3J_VENTILACIÓ_CTE_HS3 7
Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Mechanical L3J_VENTILACIÓ_CTE_HS3 1
Mecánica L3J_VENTILACIÓ_CTE_HS3 10
Mecánica L3J_VENTILACIÓ_CTE_HS3 9
Mecánica L3J_VENTILACIÓ_CTE_HS3 1
Mecánica L3J_VENTILACIÓ_CTE_HS3 11
Mecánica L3J_VENTILACIÓ_CTE_HS3 2
Mecánica L3J_VENTILACIÓ_CTE_HS3 13
Mecánica L3J_VENTILACIÓ_CTE_HS3 14

# IfcSystem: L3J_3_VENT_APORT_AIRE (7)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_3_VENT_APORT_AIRE
Name
Mecánica L3J_3_VENT_APORT_AIRE 6
Mecánica L3J_3_VENT_APORT_AIRE 4
Mecánica L3J_3_VENT_APORT_AIRE 1
Mecánica L3J_3_VENT_APORT_AIRE 2
Mecánica L3J_3_VENT_APORT_AIRE 3
Mecánica L3J_3_VENT_APORT_AIRE 7
Mecánica L3J_3_VENT_APORT_AIRE 5

# IfcSystem: L3J_3_VENT_RETORN_AIRE, Mecánica L3J_3_VENT_RETORN_AIRE 1
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_3_VENT_RETORN_AIRE

# IfcSystem: L3J_4_SAN_FECAL (3)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_4_SAN_FECAL
Name
L3J_4_SAN_FECAL 3
L3J_4_SAN_FECAL 1 (2)
L3J_4_SAN_FECAL 1

# IfcSystem: L3J_4_SAN_PLUVIAL (6)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_4_SAN_PLUVIAL
Name
L3J_4_SAN_PLUVIAL 4
L3J_4_SAN_PLUVIAL 2
L3J_4_SAN_PLUVIAL 1
L3J_4_SAN_PLUVIAL 6
L3J_4_SAN_PLUVIAL 3
L3J_4_SAN_PLUVIAL 8

# IfcSystem: L3J_6_PCI - HUMIDA (3)
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_6_PCI - HUMIDA
Name | 509.AMB.Volum (m3)
L3J_6_PCI - HUMIDA 1 | 0.00596609
L3J_6_PCI - HUMIDA 2 | 0.00488537
L3J_6_PCI - HUMIDA 3 | 0.0132966
