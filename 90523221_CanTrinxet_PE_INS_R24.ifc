Properties of the parts of a building model (IFC2X3), part 7 of 10

# IfcFlowFitting: M_Reductor - PVC - Serie 40 - DWV:REDUCTOR_SANEJAMENT_RESIDUAL_PVC_SOTERRAT (63)
Name (M_Reductor - PVC - Serie 40 - DWV:REDUCTOR_SANEJAMENT_RESIDUAL_PVC_SOTERRAT:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3686217 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-50 mmø | 0.0219901 | 0.000675002 | L3J_4_SAN_FECAL 3
3686573 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-110 mmø | 0.0514644 | 0.00212095 | L3J_4_SAN_FECAL 3
3690576 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-90 mmø | 0.0461134 | 0.00184281 | L3J_4_SAN_FECAL 3
3690675 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-40 mmø | 0.0200978 | 0.00063076 | L3J_4_SAN_FECAL 3
3691959 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 32 mmø-25 mmø | 0.00401352 | 0.0000569039 | L3J_4_SAN_FECAL 3
3691966 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00305898 | 0.0000395465 | L3J_4_SAN_FECAL 3
3691974 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 32 mmø-25 mmø | 0.00401352 | 0.0000569039 | L3J_4_SAN_FECAL 3
3692676 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 32 mmø-25 mmø | 0.00401352 | 0.0000569039 | L3J_4_SAN_FECAL 3
3694370 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-32 mmø | 0.00791933 | 0.000138368 | L3J_4_SAN_FECAL 3
3765939 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 25 mmø-25 mmø | 0.00305898 | 0.0000395465 | L3J_4_SAN_FECAL 3
3766592 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø-32 mmø | 0.00791933 | 0.000138368 | L3J_4_SAN_FECAL 3
3766594 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 32 mmø-25 mmø | 0.00401352 | 0.0000569039 | L3J_4_SAN_FECAL 3
3766596 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 32 mmø-25 mmø | 0.00401352 | 0.0000569039 | L3J_4_SAN_FECAL 3
3767512 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 40 mmø-25 mmø | 0.00515267 | 0.0000782176 | L3J_4_SAN_FECAL 3
3789288 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 125 mmø-110 mmø | 0.0514667 | 0.00212095 | L3J_4_SAN_PLUVIAL 8
3823604 | L3J_4_SAN_FECAL |  | 200 mmø-125 mmø | 0.107189 | 0.00667399 | L3J_4_SAN_FECAL 3
3824631 | L3J_4_SAN_FECAL |  | 200 mmø-160 mmø | 0.121354 | 0.00761346 | L3J_4_SAN_FECAL 3
3824807 | L3J_4_SAN_PLUVIAL |  | 160 mmø-125 mmø | 0.0772805 | 0.0038703 | L3J_4_SAN_PLUVIAL 6
3826329 | L3J_4_SAN_PLUVIAL |  | 160 mmø-125 mmø | 0.0772805 | 0.0038703 | L3J_4_SAN_PLUVIAL 8
3905392 | L3J_4_SAN_PLUVIAL |  | 160 mmø-125 mmø | 0.0772805 | 0.0038703 | L3J_4_SAN_PLUVIAL 8
3905397 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 125 mmø-110 mmø | 0.051495 | 0.00212108 | L3J_4_SAN_PLUVIAL 8
4560736 | L3J_4_SAN_FECAL |  | 200 mmø-125 mmø | 0.107188 | 0.00667411 | L3J_4_SAN_FECAL 3
4838804 | L3J_4_SAN_PLUVIAL |  | 160 mmø-110 mmø | 0.0723452 | 0.00358748 | L3J_4_SAN_PLUVIAL 6
5051624 | L3J_4_SAN_PLUVIAL |  | 200 mmø-125 mmø | 0.107188 | 0.00667411 | L3J_4_SAN_PLUVIAL 3
5051645 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 125 mmø-110 mmø | 0.0514647 | 0.00212101 | L3J_4_SAN_PLUVIAL 3
5052455 | L3J_4_SAN_PLUVIAL |  | 200 mmø-160 mmø | 0.121354 | 0.00761359 | L3J_4_SAN_PLUVIAL 3
5056364 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 160 mmø-110 mmø | 0.0723452 | 0.00358757 | L3J_4_SAN_PLUVIAL 3
5056533 | L3J_4_SAN_PLUVIAL |  | 160 mmø-125 mmø | 0.0772805 | 0.0038703 | L3J_4_SAN_PLUVIAL 3
5056703 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 125 mmø-110 mmø | 0.0514646 | 0.00212108 | L3J_4_SAN_PLUVIAL 3
5056965 | L3J_4_SAN_PLUVIAL |  | 200 mmø-125 mmø | 0.107188 | 0.00667411 | L3J_4_SAN_PLUVIAL 3
5059488 | L3J_4_SAN_FECAL |  | 200 mmø-160 mmø | 0.121354 | 0.00761359 | L3J_4_SAN_FECAL 3
5059559 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 160 mmø-125 mmø | 0.0772805 | 0.00387023 | L3J_4_SAN_FECAL 3
5060351 | L3J_4_SAN_FECAL |  | 200 mmø-125 mmø | 0.107166 | 0.00667399 | L3J_4_SAN_FECAL 3
5109685 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 110 mmø-90 mmø | 0.0386772 | 0.00140558 | L3J_4_SAN_PLUVIAL 6
5110152 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 110 mmø-90 mmø | 0.0386773 | 0.00140554 | L3J_4_SAN_PLUVIAL 6
5117557 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-90 mmø | 0.0461135 | 0.00184274 | L3J_4_SAN_FECAL 3
5117974 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 125 mmø-50 mmø | 0.0364867 | 0.00155249 | L3J_4_SAN_FECAL 3
5209016 | L3J_4_SAN_PLUVIAL | Nau Lateral Sud | 110 mmø-25 mmø | 0.025294 | 0.00102498 | L3J_4_SAN_PLUVIAL 6
5213154 | L3J_4_SAN_PLUVIAL | Nau Santa Eulalia | 125 mmø-110 mmø | 0.0514647 | 0.00212108 | L3J_4_SAN_PLUVIAL 3
5213412 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 90 mmø-50 mmø | 0.0221876 | 0.000674948 | L3J_4_SAN_FECAL 3
5219735 | L3J_4_SAN_PLUVIAL | Nau lateral | 125 mmø-110 mmø | 0.0514647 | 0.00212102 | L3J_4_SAN_PLUVIAL 6
5241974 | L3J_4_SAN_PLUVIAL |  | 200 mmø-160 mmø | 0.121365 | 0.00761352 | L3J_4_SAN_PLUVIAL 3
5241976 | L3J_4_SAN_PLUVIAL |  | 200 mmø-160 mmø | 0.121365 | 0.00761352 | L3J_4_SAN_PLUVIAL 3
5241978 | L3J_4_SAN_PLUVIAL |  | 200 mmø-160 mmø | 0.121354 | 0.00761359 | L3J_4_SAN_PLUVIAL 3

# IfcFlowFitting: M_Remate rectangular:L3J_TAP_REC_CLIMA_FIBRA_RETORNO, M_Remate rectangular:L3J_TAP_REC_CLIMA_FIBRA_RETORNO:3871808
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.40 Uniformat (Uniformat); Group: Mecánica L3J_3_CLIMA_RET_AIRE 12
Pset_DistributionFlowElementCommon - Reference: M_Remate rectangular:L3J_TAP_REC_CLIMA_FIBRA_RETORNO; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TAP_REC_CLIMA_FIBRA_RETORNO; 112.AMB.Servei: L3J_3_CLIMA_RET_AIRE; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 350 mmx250 mm
5 AMB.Geometria - 509.AMB.Volum: 0.0015 m3

# IfcFlowFitting: M_Remate redondo:IMP (4)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI
Classification: 50.30.40.30 Uniformat (Uniformat); Group: Mecánica L3J_3_CLIMA_IMP_AIRE 10
Pset_DistributionFlowElementCommon - Reference: M_Remate redondo:IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
Name (M_Remate redondo:IMP:...) | 242.AMB.Mida | 509.AMB.Volum (m3)
3391980 | 450 mmø | 0.00397578
3393091 | 350 mmø | 0.00240516
3393094 | 350 mmø | 0.00240516
3393096 | 350 mmø | 0.00240516

# IfcFlowFitting: M_Tapón - Genérico1:Estándar (11)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM
Classification: 50.10.20.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Tapón - Genérico1:Estándar; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Estándar; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Tapón - Genérico1:Estándar:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 503.AMB.Altura (m) | 509.AMB.Volum (m3) | Group
3019542 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0095875 | 0.00000276851 | L3J_2_AFS 1
3037314 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0095875 | 0.00000276851 | L3J_2_AFS 1
3199111 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0095875 | 0.00000276851 | L3J_2_AFS 1
3199154 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0095875 | 0.00000276851 | L3J_2_AFS 1
3206904 | L3J_2_AFS | Annex | 16 mmø | 0.0095875 | 0.00000276851 | L3J_2_AFS 1
3768870 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0095875 | 0.00000276851 | L3J_2_AFS 1
4057562 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø | 0.0111125 | 0.00000431087 | L3J_2_ACS 1
4057573 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0111125 | 0.00000431087 | L3J_2_AFS 2
4060942 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0095875 | 0.00000276851 | L3J_2_AFS 1
4060972 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0095875 | 0.00000276851 | L3J_2_AFS 1
4065941 | L3J_2_AFS | Annex | 16 mmø | 0.0095875 | 0.00000276851 | L3J_2_AFS 1

# IfcFlowFitting: M_Tapón - Genérico:Estándar (3)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN-PVC
Classification: 50.20.20.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Tapón - Genérico:Estándar; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Estándar; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 20 mmø
5 AMB.Geometria - 503.AMB.Altura: 0.0111125 m; 509.AMB.Volum: 0.00000431087 m3
Name (M_Tapón - Genérico:Estándar:...) | 112.AMB.Servei | Group
3035997 | L3J_2_AFS | L3J_2_AFS 1
3036013 | L3J_2_ACS | L3J_2_ACS 2
3293947 | L3J_2_AFS | L3J_2_AFS 1

# IfcFlowFitting: M_Tapón - PVC - Serie 40:TAP_SANEJAMENT_RESIDUAL_PVC_SOTERRAT (9)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN-PVCS
Classification: 50.20.20.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Tapón - PVC - Serie 40:TAP_SANEJAMENT_RESIDUAL_PVC_SOTERRAT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: TAP_SANEJAMENT_RESIDUAL_PVC_SOTERRAT; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Tapón - PVC - Serie 40:TAP_SANEJAMENT_RESIDUAL_PVC_SOTERRAT:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 503.AMB.Altura (m) | 509.AMB.Volum (m3) | Group
3054676 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 40 mmø | 0.049276 | 0.000107977 | L3J_4_SAN_FECAL 3
3061550 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø | 0.054864 | 0.000176306 | L3J_4_SAN_FECAL 3
3061552 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø | 0.054864 | 0.000176306 | L3J_4_SAN_FECAL 3
3674452 | L3J_4_SAN_FECAL | Nau Santa Eulalia | 50 mmø | 0.054864 | 0.000176306 | L3J_4_SAN_FECAL 3
3682864 | L3J_4_SAN_FECAL | Annex | 125 mmø | 0.105082 | 0.00162727 | L3J_4_SAN_FECAL 3
3683187 | L3J_4_SAN_FECAL | Annex | 40 mmø | 0.049276 | 0.000107977 | L3J_4_SAN_FECAL 3
3803254 | L3J_4_SAN_PLUVIAL |  | 160 mmø | 0.128532 | 0.00312722 | L3J_4_SAN_PLUVIAL 3
3825672 | L3J_4_SAN_PLUVIAL |  | 160 mmø | 0.128532 | 0.00312722 | L3J_4_SAN_PLUVIAL 1
3826326 | L3J_4_SAN_PLUVIAL |  | 160 mmø | 0.128532 | 0.00312722 | L3J_4_SAN_PLUVIAL 8

# IfcFlowFitting: M_Te - PVC - Serie 40:Norma_RESIDUAL, M_Te - PVC - Serie 40:Norma_RESIDUAL:3671928
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN-PPR
Classification: 50.20.20.20 Uniformat (Uniformat); Group: L3J_4_SAN_FECAL 1 (2)
Pset_DistributionFlowElementCommon - Reference: M_Te - PVC - Serie 40:Norma_RESIDUAL; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Norma_RESIDUAL; 112.AMB.Servei: L3J_4_SAN_FECAL; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 50 mmø-50 mmø-50 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000811008 m3

# IfcFlowFitting: M_Te - PVC - Serie 40:TE_SANEJAMENT_RESIDUAL_PVC_SOTERRAT (39)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN-PVCS
Classification: 50.20.20.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Te - PVC - Serie 40:TE_SANEJAMENT_RESIDUAL_PVC_SOTERRAT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: TE_SANEJAMENT_RESIDUAL_PVC_SOTERRAT; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Te - PVC - Serie 40:TE_SANEJAMENT_RESIDUAL_PVC_SOTERRAT:...) | 112.AMB.Servei | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3659190 | L3J_4_SAN_PLUVIAL | 110 mmø-110 mmø-110 mmø | 0.00598194 | L3J_4_SAN_PLUVIAL 6 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Lateral Sud
3663148 | L3J_4_SAN_PLUVIAL | 110 mmø-110 mmø-110 mmø | 0.00598194 | L3J_4_SAN_PLUVIAL 6 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Lateral Sud
3677771 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3678808 | L3J_4_SAN_FECAL | 50 mmø-50 mmø-50 mmø | 0.000808884 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3679544 | L3J_4_SAN_FECAL | 50 mmø-50 mmø-50 mmø | 0.000808863 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3683877 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00775653 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Capella
3684922 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3685975 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3686119 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3687545 | L3J_4_SAN_FECAL | 110 mmø-110 mmø-110 mmø | 0.00598342 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3690401 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3690688 | L3J_4_SAN_FECAL | 90 mmø-90 mmø-90 mmø | 0.00350622 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3691505 | L3J_4_SAN_FECAL | 32 mmø-32 mmø-32 mmø | 0.000311196 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3692241 | L3J_4_SAN_FECAL | 32 mmø-32 mmø-32 mmø | 0.000311196 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3694366 | L3J_4_SAN_FECAL | 50 mmø-50 mmø-50 mmø | 0.000808863 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3766006 | L3J_4_SAN_FECAL | 32 mmø-32 mmø-32 mmø | 0.000284483 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3767289 | L3J_4_SAN_FECAL | 40 mmø-40 mmø-40 mmø | 0.000389885 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3825992 | L3J_4_SAN_PLUVIAL | 160 mmø-160 mmø-160 mmø | 0.016508 | L3J_4_SAN_PLUVIAL 8
4560635 | L3J_4_SAN_FECAL | 200 mmø-200 mmø-200 mmø | 0.0314156 | L3J_4_SAN_FECAL 3
5051474 | L3J_4_SAN_PLUVIAL | 200 mmø-200 mmø-200 mmø | 0.0314135 | L3J_4_SAN_PLUVIAL 3
5052337 | L3J_4_SAN_PLUVIAL | 200 mmø-200 mmø-200 mmø | 0.0314135 | L3J_4_SAN_PLUVIAL 3
5056453 | L3J_4_SAN_PLUVIAL | 160 mmø-160 mmø-160 mmø | 0.0166907 | L3J_4_SAN_PLUVIAL 3
5060342 | L3J_4_SAN_FECAL | 200 mmø-200 mmø-200 mmø | 0.0314166 | L3J_4_SAN_FECAL 3
5117656 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00665904 | L3J_4_SAN_FECAL 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
5208987 | L3J_4_SAN_PLUVIAL | 110 mmø-110 mmø-110 mmø | 0.00598196 | L3J_4_SAN_PLUVIAL 6 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Lateral Sud
5213438 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3
5213525 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3
5213763 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3
5213903 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3
5214092 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3
5214409 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00845921 | L3J_4_SAN_FECAL 3
5214499 | L3J_4_SAN_FECAL | 125 mmø-125 mmø-125 mmø | 0.00647548 | L3J_4_SAN_FECAL 3
5214764 | L3J_4_SAN_FECAL | 160 mmø-160 mmø-160 mmø | 0.0166907 | L3J_4_SAN_FECAL 3
5214919 | L3J_4_SAN_FECAL | 160 mmø-160 mmø-160 mmø | 0.0130575 | L3J_4_SAN_FECAL 3
5215075 | L3J_4_SAN_FECAL | 160 mmø-160 mmø-160 mmø | 0.0130575 | L3J_4_SAN_FECAL 3
5215157 | L3J_4_SAN_FECAL | 160 mmø-160 mmø-160 mmø | 0.0130575 | L3J_4_SAN_FECAL 3
5215232 | L3J_4_SAN_FECAL | 160 mmø-160 mmø-160 mmø | 0.0166907 | L3J_4_SAN_FECAL 3
5215320 | L3J_4_SAN_FECAL | 160 mmø-160 mmø-160 mmø | 0.0166907 | L3J_4_SAN_FECAL 3
5218808 | L3J_4_SAN_PLUVIAL | 125 mmø-125 mmø-125 mmø | 0.00772481 | L3J_4_SAN_PLUVIAL 6

# IfcFlowFitting: M_Te horizontal de canal:Radio 100 mm, M_Te horizontal de canal:Radio 100 mm:5167754
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.30.10; 105.AMB.ClassificacioDescripcio: Safates de distribució elèctrica; 109.AMB.CodiTipus: ELE-SMR
Classification: 50.60.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Te horizontal de canal:Radio 100 mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Radio 100 mm; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 504.AMB.Gruix: 0.00254 m; 509.AMB.Volum: 0.0149293 m3

# IfcFlowFitting: M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_AP (2)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_AP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TE_REC_CLIMA_FIBRA_AP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 350 mmx350 mm-350 mmx350 mm-250 mmx350 mm
5 AMB.Geometria - 509.AMB.Volum: 0.024 m3
Name (M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_AP:...) | 117.AMB.Localitzacio | Group
3641957 | Nau Lateral Sud | Mecánica L3J_3_VENT_APORT_AIRE 1
3758749 | Nau Santa Eulalia | Mecánica L3J_3_VENT_APORT_AIRE 2

# IfcFlowFitting: M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_EXT (4)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.20 Uniformat (Uniformat); Group: Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Pset_DistributionFlowElementCommon - Reference: M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TE_REC_CLIMA_FIBRA_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
Name (M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_EXT:...) | 242.AMB.Mida | 509.AMB.Volum (m3)
3163330 | 400 mmx250 mm-350 mmx250 mm-350 mmx250 mm | 0.02575
3163533 | 350 mmx150 mm-350 mmx150 mm-350 mmx150 mm | 0.01125
3446257 | 350 mmx150 mm-350 mmx150 mm-350 mmx150 mm | 0.01125
3876879 | 400 mmx150 mm-350 mmx150 mm-350 mmx150 mm | 0.012875

# IfcFlowFitting: M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_IMP (3)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TE_REC_CLIMA_FIBRA_IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_IMP:...) | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3434172 | Nau Santa Eulalia | 300 mmx200 mm-300 mmx200 mm-200 mmx200 mm | 0.0080625 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3435690 | Nau Santa Eulalia | 300 mmx250 mm-300 mmx250 mm-200 mmx250 mm | 0.01075 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3644875 | Nau Lateral Sud | 350 mmx200 mm-250 mmx200 mm-250 mmx200 mm | 0.011625 | Mecánica L3J_3_CLIMA_IMP_AIRE 9

# IfcFlowFitting: M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_RETORNO (12)
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.40 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_RETORNO; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TE_REC_CLIMA_FIBRA_RETORNO; 112.AMB.Servei: L3J_3_CLIMA_RET_AIRE; 119.AMB.FaseCreacio: Obra
Name (M_Te rectangular:L3J_TE_REC_CLIMA_FIBRA_RETORNO:...) | In | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3143902 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm-450 mmx150 mm-450 mmx150 mm | 0.019 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3147281 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm-450 mmx150 mm-450 mmx150 mm | 0.019 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3163829 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 600 mmx200 mm-600 mmx200 mm-450 mmx200 mm | 0.038625 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3439780 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm-300 mmx200 mm-300 mmx200 mm | 0.0121875 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3482365 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm-150 mmx450 mm | 0.007 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3485548 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx450 mm-150 mmx450 mm-150 mmx450 mm | 0.007 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3638770 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 350 mmx250 mm-350 mmx250 mm-250 mmx250 mm | 0.016 | Mecánica L3J_3_CLIMA_RET_AIRE 2
3656812 | PLANTA COBERTA | PLANTA COBERTA | Nau Lateral Sud | 450 mmx350 mm-450 mmx350 mm-450 mmx350 mm | 0.057 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3761287 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx600 mm-200 mmx600 mm-200 mmx600 mm | 0.0281875 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3868194 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx150 mm-250 mmx150 mm-250 mmx150 mm | 0.0055 | Mecánica L3J_3_CLIMA_RET_AIRE 6
3871739 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 950 mmx250 mm-350 mmx250 mm-350 mmx250 mm | 0.0615 | Mecánica L3J_3_CLIMA_RET_AIRE 12
4541606 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 300 mmx400 mm-300 mmx400 mm-300 mmx400 mm | 0.0284375 | Mecánica L3J_3_CLIMA_RET_AIRE 1

# IfcFlowFitting: M_Te rectangular:L3J_TE_REC_CLIMA_XAPA_EXT, M_Te rectangular:L3J_TE_REC_CLIMA_XAPA_EXT:4542012
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.20 Uniformat (Uniformat); Group: Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Pset_DistributionFlowElementCommon - Reference: M_Te rectangular:L3J_TE_REC_CLIMA_XAPA_EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TE_REC_CLIMA_XAPA_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 410 mmx410 mm-310 mmx410 mm-310 mmx410 mm
5 AMB.Geometria - 509.AMB.Volum: 0.02325 m3

# IfcFlowFitting: M_Te redonda:IMP, M_Te redonda:IMP:3770878
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.30 Uniformat (Uniformat); Group: Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Pset_DistributionFlowElementCommon - Reference: M_Te redonda:IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: IMP; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 100 mmø-100 mmø-100 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.00202278 m3

# IfcFlowFitting: M_Te redonda:L3J_TE_CIRC_XAPA_EXT, M_Te redonda:L3J_TE_CIRC_XAPA_EXT:3020588
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.20 Uniformat (Uniformat); Group: Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Pset_DistributionFlowElementCommon - Reference: M_Te redonda:L3J_TE_CIRC_XAPA_EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TE_CIRC_XAPA_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 100 mmø-100 mmø-100 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.00202278 m3

# IfcFlowFitting: M_Te redonda:XAPA_IMP (3)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.30 Uniformat (Uniformat); Group: Mecánica L3J_3_CLIMA_IMP_AIRE 10
Pset_DistributionFlowElementCommon - Reference: M_Te redonda:XAPA_IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: XAPA_IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 450 mmø-450 mmø-350 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.078168 m3
Name (M_Te redonda:XAPA_IMP:...)
3388189
3388339
3391879

# IfcFlowFitting: M_Transición de rectangular a redondo - Ángulo:45 grados_EXT (5)
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición de rectangular a redondo - Ángulo:45 grados_EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: 45 grados_EXT; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
Name (M_Transición de rectangular a redondo - Ángulo:45 grados_EXT:...) | In | 112.AMB.Servei | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3713851 | PLANTA COBERTA | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA COBERTA | 350 mmø-350 mmx200 mm | 0.163902 | 0.0158409 | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
3714247 | PLANTA COBERTA | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA COBERTA | 460 mmø-460 mmx310 mm | 0.163902 | 0.0158409 | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
3720001 | PLANTA COBERTA | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA COBERTA | 350 mmø-300 mmx300 mm | 0.0939729 | 0.00585872 | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
3721618 | PLANTA COBERTA | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA COBERTA | 460 mmø-410 mmx410 mm | 0.0939721 | 0.00585872 | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
5251299 | PLANTA BAIXA | L3J_3_CLIMA_IMP_AIRE | PLANTA BAIXA | 230 mmx350 mm-230 mmø | 0.0835123 | 0.00592192 | Mecánica L3J_3_CLIMA_IMP_AIRE 1

# IfcFlowFitting: M_Transición de rectangular a redondo - Ángulo:45 grados_IMP, M_Transición de rectangular a redondo - Ángulo:45 grados_IMP:5253343
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.30 Uniformat (Uniformat); Group: Mecánica L3J_3_CLIMA_IMP_AIRE 10
Pset_DistributionFlowElementCommon - Reference: M_Transición de rectangular a redondo - Ángulo:45 grados_IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: 45 grados_IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 500 mmø-550 mmx350 mm
5 AMB.Geometria - 507.AMB.Area: 0.245896 m2; 509.AMB.Volum: 0.0295164 m3

# IfcFlowFitting: M_Transición de rectangular a redondo - Ángulo:45 grados_RET, M_Transición de rectangular a redondo - Ángulo:45 grados_RET:3643338
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.40 Uniformat (Uniformat); Group: Mecánica L3J_3_CLIMA_RET_AIRE 2
Pset_DistributionFlowElementCommon - Reference: M_Transición de rectangular a redondo - Ángulo:45 grados_RET; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: 45 grados_RET; 112.AMB.Servei: L3J_3_CLIMA_RET_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 350 mmx250 mm-325 mmø
5 AMB.Geometria - 507.AMB.Area: 0.0826103 m2; 509.AMB.Volum: 0.0056778 m3

# IfcFlowFitting: M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_AP (5)
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_AP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_AP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 119.AMB.FaseCreacio: Obra
Name (M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_AP:...) | In | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3528896 | P0_NL | P0_NL | Nau Lateral Sud | 460 mmø-410 mmx410 mm | 0.0939721 | 0.00585872 | Mecánica L3J_3_VENT_APORT_AIRE 1
3644390 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 250 mmø-250 mmx200 mm | 0.0406305 | 0.00193974 | Mecánica L3J_3_VENT_APORT_AIRE 1
3715436 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 460 mmø-460 mmx310 mm | 0.163902 | 0.0158409 | Mecánica L3J_3_VENT_APORT_AIRE 6
3722122 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 460 mmø-410 mmx410 mm | 0.0939721 | 0.00585872 | Mecánica L3J_3_VENT_APORT_AIRE 5
4541556 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 350 mmø-350 mmx250 mm | 0.105383 | 0.00827616 | Mecánica L3J_3_VENT_APORT_AIRE 1

# IfcFlowFitting: M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_IMP (18)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_IMP:...) | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3434426 | Nau Santa Eulalia | 225 mmø-200 mmx200 mm | 0.023493 | 0.00073234 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3436625 | Nau Santa Eulalia | 225 mmø-200 mmx200 mm | 0.023493 | 0.00073234 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3438527 | Nau Santa Eulalia | 300 mmx150 mm-225 mmø | 0.0468982 | 0.00240449 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3438841 | Nau Santa Eulalia | 225 mmø-200 mmx200 mm | 0.023493 | 0.00073234 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3461801 | Nau Santa Eulalia | 200 mmx200 mm-175 mmø | 0.018172 | 0.000538388 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3469853 | Nau Santa Eulalia | 200 mmx250 mm-230 mmø | 0.028851 | 0.00104954 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3469922 | Nau Santa Eulalia | 250 mmx200 mm-230 mmø | 0.028851 | 0.00104954 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3475233 | Nau Santa Eulalia | 225 mmø-200 mmx200 mm | 0.023493 | 0.00073234 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3475572 | Nau Santa Eulalia | 200 mmx200 mm-200 mmø | 0.0225 | 0.000783393 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3645017 | Nau Lateral Sud | 275 mmø-250 mmx200 mm | 0.0572425 | 0.00329346 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3645413 | Nau Lateral Sud | 275 mmø-250 mmx200 mm | 0.0572425 | 0.00329346 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3876056 | Nau Santa Eulalia | 250 mmø-250 mmx200 mm | 0.0406305 | 0.00193974 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
5251136 | Nau Santa Eulalia | 250 mmx200 mm-230 mmø | 0.028851 | 0.00104954 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
5251149 | Nau Santa Eulalia | 200 mmx250 mm-230 mmø | 0.028851 | 0.00104954 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
5251171 | Nau Santa Eulalia | 230 mmx250 mm-230 mmø | 0.0262116 | 0.000769707 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
5251337 | Nau Santa Eulalia | 250 mmx350 mm-250 mmø | 0.0803144 | 0.00569014 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
5251342 | Nau Santa Eulalia | 250 mmx350 mm-250 mmø | 0.0803144 | 0.00569014 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
5251590 | Nau Santa Eulalia | 200 mmx350 mm-175 mmø | 0.0903274 | 0.00601318 | Mecánica L3J_3_CLIMA_IMP_AIRE 4

# IfcFlowFitting: M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_RET (2)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.40 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_RET; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_RET; 112.AMB.Servei: L3J_3_CLIMA_RET_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
Name (M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_FIBRA_RET:...) | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
5249960 | 250 mmx250 mm-250 mmø | 0.04 | 0.00185693 | Mecánica L3J_3_CLIMA_RET_AIRE 2
5250113 | 450 mmx350 mm-350 mmø | 0.132454 | 0.0118975 | Mecánica L3J_3_CLIMA_RET_AIRE 1

# IfcFlowFitting: M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_XAPA_EXT, M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_XAPA_EXT:3528506
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.20 Uniformat (Uniformat); Group: Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Pset_DistributionFlowElementCommon - Reference: M_Transición de rectangular a redondo - Ángulo:L3J_TRANSICION_REC_CIRC_CLIMA_XAPA_EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TRANSICION_REC_CIRC_CLIMA_XAPA_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 460 mmø-410 mmx410 mm
5 AMB.Geometria - 507.AMB.Area: 0.0939721 m2; 509.AMB.Volum: 0.00585872 m3

# IfcFlowFitting: M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_AP (4)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_AP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_45º_REC_CLIMA_FIBRA_AP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_AP:...) | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3656921 | Nau Lateral Sud | 350 mmx350 mm-350 mmx250 mm | 0.0902939 | 0.0090533 | Mecánica L3J_3_VENT_APORT_AIRE 1
3872829 | Nau Santa Eulalia | 150 mmx200 mm-200 mmx150 mm | 0.0194382 | 0.000930478 | Mecánica L3J_3_VENT_APORT_AIRE 3
5250135 | Nau Lateral Sud | 250 mmx350 mm-200 mmx250 mm | 0.0599037 | 0.00533139 | Mecánica L3J_3_VENT_APORT_AIRE 1
5258648 | Nau Santa Eulalia | 200 mmx150 mm-200 mmx150 mm | 0.0125088 | 0.000375 | Mecánica L3J_3_VENT_APORT_AIRE 3

# IfcFlowFitting: M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_EXT (15)
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_45º_REC_CLIMA_FIBRA_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 119.AMB.FaseCreacio: Obra
Name (M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_EXT:...) | In | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3446434 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm-350 mmx150 mm | 0.0288921 | 0.00105887 | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
3465683 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx200 mm-300 mmx150 mm | 0.024602 | 0.000909543 | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
3465870 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm-200 mmx150 mm | 0.0169349 | 0.000610887 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3466703 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx250 mm-300 mmx150 mm | 0.042049 | 0.00244355 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
5244917 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm-350 mmx150 mm | 0.0288921 | 0.00105887 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
5245029 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx250 mm-250 mmx200 mm | 0.0277156 | 0.00114032 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
5245032 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx250 mm-300 mmx150 mm | 0.042049 | 0.00244355 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
5245037 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx250 mm-300 mmx150 mm | 0.042049 | 0.00244355 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
5255710 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 410 mmx310 mm-310 mmx410 mm | 0.0586787 | 0.00401828 | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
5258030 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx350 mm-350 mmx250 mm | 0.0677394 | 0.0048871 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
5258032 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx250 mm-400 mmx150 mm | 0.0569138 | 0.00342097 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
5258035 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-350 mmx150 mm | 0.0494814 | 0.00293226 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
5258041 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-350 mmx150 mm | 0.0494814 | 0.00293226 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
5258043 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-350 mmx150 mm | 0.0494814 | 0.00293226 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
5258177 | PLANTA COBERTA | PLANTA COBERTA | Nau Lateral Sud | 350 mmx250 mm-250 mmx200 mm | 0.0465559 | 0.00287796 | Mecánica L3J_VENTILACIÓ_CTE_HS3 6

# IfcFlowFitting: M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_IMP (8)
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_45º_REC_CLIMA_FIBRA_IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 119.AMB.FaseCreacio: Obra
Name (M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_IMP:...) | In | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3117014 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm-350 mmx200 mm | 0.303839 | 0.0413762 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3644835 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 950 mmx320 mm-350 mmx250 mm | 0.291125 | 0.0375399 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3646954 | PLANTA COBERTA | PLANTA COBERTA | Nau Lateral Sud | 1300 mmx410 mm-550 mmx350 mm | 0.637739 | 0.130719 | Mecánica L3J_3_CLIMA_IMP_AIRE 10
3876057 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-250 mmx200 mm | 0.0445684 | 0.00263179 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
4957273 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 950 mmx320 mm-350 mmx250 mm | 0.345608 | 0.0516593 | Mecánica L3J_3_CLIMA_IMP_AIRE 8
5257597 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm-200 mmx450 mm | 0.0820308 | 0.0077464 | Mecánica L3J_3_CLIMA_IMP_AIRE 11
5257814 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx350 mm-350 mmx250 mm | 0.137395 | 0.0160215 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
5258123 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 350 mmx250 mm-350 mmx200 mm | 0.03916 | 0.00156418 | Mecánica L3J_3_CLIMA_IMP_AIRE 9

# IfcFlowFitting: M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_RET (3)
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.40 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_RET; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_45º_REC_CLIMA_FIBRA_RET; 112.AMB.Servei: L3J_3_CLIMA_RET_AIRE; 119.AMB.FaseCreacio: Obra
Name (M_Transición rectangular - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_RET:...) | In | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3643008 | PLANTA BAIXA | PLANTA BAIXA | Nau Lateral Sud | 950 mmx320 mm-350 mmx250 mm | 0.261336 | 0.0325581 | Mecánica L3J_3_CLIMA_RET_AIRE 2
3668512 | PLANTA COBERTA | PLANTA COBERTA | Nau Lateral Sud | 1300 mmx410 mm-450 mmx400 mm | 0.728372 | 0.162607 | Mecánica L3J_3_CLIMA_RET_AIRE 1
3871686 | PLANTA COBERTA | PLANTA COBERTA | Nau Santa Eulalia | 950 mmx320 mm-950 mmx250 mm | 0.157482 | 0.00964304 | Mecánica L3J_3_CLIMA_RET_AIRE 12

# IfcFlowFitting: M_Transición rectangular - Ángulo:L3J_TOLVA_60º_REC_CLIMA_FIBRA_AP (7)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición rectangular - Ángulo:L3J_TOLVA_60º_REC_CLIMA_FIBRA_AP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_60º_REC_CLIMA_FIBRA_AP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
Name (M_Transición rectangular - Ángulo:L3J_TOLVA_60º_REC_CLIMA_FIBRA_AP:...) | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3471681 | 400 mmx250 mm-450 mmx150 mm | 0.0692484 | 0.00483531 | Mecánica L3J_3_VENT_APORT_AIRE 3
3764053 | 300 mmx600 mm-250 mmx300 mm | 0.127138 | 0.015805 | Mecánica L3J_3_VENT_APORT_AIRE 2
3764278 | 350 mmx350 mm-300 mmx250 mm | 0.0697608 | 0.00399334 | Mecánica L3J_3_VENT_APORT_AIRE 2
3867996 | 300 mmx250 mm-200 mmx150 mm | 0.0361563 | 0.00178016 | Mecánica L3J_3_VENT_APORT_AIRE 3
3873241 | 250 mmx250 mm-250 mmx200 mm | 0.0267315 | 0.00101036 | Mecánica L3J_3_VENT_APORT_AIRE 2
3873243 | 200 mmx250 mm-200 mmx200 mm | 0.0239115 | 0.00113666 | Mecánica L3J_3_VENT_APORT_AIRE 2
5257968 | 250 mmx350 mm-250 mmx300 mm | 0.0427841 | 0.00238157 | Mecánica L3J_3_VENT_APORT_AIRE 2

# IfcFlowFitting: M_Transición rectangular - Ángulo:L3J_TOLVA_60º_REC_CLIMA_FIBRA_IMP (12)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición rectangular - Ángulo:L3J_TOLVA_60º_REC_CLIMA_FIBRA_IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_60º_REC_CLIMA_FIBRA_IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
Name (M_Transición rectangular - Ángulo:L3J_TOLVA_60º_REC_CLIMA_FIBRA_IMP:...) | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3431695 | 900 mmx320 mm-300 mmx200 mm | 0.313254 | 0.0420888 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3433262 | 900 mmx320 mm-300 mmx250 mm | 0.32194 | 0.0459859 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3434292 | 300 mmx200 mm-200 mmx200 mm | 0.0330422 | 0.00173205 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3445612 | 900 mmx320 mm-350 mmx250 mm | 0.226639 | 0.0270419 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3469819 | 200 mmx350 mm-200 mmx250 mm | 0.0435705 | 0.0032476 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3483074 | 900 mmx320 mm-350 mmx250 mm | 0.311482 | 0.0439267 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3867521 | 900 mmx320 mm-300 mmx200 mm | 0.312725 | 0.0420888 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3870422 | 900 mmx320 mm-350 mmx250 mm | 0.311481 | 0.0439267 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
5249778 | 300 mmx250 mm-300 mmx150 mm | 0.0485705 | 0.0032476 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
5249780 | 200 mmx250 mm-200 mmx200 mm | 0.0239115 | 0.00113666 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
5251296 | 350 mmx200 mm-250 mmx200 mm | 0.0479006 | 0.0032476 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
5251505 | 350 mmx200 mm-200 mmx200 mm | 0.0573534 | 0.00438425 | Mecánica L3J_3_CLIMA_IMP_AIRE 4

# IfcFlowFitting: M_Transición rectangular - Ángulo:L3J_TOLVA_60º_REC_CLIMA_FIBRA_RET (16)
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.40 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición rectangular - Ángulo:L3J_TOLVA_60º_REC_CLIMA_FIBRA_RET; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_60º_REC_CLIMA_FIBRA_RET; 112.AMB.Servei: L3J_3_CLIMA_RET_AIRE; 119.AMB.FaseCreacio: Obra
Name (M_Transición rectangular - Ángulo:L3J_TOLVA_60º_REC_CLIMA_FIBRA_RET:...) | In | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3428077 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm-300 mmx200 mm | 0.313254 | 0.0420888 | Mecánica L3J_3_CLIMA_RET_AIRE 7
3445698 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm-350 mmx200 mm | 0.401338 | 0.0601346 | Mecánica L3J_3_CLIMA_RET_AIRE 10
3482325 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm-450 mmx150 mm | 0.366516 | 0.0475448 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3485388 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm-450 mmx150 mm | 0.366516 | 0.0475448 | Mecánica L3J_3_CLIMA_RET_AIRE 5
3760775 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm-600 mmx200 mm | 0.293759 | 0.0389711 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3864930 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm-300 mmx250 mm | 0.426487 | 0.0689789 | Mecánica L3J_3_CLIMA_RET_AIRE 11
3866906 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm-250 mmx150 mm | 0.426298 | 0.0598568 | Mecánica L3J_3_CLIMA_RET_AIRE 6
3868282 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx150 mm-200 mmx150 mm | 0.0188277 | 0.000757772 | Mecánica L3J_3_CLIMA_RET_AIRE 6
3870861 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 600 mmx200 mm-450 mmx150 mm | 0.10227 | 0.00779423 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3870863 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx200 mm-450 mmx150 mm | 0.0463666 | 0.00216506 | Mecánica L3J_3_CLIMA_RET_AIRE 3
5250114 | PLANTA COBERTA | PLANTA COBERTA | Nau Lateral Sud | 450 mmx400 mm-450 mmx350 mm | 0.0906967 | 0.00562917 | Mecánica L3J_3_CLIMA_RET_AIRE 1
5250115 | PLANTA COBERTA | PLANTA COBERTA | Nau Lateral Sud | 450 mmx350 mm-400 mmx300 mm | 0.076244 | 0.00447446 | Mecánica L3J_3_CLIMA_RET_AIRE 1
5259513 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm-400 mmx150 mm | 0.0508862 | 0.00321151 | Mecánica L3J_3_CLIMA_RET_AIRE 7
5259534 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx250 mm-400 mmx150 mm | 0.0567404 | 0.00382495 | Mecánica L3J_3_CLIMA_RET_AIRE 11
5259540 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx200 mm-450 mmx150 mm | 0.0584297 | 0.00375278 | Mecánica L3J_3_CLIMA_RET_AIRE 10
5259562 | PLANTA BAIXA | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx450 mm-350 mmx250 mm | 0.100297 | 0.0112583 | Mecánica L3J_3_CLIMA_RET_AIRE 12

# IfcFlowFitting: M_Transición rectangular - Ángulo:L3J_TOLVA_89º_REC_CLIMA_XAPA_IMP, M_Transición rectangular - Ángulo:L3J_TOLVA_89º_REC_CLIMA_XAPA_IMP:3873626
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.30 Uniformat (Uniformat); Group: Mecánica L3J_3_VENT_APORT_AIRE 3
Pset_DistributionFlowElementCommon - Reference: M_Transición rectangular - Ángulo:L3J_TOLVA_89º_REC_CLIMA_XAPA_IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_89º_REC_CLIMA_XAPA_IMP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 300 mmx250 mm-450 mmx150 mm
5 AMB.Geometria - 507.AMB.Area: 0.057754 m2; 509.AMB.Volum: 0.00362523 m3

# IfcFlowFitting: M_Transición redonda - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_EXT (6)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición redonda - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_45º_REC_CLIMA_FIBRA_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 125 mmø-100 mmø
5 AMB.Geometria - 507.AMB.Area: 0.0134759 m2; 509.AMB.Volum: 0.000301122 m3
Name (M_Transición redonda - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_EXT:...) | 117.AMB.Localitzacio | Group
3673698 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
3771446 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3771608 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
4968812 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
4968814 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
4968983 | Annex | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8

# IfcFlowFitting: M_Transición redonda - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_IMP (17)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: M_Transición redonda - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_45º_REC_CLIMA_FIBRA_IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (M_Transición redonda - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_IMP:...) | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 509.AMB.Volum (m3) | Group
3434427 | Nau Santa Eulalia | 225 mmø-175 mmø | 0.030415 | 0.00107618 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3436605 | Nau Santa Eulalia | 225 mmø-175 mmø | 0.030415 | 0.00107618 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3436626 | Nau Santa Eulalia | 225 mmø-175 mmø | 0.030415 | 0.00107627 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3438839 | Nau Santa Eulalia | 225 mmø-175 mmø | 0.030415 | 0.00107618 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3469654 | Nau Santa Eulalia | 230 mmø-175 mmø | 0.0330897 | 0.00122551 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3469851 | Nau Santa Eulalia | 230 mmø-175 mmø | 0.0330897 | 0.0012256 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3469920 | Nau Santa Eulalia | 230 mmø-175 mmø | 0.0330897 | 0.0012256 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3472525 | Nau Santa Eulalia | 230 mmø-175 mmø | 0.0330897 | 0.0012256 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3475231 | Nau Santa Eulalia | 225 mmø-175 mmø | 0.030415 | 0.00107618 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3475574 | Nau Santa Eulalia | 200 mmø-175 mmø | 0.018172 | 0.000449208 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3478077 | Nau Santa Eulalia | 230 mmø-175 mmø | 0.0330897 | 0.0012256 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3484975 | Nau Santa Eulalia | 230 mmø-175 mmø | 0.0330897 | 0.0012256 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3516932 | Nau Santa Eulalia | 250 mmø-175 mmø | 0.0445416 | 0.00191053 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3645018 | Nau Lateral Sud | 275 mmø-175 mmø | 0.0605517 | 0.00298205 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3645414 | Nau Lateral Sud | 275 mmø-175 mmø | 0.0605517 | 0.00298205 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3876479 | Nau Santa Eulalia | 250 mmø-175 mmø | 0.0445416 | 0.00191053 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3876508 | Nau Santa Eulalia | 250 mmø-175 mmø | 0.0445416 | 0.00191058 | Mecánica L3J_3_CLIMA_IMP_AIRE 5

# IfcFlowFitting: M_Transición redonda - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_RET, M_Transición redonda - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_RET:3643336
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.40 Uniformat (Uniformat); Group: Mecánica L3J_3_CLIMA_RET_AIRE 2
Pset_DistributionFlowElementCommon - Reference: M_Transición redonda - Ángulo:L3J_TOLVA_45º_REC_CLIMA_FIBRA_RET; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TOLVA_45º_REC_CLIMA_FIBRA_RET; 112.AMB.Servei: L3J_3_CLIMA_RET_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 325 mmø-175 mmø
5 AMB.Geometria - 507.AMB.Area: 0.0982226 m2; 509.AMB.Volum: 0.00595481 m3

# IfcFlowFitting: Rectangular Transition Pants - DTL:L3J_UNION_REC_CLIMA_FIBRA_AP, Rectangular Transition Pants - DTL:L3J_UNION_REC_CLIMA_FIBRA_AP:3515028
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.10 Uniformat (Uniformat); Group: Mecánica L3J_3_VENT_APORT_AIRE 2
Pset_DistributionFlowElementCommon - Reference: Rectangular Transition Pants - DTL:L3J_UNION_REC_CLIMA_FIBRA_AP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_UNION_REC_CLIMA_FIBRA_AP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 250 mmx200 mm-250 mmx200 mm-250 mmx200 mm
5 AMB.Geometria - 501.AMB.Longitud: 0.25 m; 507.AMB.Area: 0.119707 m2; 509.AMB.Volum: 0.01125 m3

# IfcFlowFitting: Rectangular Wye - Smooth Radius:EXT (4)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.20 Uniformat (Uniformat); Group: Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Pset_DistributionFlowElementCommon - Reference: Rectangular Wye - Smooth Radius:EXT; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
Name (Rectangular Wye - Smooth Radius:EXT:...) | 242.AMB.Mida | 509.AMB.Volum (m3)
3181914 | 300 mmx250 mm-250 mmx250 mm-300 mmx250 mm | 0.0433507
3182808 | 350 mmx250 mm-300 mmx250 mm-300 mmx250 mm | 0.0493667
3183059 | 250 mmx200 mm-200 mmx200 mm-250 mmx200 mm | 0.0212922
3464076 | 400 mmx250 mm-350 mmx250 mm-300 mmx250 mm | 0.0553827

# IfcFlowFitting: Rectangular Wye - Smooth Radius:IMP (8)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Rectangular Wye - Smooth Radius:IMP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
Name (Rectangular Wye - Smooth Radius:IMP:...) | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3184136 | 300 mmx250 mm-200 mmx250 mm-200 mmx250 mm | 0.0209776 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3184276 | 250 mmx350 mm-250 mmx350 mm-200 mmx350 mm | 0.028613 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3204640 | 250 mmx350 mm-200 mmx350 mm-230 mmx350 mm | 0.0345938 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3257107 | 300 mmx200 mm-200 mmx200 mm-200 mmx200 mm | 0.0157332 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3261785 | 250 mmx350 mm-250 mmx350 mm-250 mmx350 mm | 0.0405346 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3262832 | 200 mmx350 mm-200 mmx350 mm-200 mmx350 mm | 0.023363 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3476860 | 350 mmx250 mm-300 mmx250 mm-230 mmx250 mm | 0.0312626 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3876090 | 250 mmx350 mm-250 mmx350 mm-250 mmx350 mm | 0.0405346 | Mecánica L3J_3_CLIMA_IMP_AIRE 5

# IfcFlowFitting: Rectangular Wye - Smooth Radius:L3J_UNION_REC_CLIMA_FIBRA_AP (3)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari
Classification: 50.30.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Rectangular Wye - Smooth Radius:L3J_UNION_REC_CLIMA_FIBRA_AP; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_UNION_REC_CLIMA_FIBRA_AP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
Name (Rectangular Wye - Smooth Radius:L3J_UNION_REC_CLIMA_FIBRA_AP:...) | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
