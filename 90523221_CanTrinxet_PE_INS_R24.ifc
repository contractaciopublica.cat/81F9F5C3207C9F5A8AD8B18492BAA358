Properties of the parts of a building model (IFC2X3), part 8 of 10

# IfcFlowFitting: Rectangular Wye - Smooth Radius:L3J_UNION_REC_CLIMA_FIBRA_AP (3)
Name (Rectangular Wye - Smooth Radius:L3J_UNION_REC_CLIMA_FIBRA_AP:...) | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3470433 | 300 mmx250 mm-300 mmx250 mm-300 mmx250 mm | 0.0441785 | Mecánica L3J_3_VENT_APORT_AIRE 3
3471222 | 400 mmx250 mm-300 mmx250 mm-400 mmx250 mm | 0.0812114 | Mecánica L3J_3_VENT_APORT_AIRE 3
3513926 | 300 mmx250 mm-250 mmx250 mm-200 mmx250 mm | 0.0245855 | Mecánica L3J_3_VENT_APORT_AIRE 2

# IfcFlowSegment: Cable Tray with Fittings:L3J_SAFATA_INST_ELECTRICA_PEMSA MOD.PEMSABAND (17)
In: PLANTA BAIXA
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.30.10; 105.AMB.ClassificacioDescripcio: Safates de distribució elèctrica; 109.AMB.CodiTipus: ELE-SMR
Classification: 50.60.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Cable Tray with Fittings:L3J_SAFATA_INST_ELECTRICA_PEMSA MOD.PEMSABAND; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_SAFATA_INST_ELECTRICA_PEMSA MOD.PEMSABAND; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 503.AMB.Altura: 0.1 m; sets with these values: 2
Name (Cable Tray with Fittings:L3J_SAFATA_INST_ELECTRICA_PEMSA MOD.PEMSABAND:...) | Length (m) = 501.AMB.Longitud (m) | 502.AMB.Amplada (m)
3239115 | 2.66 | 0.3
3239391 | 1.11263 | 0.2
3239923 | 2.74 | 0.3
3240639 | 1.1351 | 0.2
3240889 | 0.317662 | 0.2
3241085 | 16.6781 | 0.2
3244965 | 1.34 | 0.2
3246021 | 1.35659 | 0.2
3246383 | 0.309175 | 0.2
5166806 | 0.126954 | 0.2
5166988 | 0.117474 | 0.2
5167000 | 1.34575 | 0.2
5167123 | 0.375736 | 0.2
5167131 | 0.00783558 | 0.2
5167332 | 0.205606 | 0.2
5167333 | 0.119567 | 0.2
5167755 | 16.1281 | 0.2

# IfcFlowSegment: Flex Duct Round:L3J_COND_FLEX_CIRC_CLIMA_EXT (6)
In: PLANTA BAIXA
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-CCFL
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Flex Duct Round:L3J_COND_FLEX_CIRC_CLIMA_EXT; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_FLEX_CIRC_CLIMA_EXT; 112.AMB.Servei: L3J_3_VENTILACIÓ_CTE_HS3; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 100 mmø
5 AMB.Geometria - 505.AMB.Diametre: 0.1 m
Name (Flex Duct Round:L3J_COND_FLEX_CIRC_CLIMA_EXT:...) | Length (m) = 501.AMB.Longitud (m) | 117.AMB.Localitzacio | Group
3159077 | 0.319956 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
3197467 | 0.338644 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
3198730 | 0.407352 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
3350058 | 0.411622 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3771601 | 0.414359 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
4792889 | 0.347063 | Annex | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8

# IfcFlowSegment: Flex Duct Round:L3J_COND_FLEX_CIRC_CLIMA_IMP (21)
In: PLANTA BAIXA
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.30; 105.AMB.ClassificacioDescripcio: Impulsió de aire tractat; 109.AMB.CodiTipus: CLI-CCFL
Classification: 50.30.40.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Flex Duct Round:L3J_COND_FLEX_CIRC_CLIMA_IMP; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_FLEX_CIRC_CLIMA_IMP; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (Flex Duct Round:L3J_COND_FLEX_CIRC_CLIMA_IMP:...) | Length (m) = 501.AMB.Longitud (m) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 505.AMB.Diametre (m) | Group
3262361 | 1.01453 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 200 mmø | 0.2 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3434423 | 0.601634 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 175 mmø | 0.175 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3436392 | 0.416648 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 175 mmø | 0.175 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3436602 | 0.523919 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 175 mmø | 0.175 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3438836 | 0.315527 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 175 mmø | 0.175 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3460715 | 0.574377 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 125 mmø | 0.125 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3461798 | 0.500623 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 125 mmø | 0.125 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3469651 | 0.312847 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 230 mmø | 0.18 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3469828 | 0.36079 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 230 mmø | 0.18 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3469909 | 0.769106 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 230 mmø | 0.18 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3472515 | 0.819411 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 180 mmø | 0.18 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3475228 | 0.642552 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 225 mmø | 0.175 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3475569 | 0.802208 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 200 mmø | 0.15 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3478051 | 0.407935 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 180 mmø | 0.18 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3484960 | 0.265582 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 180 mmø | 0.18 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3639229 | 0.332386 | L3J_3_VENT_APORT_AIRE | Nau Lateral Sud | 250 mmø | 0.2 | Mecánica L3J_3_VENT_APORT_AIRE 1; Mecánica L3J_3_CLIMA_RET_AIRE 2
3645001 | 0.559902 | L3J_3_CLIMA_IMP_AIRE | Nau Lateral Sud | 275 mmø | 0.225 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3645394 | 0.698236 | L3J_3_CLIMA_IMP_AIRE | Nau Lateral Sud | 275 mmø | 0.225 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3657214 | 0.859531 | L3J_3_VENT_APORT_AIRE | Nau Lateral Sud | 350 mmø | 0.3 | Mecánica L3J_3_CLIMA_RET_AIRE 1; Mecánica L3J_3_VENT_APORT_AIRE 1
3876372 | 0.274986 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 250 mmø | 0.2 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3876474 | 0.251914 | L3J_3_CLIMA_IMP_AIRE | Nau Santa Eulalia | 250 mmø | 0.2 | Mecánica L3J_3_CLIMA_IMP_AIRE 5

# IfcFlowSegment: Flex Duct Round:L3J_COND_FLEX_CIRC_CLIMA_RET, Flex Duct Round:L3J_COND_FLEX_CIRC_CLIMA_RET:3643283
In: PLANTA BAIXA
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI-CCFL
Classification: 50.30.40.40 Uniformat (Uniformat); Group: Mecánica L3J_3_CLIMA_RET_AIRE 2
Pset_DistributionFlowElementCommon - Reference: Flex Duct Round:L3J_COND_FLEX_CIRC_CLIMA_RET; sets with these values: 2
Pset_FlowSegmentDuctSegment - Length: 1.3831 m; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_FLEX_CIRC_CLIMA_RET; 112.AMB.Servei: L3J_3_CLIMA_RET_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 275 mmø
5 AMB.Geometria - 501.AMB.Longitud: 1.3831 m; 505.AMB.Diametre: 0.275 m

# IfcFlowSegment: Pipe Types:L3J_TUBERIA_FONT_PE100 (19)
In: PLANTA BAIXA
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: CLI-PEX
Classification: 50.10.20.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:L3J_TUBERIA_FONT_PE100; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TUBERIA_FONT_PE100; 112.AMB.Servei: L3J_2_AFS; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:L3J_TUBERIA_FONT_PE100:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
2975691 | 11.2245 | -0.448 | 32 mmø | 1.12841 | 0.032 | L3J_2_AFS 1 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Capella
2975768 | 0.779714 | -0.4452 | 25 mmø | 0.0612386 | 0.025 | L3J_2_AFS 1 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
2975786 | 2.28775 | -0.414363 | 25 mmø | 0.17968 | 0.025 | L3J_2_AFS 1 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
2977581 | 1.60938 | 0.973812 | 32 mmø | 0.161793 | 0.032 | L3J_2_AFS 1 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Annex
2978055 | 0.406355 | 0.297033 | 25 mmø | 0.031915 | 0.025 | L3J_2_AFS 1 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
4009147 | 1.39373 | -0.414363 | 25 mmø | 0.109463 | 0.025 | AFS 3
4009149 | 0.250165 | -0.4452 | 25 mmø | 0.0196479 | 0.025 | AFS 3
4009183 | 32.0874 | -0.4452 | 25 mmø | 2.52014 | 0.025 | L3J_2_AFS 1 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
4009186 | 14.0639 | -0.4452 | 25 mmø | 1.10458 | 0.025 | L3J_2_AFS 1
4009188 | 0.399278 | -0.4452 | 25 mmø | 0.0313592 | 0.025 | L3J_2_AFS 1
4009190 | 1.41436 | -0.414363 | 25 mmø | 0.111084 | 0.025 | L3J_2_AFS 1
4009202 | 54.3567 | -0.448 | 32 mmø | 5.46453 | 0.032 | L3J_2_AFS 1
4009205 | 13.9336 | -0.448 | 32 mmø | 1.40076 | 0.032 | L3J_2_AFS 1
4009207 | 0.557728 | -0.448 | 32 mmø | 0.0560689 | 0.032 | L3J_2_AFS 1
4009209 | 1.41119 | -0.411188 | 32 mmø | 0.141868 | 0.032 | L3J_2_AFS 1
4009417 | 14.6493 | -0.4452 | 25 mmø | 1.15055 | 0.025 | AFS 3
4064514 | 1.33738 | -0.411188 | 32 mmø | 0.134448 | 0.032 | L3J_2_AFS 1 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Capella
4064575 | 0.33886 | 0.937 | 32 mmø | 0.0340659 | 0.032 | L3J_2_AFS 1 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Annex
4569213 | 0.697108 | -0.414363 | 25 mmø | 0.0547507 | 0.025 | AFS 3 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia

# IfcFlowSegment: Pipe Types:L3J_TUBERIA_FONT_PEX-AL-PEX (123)
In: PLANTA BAIXA
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: CLI-PEX
Classification: 50.10.20.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:L3J_TUBERIA_FONT_PEX-AL-PEX; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TUBERIA_FONT_PEX-AL-PEX; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:L3J_TUBERIA_FONT_PEX-AL-PEX:...) | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
2975569 | 0.101432 | 3.49585 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00509852 | 0.016 | L3J_2_AFS 1
2975754 | 1.71094 | 2.96842 | L3J_2_AFS | Annex | 25 mmø | 0.134377 | 0.025 | L3J_2_AFS 1
2976246 | 0.0964494 | 0.820146 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00484807 | 0.016 | L3J_2_AFS 1
2976255 | 2.83487 | 0.842084 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.142496 | 0.016 | L3J_2_AFS 1
2976393 | 0.194591 | 0.564 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00978122 | 0.016 | L3J_2_AFS 1
2976402 | 2.88179 | 0.585938 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.144854 | 0.016 | L3J_2_AFS 1
2976405 | 0.710077 | 3.4941 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0446155 | 0.02 | L3J_2_AFS 1
2976636 | 0.13824 | 0.86225 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.00868585 | 0.02 | L3J_2_AFS 2
2976747 | 0.0940625 | 1.594 | L3J_2_AFS | Annex | 16 mmø | 0.0047281 | 0.016 | L3J_2_AFS 1
2976783 | 3.21813 | 1.61594 | L3J_2_AFS | Annex | 16 mmø | 0.161761 | 0.016 | L3J_2_AFS 1
2976849 | 0.768285 | 4.844 | L3J_2_AFS | Annex | 16 mmø | 0.0386182 | 0.016 | L3J_2_AFS 1
2976862 | 3.21812 | 1.61594 | L3J_2_AFS | Annex | 16 mmø | 0.161761 | 0.016 | L3J_2_AFS 1
2976865 | 0.0678169 | 1.594 | L3J_2_AFS | Annex | 16 mmø | 0.00340885 | 0.016 | L3J_2_AFS 1
2977261 | 1.68529 | 4.844 | L3J_2_AFS | Annex | 16 mmø | 0.0847119 | 0.016 | L3J_2_AFS 1
2977890 | 0.0340625 | 0.564 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00171217 | 0.016 | L3J_2_AFS 1
2977914 | 0.0458127 | 0.86225 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0028785 | 0.02 | L3J_2_AFS 1
2977937 | 0.9112 | 4.50335 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0572524 | 0.02 | L3J_2_AFS 1
2977946 | 1.32353 | 0.896612 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.10395 | 0.025 | L3J_2_AFS 1
2978219 | 3.90923 | 0.585938 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.196499 | 0.016 | L3J_2_AFS 1
2978222 | 0.0779571 | 0.564 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00391855 | 0.016 | L3J_2_AFS 1
2978282 | 1.34415 | 4.56073 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0675644 | 0.016 | L3J_2_AFS 1
2978352 | 0.0879484 | 4.5051 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00442077 | 0.016 | L3J_2_AFS 1
2978356 | 1.10062 | 4.56957 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0553234 | 0.016 | L3J_2_AFS 1
2978375 | 3.97369 | 0.585938 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.19974 | 0.016 | L3J_2_AFS 1
3019357 | 0.1204 | 0.864 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00605198 | 0.016 | L3J_2_AFS 1
3019403 | 0.135423 | 0.714 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00680709 | 0.016 | L3J_2_AFS 1
3019711 | 0.150832 | 2.06661 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0118463 | 0.025 | L3J_2_AFS 1
3019753 | 2.79813 | 0.885938 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.140649 | 0.016 | L3J_2_AFS 1
3019755 | 0.445755 | 3.694 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0224061 | 0.016 | L3J_2_AFS 1
3019782 | 2.94813 | 0.735937 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.148189 | 0.016 | L3J_2_AFS 1
3019784 | 0.144974 | 3.694 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00728717 | 0.016 | L3J_2_AFS 1
3033901 | 0.159984 | 0.692553 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0100521 | 0.02 | L3J_2_AFS 1
3033922 | 0.530892 | 3.49 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0416962 | 0.025 | L3J_2_AFS 1
3033938 | 0.159984 | 0.692553 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø | 0.0100521 | 0.02 | L3J_2_ACS 1
3034339 | 0.125905 | 0.86225 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø | 0.00791087 | 0.02 | L3J_2_ACS 1
3034341 | 0.170472 | 0.86225 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø | 0.0107111 | 0.02 | L3J_2_ACS 1
3034352 | 0.113261 | 0.86225 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø | 0.0071164 | 0.02 | L3J_2_ACS 1
3034712 | 0.0587614 | 0.86225 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.00369209 | 0.02 | L3J_2_AFS 1
3034722 | 0.159984 | 0.692553 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0100521 | 0.02 | L3J_2_AFS 1
3035854 | 0.159984 | 0.692553 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø | 0.0100521 | 0.02 | L3J_2_ACS 2
3035888 | 0.0848669 | 0.86225 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø | 0.00533234 | 0.02 | L3J_2_ACS 2
3035933 | 0.677937 | 0.86225 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø | 0.042596 | 0.02 | L3J_2_ACS 2
3035943 | 0.0725375 | 0.86225 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø | 0.00455767 | 0.02 | L3J_2_ACS 2
3293322 | 3.99507 | 0.887463 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.251018 | 0.02 | L3J_2_AFS 1
3293820 | 1.02216 | 4.89225 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0642239 | 0.02 | L3J_2_AFS 1
3293860 | 0.0575375 | 0.86225 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.00361519 | 0.02 | L3J_2_AFS 1
3348809 | 17.3179 | 4.55949 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 1.36014 | 0.025 | L3J_2_AFS 1
3348820 | 0.19854 | 4.56174 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0124746 | 0.02 | L3J_2_AFS 1
3349062 | 0.393533 | 1.68551 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0247264 | 0.02 | L3J_2_AFS 1
3349132 | 0.156313 | 1.71707 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.00982144 | 0.02 | L3J_2_AFS 1
3349171 | 2.82067 | 1.72104 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.177228 | 0.02 | L3J_2_AFS 1
3349732 | 0.19564 | 4.55949 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0153655 | 0.025 | L3J_2_AFS 1
3364494 | 0.742957 | 3.49997 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0373451 | 0.016 | L3J_2_AFS 1
3364496 | 1.30562 | 3.68689 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0656275 | 0.016 | L3J_2_AFS 1
3365940 | 1.01247 | 4.56349 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0508922 | 0.016 | L3J_2_AFS 1
3365953 | 0.810418 | 4.56349 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.040736 | 0.016 | L3J_2_AFS 1
3366018 | 0.194227 | 0.744 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0097629 | 0.016 | L3J_2_AFS 1
3366034 | 3.78762 | 0.765938 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.190386 | 0.016 | L3J_2_AFS 1
3767778 | 0.586802 | 3.694 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0294959 | 0.016 | L3J_2_AFS 1
3769570 | 0.122004 | 0.86225 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.00766576 | 0.02 | L3J_2_AFS 1
3769803 | 0.32594 | 0.54225 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0204794 | 0.02 | L3J_2_AFS 1
3769823 | 0.278725 | 0.567462 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0175128 | 0.02 | L3J_2_AFS 1
3769965 | 0.302537 | 0.567462 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.019009 | 0.02 | L3J_2_AFS 1
3771976 | 0.59712 | 3.694 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0300145 | 0.016 | L3J_2_AFS 1
3921378 | 0.708145 | 4.90894 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0355953 | 0.016 | L3J_2_AFS 1
3921391 | 0.353831 | 4.59151 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0177855 | 0.016 | L3J_2_AFS 1
3991213 | 0.43243 | 4.5051 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0217363 | 0.016 | L3J_2_AFS 1
3991422 | 0.0177726 | 4.53338 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.000893351 | 0.016 | L3J_2_AFS 1
3991556 | 0.0404968 | 4.5051 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00203559 | 0.016 | L3J_2_AFS 1
3991700 | 3.59983 | 0.887462 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.226184 | 0.02 | L3J_2_AFS 1
3991857 | 3.59983 | 0.887462 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.226184 | 0.02 | L3J_2_AFS 1
3992817 | 0.197624 | 4.53491 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0124171 | 0.02 | L3J_2_AFS 1
3993845 | 0.57987 | 4.50335 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0364343 | 0.02 | L3J_2_AFS 1
3994007 | 1.0207 | 4.74225 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0641327 | 0.02 | L3J_2_AFS 1
3994322 | 0.115075 | 4.76746 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.00723038 | 0.02 | L3J_2_AFS 1
4010934 | 1.20794 | 2.27142 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0948718 | 0.025 | L3J_2_AFS 1
4011279 | 0.0242823 | 2.23443 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.00190713 | 0.025 | L3J_2_AFS 1
4011299 | 0.480011 | 1.74378 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0377 | 0.025 | L3J_2_AFS 1
4011309 | 0.0368195 | 1.71315 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0028918 | 0.025 | L3J_2_AFS 1
4011319 | 1.61745 | 2.06661 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0813019 | 0.016 | L3J_2_AFS 1
4011739 | 0.129605 | 1.74378 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0101791 | 0.025 | L3J_2_AFS 1
4012051 | 0.15078 | 3.694 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00757901 | 0.016 | L3J_2_AFS 1
4012053 | 0.230321 | 3.694 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0115772 | 0.016 | L3J_2_AFS 1
4012707 | 0.0570757 | 0.893812 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.00358617 | 0.02 | L3J_2_AFS 1
4012738 | 0.154662 | 0.960601 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0097177 | 0.02 | L3J_2_AFS 1
4012751 | 0.132751 | 0.570637 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0104262 | 0.025 | L3J_2_AFS 1
4012762 | 0.0890985 | 0.54 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.00699778 | 0.025 | L3J_2_AFS 1
4012856 | 0.0542763 | 0.896612 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.00341028 | 0.02 | L3J_2_AFS 1
4013182 | 2.90873 | 0.570638 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.228451 | 0.025 | L3J_2_AFS 1
4058032 | 0.181943 | 2.23713 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0142898 | 0.025 | L3J_2_AFS 1
4058042 | 0.1888 | 0.514588 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0118626 | 0.02 | L3J_2_AFS 1
4058052 | 0.199383 | 0.489376 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0125276 | 0.02 | L3J_2_AFS 1
4058062 | 1.87507 | 0.514588 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.117814 | 0.02 | L3J_2_AFS 1
4058075 | 0.285075 | 2.39938 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0179118 | 0.02 | L3J_2_AFS 1
4058109 | 2.06905 | 2.42459 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.130002 | 0.02 | L3J_2_AFS 1
4058111 | 0.392452 | 4.50335 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.0246585 | 0.02 | L3J_2_AFS 1
4058215 | 1.32988 | 0.896612 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.104448 | 0.025 | L3J_2_AFS 1
4059479 | 2.48224 | 2.06661 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.194955 | 0.025 | L3J_2_AFS 1
4059488 | 0.202607 | 4.55949 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0159127 | 0.025 | L3J_2_AFS 1
4059603 | 0.0625493 | 1.68551 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.00393009 | 0.02 | L3J_2_AFS 1
4059614 | 1.77367 | 1.71072 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.111443 | 0.02 | L3J_2_AFS 1
4059745 | 0.210325 | 0.493063 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.0105721 | 0.016 | L3J_2_AFS 1
4059813 | 0.104591 | 0.471126 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00525734 | 0.016 | L3J_2_AFS 1
4059984 | 4.0021 | 0.493063 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.201167 | 0.016 | L3J_2_AFS 1
4060266 | 2.21 | 2.27411 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.173573 | 0.025 | L3J_2_AFS 1
4060285 | 3.59385 | 0.896612 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.28226 | 0.025 | L3J_2_AFS 1
4060287 | 0.404869 | 4.5011 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.0317983 | 0.025 | L3J_2_AFS 1
4060369 | 0.0107641 | 4.53809 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø | 0.000845407 | 0.025 | L3J_2_AFS 1
4060391 | 0.0878314 | 4.5051 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø | 0.00441489 | 0.016 | L3J_2_AFS 1
4064698 | 0.068204 | 2.93369 | L3J_2_AFS | Annex | 20 mmø | 0.00428538 | 0.02 | L3J_2_AFS 1
4064707 | 0.136911 | 2.77754 | L3J_2_AFS | Annex | 25 mmø | 0.010753 | 0.025 | L3J_2_AFS 1
4064713 | 0.245415 | 2.3389 | L3J_2_AFS | Annex | 20 mmø | 0.0154199 | 0.02 | L3J_2_AFS 1
4064726 | 0.105278 | 2.31369 | L3J_2_AFS | Annex | 20 mmø | 0.00661482 | 0.02 | L3J_2_AFS 1
4065024 | 0.146436 | 2.77754 | L3J_2_AFS | Annex | 20 mmø | 0.00920087 | 0.02 | L3J_2_AFS 1
4065263 | 2.48729 | 2.3389 | L3J_2_AFS | Annex | 20 mmø | 0.156281 | 0.02 | L3J_2_AFS 1
4065265 | 0.321293 | 4.844 | L3J_2_AFS | Annex | 16 mmø | 0.0161499 | 0.016 | L3J_2_AFS 1
4065363 | 0.0578151 | 4.69 | L3J_2_AFS | Annex | 25 mmø | 0.00454079 | 0.025 | L3J_2_AFS 1
4065502 | 0.439278 | 4.69 | L3J_2_AFS | Annex | 25 mmø | 0.0345008 | 0.025 | L3J_2_AFS 1
4065516 | 2.83921 | 4.69 | L3J_2_AFS | Annex | 25 mmø | 0.222991 | 0.025 | L3J_2_AFS 1
4065565 | 0.219363 | 1.59 | L3J_2_AFS | Annex | 25 mmø | 0.0172287 | 0.025 | L3J_2_AFS 1
4065576 | 1.14344 | 1.62064 | L3J_2_AFS | Annex | 25 mmø | 0.0898053 | 0.025 | L3J_2_AFS 1
4065603 | 1.72207 | 2.9573 | L3J_2_AFS | Annex | 25 mmø | 0.135251 | 0.025 | L3J_2_AFS 1
5117440 | 0.0171141 | 4.53491 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø | 0.00107531 | 0.02 | L3J_2_AFS 1

# IfcFlowSegment: Pipe Types:L3J_TUBERIA_FRIGORÍFICA_COURE (217)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.10; 105.AMB.ClassificacioDescripcio: Línies frigorífiques; 109.AMB.CodiTipus: CLI-TCRA
Classification: 50.30.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:L3J_TUBERIA_FRIGORÍFICA_COURE; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TUBERIA_FRIGORÍFICA_COURE; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:L3J_TUBERIA_FRIGORÍFICA_COURE:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 112.AMB.Servei | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
3519722 | PLANTA BAIXA | 0.100086 | 3.29015 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.00199663 | 0.00635 | L3J_3_CALEF_IMP 4
3519868 | PLANTA BAIXA | 0.68366 | 3.59682 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.0136384 | 0.00635 | L3J_3_CALEF_IMP 4
3519878 | PLANTA BAIXA | 0.283505 | 3.30491 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.00565566 | 0.00635 | L3J_3_CALEF_IMP 4
3519888 | PLANTA BAIXA | 0.469998 | 3.59683 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.00937604 | 0.00635 | L3J_3_CALEF_IMP 4
3519896 | PLANTA BAIXA | 0.512452 | 3.59683 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.010223 | 0.00635 | L3J_3_CALEF_IMP 4
3519905 | PLANTA BAIXA | 0.355141 | 5.01266 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.00708474 | 0.00635 | L3J_3_CALEF_IMP 4
3520003 | PLANTA BAIXA | 1.39269 | 3.61159 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.0277829 | 0.00635 | L3J_3_CALEF_IMP 4
3520921 | PLANTA BAIXA | 0.16418 | 3.20982 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.0065505 | 0.0127 | L3J_3_CALEF_RET 4
3520932 | PLANTA BAIXA | 0.0722351 | 3.20982 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.00288205 | 0.0127 | L3J_3_CALEF_RET 4
3520947 | PLANTA BAIXA | 0.691351 | 3.64365 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.0275837 | 0.0127 | L3J_3_CALEF_RET 4
3521156 | PLANTA BAIXA | 0.404312 | 3.23093 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.0161313 | 0.0127 | L3J_3_CALEF_RET 4
3521164 | PLANTA BAIXA | 0.557658 | 3.64365 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.0222496 | 0.0127 | L3J_3_CALEF_RET 4
3521172 | PLANTA BAIXA | 0.56956 | 3.64365 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.0227244 | 0.0127 | L3J_3_CALEF_RET 4
3521271 | PLANTA BAIXA | 0.428366 | 5.00862 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.017091 | 0.0127 | L3J_3_CALEF_RET 4
3521283 | PLANTA BAIXA | 1.33548 | 3.66476 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.0532834 | 0.0127 | L3J_3_CALEF_RET 4
3521986 | PLANTA BAIXA | 1.48729 | 5.01324 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.0593403 | 0.0127 | L3J_3_CALEF_RET 4
3522013 | PLANTA BAIXA | 1.48776 | 5.01603 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.0296795 | 0.00635 | L3J_3_CALEF_IMP 4
3523000 | PLANTA COBERTA | 0.261981 | 5.44365 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0104526 | 0.0127 | L3J_3_CALEF_RET 4
3523139 | PLANTA COBERTA | 0.190768 | 5.44682 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00380566 | 0.00635 | L3J_3_CALEF_IMP 4
3709039 | PLANTA COBERTA | 0.635758 | 4.79047 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 49 mmø | 0.0380484 | 0.01905 | L3J_3_CALEF_RET 9
3709054 | PLANTA COBERTA | 0.126549 | 5.40747 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 49 mmø | 0.0075736 | 0.01905 | L3J_3_CALEF_RET 9
3709055 | PLANTA COBERTA | 0.581115 | 4.81794 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 49 mmø | 0.0347782 | 0.01905 | L3J_3_CALEF_RET 9
3709234 | PLANTA COBERTA | 0.586536 | 4.79205 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 46 mmø | 0.0292983 | 0.0159 | L3J_3_CALEF_IMP 8
3709247 | PLANTA COBERTA | 0.150225 | 5.45905 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 46 mmø | 0.00750394 | 0.0159 | L3J_3_CALEF_IMP 8
3709248 | PLANTA COBERTA | 0.634282 | 4.81636 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 46 mmø | 0.0316832 | 0.0159 | L3J_3_CALEF_IMP 8
3717936 | PLANTA COBERTA | 0.261376 | 5.51246 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 30 mmø | 0.00780079 | 0.0095 | L3J_3_CALEF_IMP 10
3717937 | PLANTA COBERTA | 0.690894 | 4.81316 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 30 mmø | 0.0206198 | 0.0095 | L3J_3_CALEF_IMP 10
3717938 | PLANTA COBERTA | 0.517132 | 4.79525 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 30 mmø | 0.0154339 | 0.0095 | L3J_3_CALEF_IMP 10
3718068 | PLANTA COBERTA | 1.10295 | 4.79205 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 56 mmø | 0.0550937 | 0.0159 | L3J_3_CALEF_IMP 12
3718107 | PLANTA COBERTA | 1.10805 | 4.79047 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 59 mmø | 0.0663137 | 0.01905 | L3J_3_CALEF_RET 12
3718559 | PLANTA COBERTA | 0.0893809 | 4.62347 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 59 mmø | 0.00534921 | 0.01905 | L3J_3_CALEF_IMP 11
3718586 | PLANTA COBERTA | 0.0227716 | 4.62505 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 56 mmø | 0.00113747 | 0.0159 | L3J_3_CALEF_RET 3
3719036 | PLANTA BAIXA | 0.221751 | 4.79525 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 30 mmø | 0.0066182 | 0.0095 | L3J_3_CALEF_IMP 10
3719048 | PLANTA BAIXA | 0.14935 | 4.79205 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 46 mmø | 0.00746022 | 0.0159 | L3J_3_CALEF_IMP 8
3719067 | PLANTA BAIXA | 0.102182 | 4.79047 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 49 mmø | 0.00611531 | 0.01905 | L3J_3_CALEF_RET 9
3719259 | PLANTA COBERTA | 0.0487048 | 4.62825 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 40 mmø | 0.0014536 | 0.0095 | L3J_3_CALEF_IMP 14
3719286 | PLANTA BAIXA | 1.0996 | 4.79525 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 40 mmø | 0.0328178 | 0.0095 | L3J_3_CALEF_IMP 14
3719295 | PLANTA COBERTA | 2.5698 | 4.62825 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 40 mmø | 0.0766961 | 0.0095 | L3J_3_CALEF_IMP 14
3719375 | PLANTA BAIXA | 0.140682 | 4.64616 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 40 mmø | 0.00419867 | 0.0095 | L3J_3_CALEF_IMP 14
3719609 | PLANTA COBERTA | 2.5934 | 4.62505 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 56 mmø | 0.129544 | 0.0159 | L3J_3_CALEF_RET 3; L3J_3_CALEF_IMP 12
3719619 | PLANTA COBERTA | 0.134282 | 4.64936 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 56 mmø | 0.00670757 | 0.0159 | L3J_3_CALEF_IMP 12
3719645 | PLANTA COBERTA | 2.61543 | 4.62347 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 59 mmø | 0.156527 | 0.01905 | L3J_3_CALEF_RET 12
3719655 | PLANTA COBERTA | 0.131115 | 4.65094 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 59 mmø | 0.00784686 | 0.01905 | L3J_3_CALEF_RET 12
3724766 | PLANTA BAIXA | 0.229128 | 4.62825 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 40 mmø | 0.00683834 | 0.0095 | L3J_3_CALEF_IMP 19
3725663 | PLANTA BAIXA | 1.14836 | 5.09047 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 59 mmø | 0.0687265 | 0.01905 | L3J_3_CALEF_IMP 17
3725691 | PLANTA BAIXA | 1.14995 | 5.09205 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 56 mmø | 0.0574414 | 0.0159 | L3J_3_CALEF_RET 16
3725705 | PLANTA BAIXA | 1.15315 | 5.09525 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 40 mmø | 0.0344158 | 0.0095 | L3J_3_CALEF_IMP 19
3726187 | PLANTA COBERTA | 1.48679 | 4.62825 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 40 mmø | 0.0443735 | 0.0095 | L3J_3_CALEF_IMP 19
3726233 | PLANTA COBERTA | 1.45039 | 4.62505 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 56 mmø | 0.072449 | 0.0159 | L3J_3_CALEF_RET 16
3726265 | PLANTA COBERTA | 1.42202 | 4.62347 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 59 mmø | 0.0851044 | 0.01905 | L3J_3_CALEF_IMP 17
3726574 | PLANTA BAIXA | 0.396237 | 5.11636 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 46 mmø | 0.0197926 | 0.0159 | L3J_3_CALEF_RET 11
3726612 | PLANTA BAIXA | 0.782096 | 5.09525 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 30 mmø | 0.0233418 | 0.0095 | L3J_3_CALEF_IMP 18
3726691 | PLANTA BAIXA | 0.452849 | 5.11316 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 30 mmø | 0.0135153 | 0.0095 | L3J_3_CALEF_IMP 18
3726840 | PLANTA COBERTA | 0.0624575 | 5.46943 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 49 mmø | 0.00373792 | 0.01905 | L3J_3_CALEF_RET 14
3726897 | PLANTA COBERTA | 0.184032 | 5.521 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 46 mmø | 0.00919266 | 0.0159 | L3J_3_CALEF_IMP 16
3727026 | PLANTA COBERTA | 0.0431901 | 5.57442 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 30 mmø | 0.00128901 | 0.0095 | L3J_3_CALEF_IMP 18
3727130 | PLANTA COBERTA | 0.271548 | 5.57442 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 30 mmø | 0.00810437 | 0.0095 | L3J_3_CALEF_IMP 18
3727203 | PLANTA COBERTA | 0.265497 | 5.521 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 46 mmø | 0.0132619 | 0.0159 | L3J_3_CALEF_IMP 16; L3J_3_CALEF_RET 11
3728324 | PLANTA BAIXA | 0.0837492 | 4.62505 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 56 mmø | 0.00418338 | 0.0159 | L3J_3_CALEF_RET 16
3728354 | PLANTA BAIXA | 0.0134323 | 4.62347 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 59 mmø | 0.000803887 | 0.01905 | L3J_3_CALEF_IMP 17
3728454 | PLANTA BAIXA | 0.440682 | 4.64616 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 40 mmø | 0.0131522 | 0.0095 | L3J_3_CALEF_IMP 19
3728486 | PLANTA BAIXA | 0.434282 | 4.64936 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 56 mmø | 0.021693 | 0.0159 | L3J_3_CALEF_RET 16
3728533 | PLANTA BAIXA | 0.431115 | 4.65094 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 59 mmø | 0.0258011 | 0.01905 | L3J_3_CALEF_IMP 17
3728900 | PLANTA COBERTA | 1.19056 | 5.41278 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.0237506 | 0.00635 | L3J_3_CALEF_IMP 2
3729678 | PLANTA COBERTA | 1.12023 | 5.46357 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.044695 | 0.0127 | L3J_3_CALEF_RET 2
3730123 | PLANTA BAIXA | 0.15187 | 5.09846 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.00605936 | 0.0127 | L3J_3_CALEF_RET 2
3730224 | PLANTA COBERTA | 0.376067 | 5.34365 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0150044 | 0.0127 | L3J_3_CALEF_RET 2
3730234 | PLANTA BAIXA | 0.215669 | 5.11957 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.00860483 | 0.0127 | L3J_3_CALEF_RET 2
3730587 | PLANTA COBERTA | 0.0428316 | 5.36158 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.000854452 | 0.00635 | L3J_3_CALEF_IMP 2
3730710 | PLANTA COBERTA | 0.0903978 | 5.36476 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00360671 | 0.0127 | L3J_3_CALEF_RET 2
3731081 | PLANTA BAIXA | 13.2148 | 5.46357 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.527246 | 0.0127 | L3J_3_CALEF_RET 2
3731171 | PLANTA COBERTA | 0.165241 | 5.05619 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00659282 | 0.0127 | L3J_3_CALEF_RET 2
3731289 | PLANTA COBERTA | 0.308667 | 5.34365 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0123153 | 0.0127 | L3J_3_CALEF_RET 2
3731298 | PLANTA COBERTA | 0.257947 | 5.07729 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0102916 | 0.0127 | L3J_3_CALEF_RET 2
3731315 | PLANTA COBERTA | 0.0903978 | 5.36476 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00360671 | 0.0127 | L3J_3_CALEF_RET 2
3734014 | PLANTA BAIXA | 0.135052 | 5.09564 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.00269416 | 0.00635 | L3J_3_CALEF_IMP 2
3734634 | PLANTA COBERTA | 0.341832 | 5.34682 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00681925 | 0.00635 | L3J_3_CALEF_IMP 2
3734643 | PLANTA COBERTA | 0.228019 | 5.1104 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00454879 | 0.00635 | L3J_3_CALEF_IMP 2
3735094 | PLANTA COBERTA | 13.2869 | 5.41278 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.265061 | 0.00635 | L3J_3_CALEF_IMP 2
3735135 | PLANTA COBERTA | 0.148416 | 5.05336 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00296077 | 0.00635 | L3J_3_CALEF_IMP 2
3735145 | PLANTA COBERTA | 0.275017 | 5.34682 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00548634 | 0.00635 | L3J_3_CALEF_IMP 2
3735176 | PLANTA COBERTA | 0.270297 | 5.06812 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00539218 | 0.00635 | L3J_3_CALEF_IMP 2
3735193 | PLANTA COBERTA | 0.0427868 | 5.36158 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.000853558 | 0.00635 | L3J_3_CALEF_IMP 2
3735236 | PLANTA COBERTA | 18.1704 | 5.41278 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.362482 | 0.00635 | L3J_3_CALEF_IMP 2
3735246 | PLANTA COBERTA | 0.121919 | 5.29682 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00243217 | 0.00635 | L3J_3_CALEF_IMP 2
3735289 | PLANTA COBERTA | 0.0927868 | 5.31158 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00185101 | 0.00635 | L3J_3_CALEF_IMP 2
3735354 | PLANTA COBERTA | 0.138729 | 5.14014 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00276752 | 0.00635 | L3J_3_CALEF_IMP 2
3735373 | PLANTA COBERTA | 0.133522 | 5.15489 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00266364 | 0.00635 | L3J_3_CALEF_IMP 2
3735409 | PLANTA COBERTA | 20.5179 | 5.41278 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.409313 | 0.00635 | L3J_3_CALEF_IMP 2
3735421 | PLANTA COBERTA | 0.031502 | 5.41278 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.000628437 | 0.00635 | L3J_3_CALEF_IMP 2
3735501 | PLANTA COBERTA | 0.0320042 | 5.11698 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.000638455 | 0.00635 | L3J_3_CALEF_IMP 2
3735522 | PLANTA COBERTA | 0.272675 | 5.13174 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00543962 | 0.00635 | L3J_3_CALEF_IMP 2
3735611 | PLANTA COBERTA | 15.9723 | 5.46357 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.637267 | 0.0127 | L3J_3_CALEF_RET 2
3735690 | PLANTA COBERTA | 0.0903978 | 5.36476 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00360671 | 0.0127 | L3J_3_CALEF_RET 2
3735721 | PLANTA COBERTA | 0.070554 | 5.14296 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00281498 | 0.0127 | L3J_3_CALEF_RET 2
3735740 | PLANTA COBERTA | 0.121172 | 5.16407 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00483454 | 0.0127 | L3J_3_CALEF_RET 2
3735834 | PLANTA COBERTA | 0.222569 | 5.29365 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00888009 | 0.0127 | L3J_3_CALEF_RET 2
3735859 | PLANTA COBERTA | 2.07843 | 5.34365 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0829257 | 0.0127 | L3J_3_CALEF_RET 2
3736717 | PLANTA COBERTA | 16.0523 | 5.46357 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.640458 | 0.0127 | L3J_3_CALEF_RET 2
3736818 | PLANTA COBERTA | 0.0903978 | 5.36476 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00360671 | 0.0127 | L3J_3_CALEF_RET 2
3737082 | PLANTA COBERTA | 0.020482 | 5.31476 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.000817197 | 0.0127 | L3J_3_CALEF_RET 2
3737424 | PLANTA COBERTA | 4.57092 | 5.34365 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.182372 | 0.0127 | L3J_3_CALEF_RET 2
3737438 | PLANTA COBERTA | 0.13217 | 5.34365 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00527334 | 0.0127 | L3J_3_CALEF_RET 2
3737479 | PLANTA COBERTA | 0.108814 | 5.11981 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00434148 | 0.0127 | L3J_3_CALEF_RET 2
3737511 | PLANTA COBERTA | 0.194325 | 5.14092 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00775321 | 0.0127 | L3J_3_CALEF_RET 2
3738266 | PLANTA BAIXA | 0.0721739 | 5.23915 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.00143981 | 0.00635 | L3J_3_CALEF_RET 5
3738301 | PLANTA COBERTA | 0.0455833 | 5.18835 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00181869 | 0.0127 | L3J_3_CALEF_IMP 3
3739384 | PLANTA COBERTA | 1.13502 | 4.99334 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.0226426 | 0.00635 | L3J_3_CALEF_RET 5
3739394 | PLANTA COBERTA | 0.222641 | 5.0081 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.0044415 | 0.00635 | L3J_3_CALEF_RET 5
3739404 | PLANTA BAIXA | 0.517895 | 4.89682 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.0103315 | 0.00635 | L3J_3_CALEF_RET 5
3739465 | PLANTA COBERTA | 0.0733478 | 4.91158 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00146322 | 0.00635 | L3J_3_CALEF_RET 5
3739492 | PLANTA COBERTA | 1.09345 | 4.99017 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0436269 | 0.0127 | L3J_3_CALEF_IMP 3
3739502 | PLANTA COBERTA | 0.168666 | 5.01127 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00672949 | 0.0127 | L3J_3_CALEF_IMP 3
3739512 | PLANTA BAIXA | 0.467335 | 4.89365 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.0186459 | 0.0127 | L3J_3_CALEF_IMP 3
3739563 | PLANTA COBERTA | 0.0669978 | 4.91476 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00267309 | 0.0127 | L3J_3_CALEF_IMP 3
3740670 | PLANTA COBERTA | 0.423966 | 5.01127 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0169155 | 0.0127 | L3J_3_CALEF_RET 4
3740680 | PLANTA COBERTA | 1.16467 | 4.99017 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0464683 | 0.0127 | L3J_3_CALEF_RET 4
3740771 | PLANTA COBERTA | 0.430316 | 5.0081 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00858443 | 0.00635 | L3J_3_CALEF_IMP 4
3740781 | PLANTA COBERTA | 1.21229 | 4.99334 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.0241841 | 0.00635 | L3J_3_CALEF_IMP 4
3741088 | PLANTA COBERTA | 0.0669978 | 4.91476 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00267309 | 0.0127 | L3J_3_CALEF_RET 4
3741125 | PLANTA COBERTA | 0.0733478 | 4.91158 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00146322 | 0.00635 | L3J_3_CALEF_IMP 4
3741166 | PLANTA BAIXA | 0.0646746 | 4.89682 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.0012902 | 0.00635 | L3J_3_CALEF_IMP 4
3741198 | PLANTA BAIXA | 0.134095 | 4.89365 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.00535013 | 0.0127 | L3J_3_CALEF_RET 4; L3J_3_CALEF_IMP 20
3741567 | PLANTA COBERTA | 2.53338 | 4.57165 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 43 mmø | 0.101077 | 0.0127 | L3J_3_CALEF_IMP 9
3741602 | PLANTA COBERTA | 2.5001 | 4.57482 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 36 mmø | 0.0498747 | 0.00635 | L3J_3_CALEF_IMP 5
3742772 | PLANTA BAIXA | 0.0799059 | 3.29015 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.00159405 | 0.00635 | L3J_3_CALEF_IMP 4
3743660 | PLANTA BAIXA | 1.15472 | 5.09682 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 36 mmø | 0.0230357 | 0.00635 | L3J_3_CALEF_IMP 5
3743695 | PLANTA BAIXA | 1.15155 | 5.09365 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 43 mmø | 0.0459447 | 0.0127 | L3J_3_CALEF_IMP 9
3743718 | PLANTA BAIXA | 1.15472 | 5.09682 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 26 mmø | 0.0230357 | 0.00635 | L3J_3_CALEF_IMP 21
3743749 | PLANTA BAIXA | 1.15155 | 5.09365 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 33 mmø | 0.0459447 | 0.0127 | L3J_3_CALEF_IMP 6
3743854 | PLANTA COBERTA | 0.498832 | 4.58958 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 36 mmø | 0.00995126 | 0.00635 | L3J_3_CALEF_IMP 5
3743885 | PLANTA COBERTA | 0.492482 | 4.59276 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 43 mmø | 0.0196492 | 0.0127 | L3J_3_CALEF_IMP 9
3743922 | PLANTA COBERTA | 0.492482 | 4.59276 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0196492 | 0.0127 | L3J_3_CALEF_IMP 6
3743956 | PLANTA COBERTA | 0.498832 | 4.58958 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00995126 | 0.00635 | L3J_3_CALEF_IMP 21
3746459 | PLANTA COBERTA | 0.036832 | 4.59538 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 36 mmø | 0.000734766 | 0.00635 | L3J_3_CALEF_IMP 5
3746469 | PLANTA COBERTA | 0.364524 | 4.59538 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 36 mmø | 0.00727192 | 0.00635 | L3J_3_CALEF_IMP 5
3746496 | PLANTA COBERTA | 0.00909812 | 4.59538 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 36 mmø | 0.000181499 | 0.00635 | L3J_3_CALEF_IMP 5
3746497 | PLANTA COBERTA | 0.01909 | 4.57928 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 36 mmø | 0.000380829 | 0.00635 | L3J_3_CALEF_IMP 5
3746542 | PLANTA COBERTA | 0.0533304 | 4.62625 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 43 mmø | 0.00212779 | 0.0127 | L3J_3_CALEF_RET 10
3746552 | PLANTA COBERTA | 0.439446 | 4.62625 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 43 mmø | 0.0175331 | 0.0127 | L3J_3_CALEF_RET 10
3746577 | PLANTA COBERTA | 0.0250786 | 4.59276 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 43 mmø | 0.00100059 | 0.0127 | L3J_3_CALEF_IMP 9
3748718 | PLANTA COBERTA | 3.50335 | 4.57482 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.0698887 | 0.00635 | L3J_3_CALEF_IMP 21
3748729 | PLANTA COBERTA | 0.61221 | 4.57482 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 36 mmø | 0.012213 | 0.00635 | L3J_3_CALEF_IMP 21
3748767 | PLANTA COBERTA | 3.55473 | 4.57165 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.141828 | 0.0127 | L3J_3_CALEF_IMP 6
3749924 | PLANTA COBERTA | 0.101152 | 4.68977 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 36 mmø | 0.0020179 | 0.00635 | L3J_3_CALEF_IMP 21
3750727 | PLANTA COBERTA | 0.091775 | 4.58958 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 36 mmø | 0.00183083 | 0.00635 | L3J_3_CALEF_IMP 21
3750821 | PLANTA COBERTA | 0.040241 | 4.60902 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 43 mmø | 0.00160555 | 0.0127 | L3J_3_CALEF_RET 7
3750832 | PLANTA COBERTA | 0.642333 | 4.60902 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 43 mmø | 0.0256279 | 0.0127 | L3J_3_CALEF_RET 7
3751064 | PLANTA COBERTA | 0.00785109 | 4.59276 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 43 mmø | 0.000313244 | 0.0127 | L3J_3_CALEF_IMP 6
3755418 | PLANTA COBERTA | 17.8766 | 5.40161 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.713246 | 0.0127 | L3J_3_CALEF_RET 1
3755464 | PLANTA COBERTA | 17.8147 | 5.35082 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.355388 | 0.00635 | L3J_3_CALEF_IMP 1
3755510 | PLANTA COBERTA | 9.25556 | 5.40161 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.36928 | 0.0127 | L3J_3_CALEF_RET 1
3755552 | PLANTA COBERTA | 9.27172 | 5.35082 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.184963 | 0.00635 | L3J_3_CALEF_IMP 1
3755596 | PLANTA COBERTA | 5.50971 | 5.40161 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.219828 | 0.0127 | L3J_3_CALEF_RET 1
3755639 | PLANTA COBERTA | 5.58189 | 5.35082 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.111354 | 0.00635 | L3J_3_CALEF_IMP 1
3755735 | PLANTA COBERTA | 0.033416 | 4.84551 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00066662 | 0.00635 | L3J_3_CALEF_IMP 1
3755748 | PLANTA COBERTA | 1.12458 | 5.09682 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.0224344 | 0.00635 | L3J_3_CALEF_IMP 1
3755868 | PLANTA COBERTA | 0.228148 | 4.86027 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00455135 | 0.00635 | L3J_3_CALEF_IMP 1
3756043 | PLANTA COBERTA | 0.230832 | 5.11158 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00460489 | 0.00635 | L3J_3_CALEF_IMP 1
3756193 | PLANTA COBERTA | 0.065244 | 4.84833 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00260312 | 0.0127 | L3J_3_CALEF_RET 1
3756380 | PLANTA COBERTA | 1.17323 | 5.09365 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0468098 | 0.0127 | L3J_3_CALEF_RET 1
3756390 | PLANTA COBERTA | 0.215785 | 4.86946 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00860944 | 0.0127 | L3J_3_CALEF_RET 1
3756495 | PLANTA COBERTA | 0.278443 | 5.11476 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0111094 | 0.0127 | L3J_3_CALEF_RET 1
3756652 | PLANTA COBERTA | 0.204711 | 4.84552 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00408381 | 0.00635 | L3J_3_CALEF_IMP 1
3756678 | PLANTA COBERTA | 0.261536 | 4.84835 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0104348 | 0.0127 | L3J_3_CALEF_RET 1
3756705 | PLANTA COBERTA | 0.482132 | 4.86028 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00961811 | 0.00635 | L3J_3_CALEF_IMP 1
3756718 | PLANTA COBERTA | 0.523743 | 4.86946 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0208964 | 0.0127 | L3J_3_CALEF_RET 1
3756757 | PLANTA COBERTA | 0.323029 | 5.25332 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00644415 | 0.00635 | L3J_3_CALEF_IMP 1
3756785 | PLANTA COBERTA | 0.379854 | 5.25615 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.0151555 | 0.0127 | L3J_3_CALEF_RET 1
3756811 | PLANTA COBERTA | 0.074332 | 5.26808 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 26 mmø | 0.00148286 | 0.00635 | L3J_3_CALEF_IMP 1
3756823 | PLANTA COBERTA | 0.115943 | 5.27726 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 33 mmø | 0.00462592 | 0.0127 | L3J_3_CALEF_RET 1
3757162 | PLANTA BAIXA | 0.778373 | 5.09205 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Santa Eulalia | 46 mmø | 0.0388807 | 0.0159 | L3J_3_CALEF_RET 11
3757200 | PLANTA BAIXA | 1.075 | 5.09047 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Santa Eulalia | 49 mmø | 0.0643361 | 0.01905 | L3J_3_CALEF_IMP 15
3757211 | PLANTA COBERTA | 0.152868 | 5.09047 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Santa Eulalia | 49 mmø | 0.00914872 | 0.01905 | L3J_3_CALEF_RET 14; L3J_3_CALEF_IMP 15
3758131 | PLANTA COBERTA | 0.343069 | 5.11794 | L3J_3_CALEF_RET | PLANTA COBERTA | Nau Santa Eulalia | 49 mmø | 0.0205318 | 0.01905 | L3J_3_CALEF_RET 14
4947279 | PLANTA COBERTA | 0.0864377 | 7.26379 | L3J_3_CALEF_IMP | PLANTA COBERTA | Nau Lateral Sud | 13 mmø | 0.00344871 | 0.0127 | L3J_3_CALEF_IMP 13
4947426 | PLANTA BAIXA | 0.467166 | 7.26379 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Lateral Sud | 13 mmø | 0.0186391 | 0.0127 | L3J_3_CALEF_IMP 13
4947434 | PLANTA BAIXA | 0.0987191 | 7.26379 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Lateral Sud | 13 mmø | 0.00393872 | 0.0127 | L3J_3_CALEF_IMP 13
4947442 | PLANTA BAIXA | 2.43232 | 7.04365 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Lateral Sud | 13 mmø | 0.0970451 | 0.0127 | L3J_3_CALEF_IMP 13
4947519 | PLANTA BAIXA | 0.190619 | 7.06476 | L3J_3_CALEF_IMP | PLANTA BAIXA | Nau Lateral Sud | 13 mmø | 0.00760536 | 0.0127 | L3J_3_CALEF_IMP 13
4948181 | PLANTA BAIXA | 0.173056 | 7.31459 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Lateral Sud | 6 mmø | 0.00345232 | 0.00635 | L3J_3_CALEF_RET 13
4948244 | PLANTA BAIXA | 0.595068 | 7.31459 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Lateral Sud | 6 mmø | 0.0118711 | 0.00635 | L3J_3_CALEF_RET 13
4948252 | PLANTA BAIXA | 0.166858 | 7.31459 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Lateral Sud | 6 mmø | 0.00332866 | 0.00635 | L3J_3_CALEF_RET 13
4948260 | PLANTA BAIXA | 2.43342 | 7.04682 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Lateral Sud | 6 mmø | 0.0485445 | 0.00635 | L3J_3_CALEF_RET 13
4948320 | PLANTA BAIXA | 0.244594 | 7.06158 | L3J_3_CALEF_RET | PLANTA BAIXA | Nau Lateral Sud | 6 mmø | 0.00487944 | 0.00635 | L3J_3_CALEF_RET 13
4948363 | P0_NL | 0.12764 | 5.72565 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 13 mmø | 0.00509262 | 0.0127 | L3J_3_CALEF_RET 15
4948393 | P0_NL | 0.179748 | 5.72882 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.00358581 | 0.00635 | L3J_3_CALEF_IMP 22
4948444 | P0_NL | 0.157437 | 5.72882 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.00314073 | 0.00635 | L3J_3_CALEF_IMP 22
4948459 | P0_NL | 0.76858 | 5.72882 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.0153325 | 0.00635 | L3J_3_CALEF_IMP 22
4948483 | P0_NL | 1.62101 | 5.72882 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.0323376 | 0.00635 | L3J_3_CALEF_IMP 22
4948513 | P0_NL | 0.0710425 | 5.72565 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 13 mmø | 0.00283447 | 0.0127 | L3J_3_CALEF_RET 15
4948530 | P0_NL | 0.639571 | 5.72565 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 13 mmø | 0.0255178 | 0.0127 | L3J_3_CALEF_RET 15
4948538 | P0_NL | 1.56672 | 5.72565 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 13 mmø | 0.0625095 | 0.0127 | L3J_3_CALEF_RET 15
4949143 | P0_NL | 0.272935 | 5.84377 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.00544481 | 0.00635 | L3J_3_CALEF_IMP 23
4949166 | P0_NL | 0.138776 | 5.76462 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 10 mmø | 0.00414178 | 0.0095 | L3J_3_CALEF_RET 17
4949193 | P0_NL | 0.815143 | 5.84377 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.0162614 | 0.00635 | L3J_3_CALEF_IMP 23
4949235 | P0_NL | 0.81157 | 5.76462 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 10 mmø | 0.0242214 | 0.0095 | L3J_3_CALEF_RET 17
4949245 | P0_NL | 1.81368 | 5.76462 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 10 mmø | 0.0541294 | 0.0095 | L3J_3_CALEF_RET 17
4949365 | P0_NL | 0.524529 | 5.76462 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 10 mmø | 0.0156546 | 0.0095 | L3J_3_CALEF_RET 17
4949395 | P0_NL | 1.81605 | 3.94016 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 10 mmø | 0.0542003 | 0.0095 | L3J_3_CALEF_RET 17
4949419 | P0_NL | 1.93764 | 5.84377 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.0386542 | 0.00635 | L3J_3_CALEF_IMP 23
4949427 | P0_NL | 0.527799 | 5.84377 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.0105291 | 0.00635 | L3J_3_CALEF_IMP 23
4949436 | P0_NL | 0.169283 | 4.00101 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.00337705 | 0.00635 | L3J_3_CALEF_IMP 23
4949644 | P0_NL | 1.81959 | 4.01577 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.0362992 | 0.00635 | L3J_3_CALEF_IMP 23
4949723 | P0_NL | 0.344334 | 3.92225 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 10 mmø | 0.0102767 | 0.0095 | L3J_3_CALEF_RET 17
4949799 | P0_NL | 0.482099 | 3.92228 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 10 mmø | 0.0143883 | 0.0095 | L3J_3_CALEF_RET 17
4949826 | P0_NL | 0.488222 | 4.00101 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.0097396 | 0.00635 | L3J_3_CALEF_IMP 23
4950043 | P0_NL | 0.0680804 | 5.74938 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.00135814 | 0.00635 | L3J_3_CALEF_IMP 24
4950073 | P0_NL | 0.0502826 | 5.7789 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 16 mmø | 0.00251168 | 0.0159 | L3J_3_CALEF_IMP 25
4950135 | P0_NL | 0.257671 | 5.7243 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 16 mmø | 0.012871 | 0.0159 | L3J_3_CALEF_IMP 25
4950147 | P0_NL | 0.0218786 | 5.74861 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 16 mmø | 0.00109287 | 0.0159 | L3J_3_CALEF_IMP 25
4950171 | P0_NL | 0.199436 | 5.69108 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.00397857 | 0.00635 | L3J_3_CALEF_IMP 24
4950183 | P0_NL | 0.0353858 | 5.70584 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.000705916 | 0.00635 | L3J_3_CALEF_IMP 24
4950217 | P0_NL | 0.67776 | 5.00491 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 6 mmø | 0.0135207 | 0.00635 | L3J_3_CALEF_IMP 24
4950306 | P0_NL | 0.67545 | 5.04044 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 16 mmø | 0.0337396 | 0.0159 | L3J_3_CALEF_IMP 25
4950331 | P0_NL | 1.78927 | 4.99015 | L3J_3_CALEF_RET | P0_NL | Nau Lateral Sud | 6 mmø | 0.0356944 | 0.00635 | L3J_3_CALEF_RET 19
4950393 | P0_NL | 1.82852 | 4.93935 | L3J_3_CALEF_IMP | P0_NL | Nau Lateral Sud | 13 mmø | 0.0729548 | 0.0127 | L3J_3_CALEF_IMP 25

# IfcFlowSegment: Pipe Types:L3J_TUBERIA_SANEJAMENT_PLUVIAL_PVC (26)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.10; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües pluvials; 109.AMB.CodiTipus: SAN-PVCS
Classification: 50.20.20.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:L3J_TUBERIA_SANEJAMENT_PLUVIAL_PVC; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TUBERIA_SANEJAMENT_PLUVIAL_PVC; 112.AMB.Servei: L3J_4_SAN_PLUVIAL; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:L3J_TUBERIA_SANEJAMENT_PLUVIAL_PVC:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
3002897 | PLANTA BAIXA | 4.13651 | 0.0813269 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 1.42948 | 0.11 | L3J_4_SAN_PLUVIAL 3
3013282 | PLANTA BAIXA | 4.26544 | -0.0882861 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 1.47403 | 0.11 | L3J_4_SAN_PLUVIAL 8
3290733 | PLANTA BAIXA | 4.40775 | -0.188613 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 1.52321 | 0.11 | L3J_4_SAN_PLUVIAL 3
3303993 | PLANTA COBERTA | 0.533269 | 5.12098 | PLANTA COBERTA | Nau Lateral Sud | 110 mmø | 0.184285 | 0.11 | L3J_4_SAN_PLUVIAL 6
3304809 | PLANTA BAIXA | 4.4031 | -0.203102 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 1.5216 | 0.11 | L3J_4_SAN_PLUVIAL 3
3627965 | PLANTA COBERTA | 0.25834 | 4.93429 | PLANTA COBERTA | Nau Lateral Sud | 110 mmø | 0.0892758 | 0.11 | L3J_4_SAN_PLUVIAL 6
3636689 | PLANTA BAIXA | 0.293212 | 4.55495 | PLANTA BAIXA | Nau Lateral Sud | 90 mmø | 0.0829038 | 0.09 | L3J_4_SAN_PLUVIAL 6
3658276 | PLANTA BAIXA | 1.99183 | 0.510454 | PLANTA BAIXA | Nau Lateral Sud | 110 mmø | 0.688327 | 0.11 | L3J_4_SAN_PLUVIAL 6
3659182 | PLANTA BAIXA | 0.431804 | 3.69112 | PLANTA BAIXA | Nau Lateral Sud | 110 mmø | 0.149221 | 0.11 | L3J_4_SAN_PLUVIAL 6
3659191 | PLANTA BAIXA | 0.0903469 | 3.77622 | PLANTA BAIXA | Nau Lateral Sud | 110 mmø | 0.0312216 | 0.11 | L3J_4_SAN_PLUVIAL 6
3659277 | PLANTA BAIXA | 1.16798 | 4.05219 | PLANTA BAIXA | Nau Lateral Sud | 110 mmø | 0.403625 | 0.11 | L3J_4_SAN_PLUVIAL 6
3659335 | PLANTA BAIXA | 0.60681 | 4.24797 | PLANTA BAIXA | Nau Lateral Sud | 110 mmø | 0.209699 | 0.11 | L3J_4_SAN_PLUVIAL 6
3660697 | PLANTA BAIXA | 0.0994812 | 4.91708 | PLANTA BAIXA | Nau Lateral Sud | 90 mmø | 0.0281277 | 0.09 | L3J_4_SAN_PLUVIAL 6
3660822 | PLANTA BAIXA | 0.149496 | 4.99076 | PLANTA BAIXA | Nau Lateral Sud | 90 mmø | 0.042269 | 0.09 | L3J_4_SAN_PLUVIAL 6
3663037 | PLANTA BAIXA | 0.257769 | 4.19923 | PLANTA BAIXA | Nau Lateral Sud | 90 mmø | 0.0728826 | 0.09 | L3J_4_SAN_PLUVIAL 6
3770154 | PLANTA BAIXA | 4.60509 | -0.387258 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 1.59141 | 0.11 | L3J_4_SAN_PLUVIAL 8
5051867 | PLANTA BAIXA | 1.23636 | 4.2795 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.427254 | 0.11 | L3J_4_SAN_PLUVIAL 3
5052038 | PLANTA BAIXA | 0.0240307 | 4.47597 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.00830441 | 0.11 | L3J_4_SAN_PLUVIAL 3
5052516 | PLANTA BAIXA | 1.19988 | 4.25595 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.414648 | 0.11 | L3J_4_SAN_PLUVIAL 3
5052539 | PLANTA BAIXA | 4.13842 | 0.0380261 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 1.43013 | 0.11 | L3J_4_SAN_PLUVIAL 3
5056302 | PLANTA COBERTA | 0.0479264 | 4.45207 | PLANTA COBERTA | Nau Santa Eulalia | 110 mmø | 0.0165622 | 0.11 | L3J_4_SAN_PLUVIAL 3
