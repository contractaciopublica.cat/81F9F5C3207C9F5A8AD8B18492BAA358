Properties of the parts of a building model (IFC2X3), part 1 of 10

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 29265434-2937-4783-95c3-5d2861204dff, NumberOfSaves: 314], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Interno]
File name: 0001
Time: 2025-04-28T10:26:39+01:00
Written by: ODA SDAI 24.3
Made in: Autodesk Revit 24.1.11.26 (ESP) - IFC 24.1.11.26

# IfcProject, 0001
LongName: CONSOLIDACIÓ I ADEQUACIÒ DE DIVERSES NAUS A CAN TRINXET, A L`HOSPITALET DE LLOBREGAT; Phase: Projecte Executiu
0 AMB.Informacio Projecte - 001.AMB.ExpedientNumero: 905232/21; 003.AMB.NomProjecte: CONSOLIDACIÓ I ADEQUACIÒ DE DIVERSES NAUS A CAN TRINXET, A L`HOSPITALET DE LLOBREGAT; 004.AMB.FaseProjecte: Projecte Executiu; 007.AMB.ModelDisciplina: INS; 008.AMB.Adreca: Carrer de Santa Eulália 212-216, 08902 l`Hospitaler de Ll.; 009.AMB.Municipi: L'Hospitalet de Llobregat; 010.AMB.AutorProjecte: GFA2 Arquitectos; 011.AMB.AutorProjecte2: self-office; 012.AMB.AutorProjecte3: E.Fernádez; 013.AMB.ProjectesIObres: AMB. SAEP II; 014.AMB.CapServei: GFA2 + self-office, UTE; 019.AMB.AutorCollaborador: Gabriel Fernández-Abascal González-Valdés; 020.AMB.AutorCollaborador2: Guillermo Fernández-Abascal González-Valdés; 023.AMB.AutorCollaborador5: Laura-Maria Solsona Ramo; 024.AMB.AutorCollaborador6: Eduard Fernàndez Garcia

# IfcSite, Carrer de Santa Eulália 212-216, 08902 l`Hospitaler de Ll.
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 m
0 AMB.Informacio Projecte - 008.AMB.Adreca: Carrer de Santa Eulália 212-216, 08902 l`Hospitaler de Ll.; 009.AMB.Municipi: L'Hospitalet de Llobregat

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 5
0 AMB.Informacio Projecte - 008.AMB.Adreca: Carrer de Santa Eulália 212-216, 08902 l`Hospitaler de Ll.; 009.AMB.Municipi: L'Hospitalet de Llobregat

# IfcBuildingStorey: Level:Extremo inicial 8 mm (5)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name = 106.AMB.Nom | Elevation (m)
PLANTA BAIXA | PLANTA BAIXA | 0
P0_NL | P0_NL | 1.71425
1.5_nau | 1.5_nau | 3.21425
PLANTA COBERTA | PLANTA COBERTA | 4.5
P2 | P2 | 5.6674

# IfcBuildingElementProxy: GRAF_Flat Tank Platin 5000L:Platin 5000L, GRAF_Flat Tank Platin 5000L:Platin 5000L:2997532
In: PLANTA BAIXA
Type - Material: Graf_PE, Graf_Gravel
Type - Pset_ManufacturerTypeInformation - ArticleNumber: 390002; Manufacturer: Otto Graf GmbH
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.10.30; 105.AMB.ClassificacioDescripcio: Dipòsits d'evacuació d'aigües; 109.AMB.CodiTipus: SAN
Classification: 50.20.10.30 Uniformat (Uniformat); Material: Graf_Gravel, Graf_PE; Group: L3J_4_SAN_FECAL 3; L3J_4_SAN_PLUVIAL 4; L3J_4_SAN_PLUVIAL 2; L3J_4_SAN_PLUVIAL 1; L3J_4_SAN_PLUVIAL 6
Pset_BuildingElementProxyCommon - Reference: GRAF_Flat Tank Platin 5000L:Platin 5000L; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Platin 5000L; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 19.7554 m2; 509.AMB.Volum: 7.3237 m3

# IfcBuildingElementProxy: GRAF_Tele Dome 600 Maxi:600 Maxi, GRAF_Tele Dome 600 Maxi:600 Maxi:2997533
In: PLANTA BAIXA
Type - Material: Graf_PE_Light_Green
Type - Pset_ManufacturerTypeInformation - ArticleNumber: 371011; Manufacturer: Otto Graf GmbH
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.10.30; 105.AMB.ClassificacioDescripcio: Dipòsits d'evacuació d'aigües; 109.AMB.CodiTipus: SAN
Classification: 50.20.10.30 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: GRAF_Tele Dome 600 Maxi:600 Maxi; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: 600 Maxi; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.04076 m2; 509.AMB.Volum: 0.150383 m3

# IfcBuildingElementProxy: L3J_ARMARIO FONT1:L3J_ARMARIO FONT 2, L3J_ARMARIO FONT1:L3J_ARMARIO FONT 2:3104647
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de fontaneria; 109.AMB.CodiTipus: LAM
Classification: 50.10.20.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_ARMARIO FONT1:L3J_ARMARIO FONT 2; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_ARMARIO FONT 2; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 3.06492 m2; 509.AMB.Volum: 0.917263 m3

# IfcBuildingElementProxy: L3J_ARQUETA:H_800 (12)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.50; 105.AMB.ClassificacioDescripcio: Arquetes i pous d'evaquació d'aigües; 109.AMB.CodiTipus: SAN-PERP
Classification: 50.20.20.50 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_ARQUETA:H_800; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: H_800; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (L3J_ARQUETA:H_800:...) | 507.AMB.Area (m2) | 509.AMB.Volum (m3)
2968176 | 3.32 | 0.316
3534928 | 3.32 | 0.316
3535873 | 3.32 | 0.316
3802422 | 6.5414 | 0.637243
3935759 | 3.32 | 0.316
3936046 | 3.32 | 0.316
3947524 | 2.28 | 0.216 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau de Sta. Eulalia
4561323 | 3.32 | 0.316
5051173 | 3.32 | 0.316
5051208 | 4.72 | 0.456
5068170 | 3.32 | 0.316
5068250 | 3.32 | 0.316

# IfcBuildingElementProxy: L3J_ARQUETA_REC:600x600, L3J_ARQUETA_REC:600x600:2967982
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.50; 105.AMB.ClassificacioDescripcio: Arquetes i pous d'evaquació d'aigües; 109.AMB.CodiTipus: SAN-PERR
Classification: 50.20.20.50 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_ARQUETA_REC:600x600; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: 600x600; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 7.06 m2; 509.AMB.Volum: 0.688 m3

# IfcBuildingElementProxy: L3J_BOCA_INCENDI_EQUIPADA:GENERIC (3)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.70; 105.AMB.ClassificacioDescripcio: BIES; 109.AMB.CodiTipus: PCI-BIE
Classification: 50.50.10.70 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_BOCA_INCENDI_EQUIPADA:GENERIC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: GENERIC; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 509.AMB.Volum: 0.0908063 m3
Name (L3J_BOCA_INCENDI_EQUIPADA:GENERIC:...) | 117.AMB.Localitzacio | Group
3903273 | Nau Santa Eulalia | L3J_6_PCI - HUMIDA 1
3903627 | Nau Santa Eulalia | L3J_6_PCI - HUMIDA 2
3904188 | Nau Lateral Sud | L3J_6_PCI - HUMIDA 3

# IfcBuildingElementProxy: L3J_CGP+CONTADORES:L3J_CGP+CONTADORES, L3J_CGP+CONTADORES:L3J_CGP+CONTADORES:3101559
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.10.30; 105.AMB.ClassificacioDescripcio: Escomeses elèctriques; 109.AMB.CodiTipus: ELE
Classification: 50.60.10.30 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_CGP+CONTADORES:L3J_CGP+CONTADORES; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CGP+CONTADORES; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 2.9529 m2; 509.AMB.Volum: 0.62487 m3

# IfcBuildingElementProxy: L3J_CONJUNT_PRESES_CORRENT_3P_PARET:CONJUNT_2 CORRENT_1 RJ45 (29)
In: PLANTA BAIXA
Type - Material: Nuevo material por defecto
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.40.20; 105.AMB.ClassificacioDescripcio: Preses; 109.AMB.CodiTipus: ELE
Classification: 50.60.40.20 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_CONJUNT_PRESES_CORRENT_3P_PARET:CONJUNT_2 CORRENT_1 RJ45; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: CONJUNT_2 CORRENT_1 RJ45; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0914174 m2; 509.AMB.Volum: 0.000926899 m3
Name (L3J_CONJUNT_PRESES_CORRENT_3P_PARET:CONJUNT_2 CORRENT_1 RJ45:...) | 117.AMB.Localitzacio
3191315 | Nau Lateral Sud
3192050 | Nau Santa Eulalia
3192599 | Nau Santa Eulalia
3192675 | Nau Santa Eulalia
3194585 | Nau Santa Eulalia
3194616 | Nau Santa Eulalia
3194718 | Nau Santa Eulalia
3195658 | Nau Santa Eulalia
3860927 | Nau Santa Eulalia
3864485 | Nau Santa Eulalia
3877390 | Nau Santa Eulalia
3877469 | Nau Santa Eulalia
3877481 | Nau Santa Eulalia
3877880 | Nau Santa Eulalia
3877889 | Nau Santa Eulalia
3878006 | Nau Santa Eulalia
3878026 | Nau Santa Eulalia
3899480 | Nau Santa Eulalia
3899749 | Nau Santa Eulalia
3899806 | Nau Santa Eulalia
3899827 | Nau Santa Eulalia
3901184 | Nau Lateral Sud
3901196 | Nau Lateral Sud
3901479 | Nau Lateral Sud
3901489 | Nau Lateral Sud
3901791 | Nau Lateral Sud
3901959 | Nau Lateral Sud
4942560 | Nau Santa Eulalia
5089524 | Nau Santa Eulalia

# IfcBuildingElementProxy: L3J_DETECOR_MOVIMENT:LUXOMAT PD9-M-1C-SDB-IP65, L3J_DETECOR_MOVIMENT:LUXOMAT PD9-M-1C-SDB-IP65:4839026
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.40.10; 105.AMB.ClassificacioDescripcio: Mecanismes; 109.AMB.CodiTipus: COM-02
Classification: 50.60.40.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_DETECOR_MOVIMENT:LUXOMAT PD9-M-1C-SDB-IP65; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: LUXOMAT PD9-M-1C-SDB-IP65; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0280542 m2; 509.AMB.Volum: 0.000424081 m3

# IfcBuildingElementProxy: L3J_DETECTOR_MOVIMENT_CREPUSCULAR_MECANISME:GENERIC (6)
In: PLANTA BAIXA
Type - Material: Nuevo material por defecto
Type - Pset_ManufacturerTypeInformation - Manufacturer: NIESSEN
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.40.10; 105.AMB.ClassificacioDescripcio: Mecanismes; 109.AMB.CodiTipus: COM-04
Classification: 50.60.40.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_DETECTOR_MOVIMENT_CREPUSCULAR_MECANISME:GENERIC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: GENERIC; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0161596 m2; 509.AMB.Volum: 0.000161159 m3
Name (L3J_DETECTOR_MOVIMENT_CREPUSCULAR_MECANISME:GENERIC:...) | 117.AMB.Localitzacio
4839472 | Nau Santa Eulalia
4895041 | Nau Santa Eulalia
4896656 | Nau Santa Eulalia
4897852 | Nau Santa Eulalia
4897965 | Nau Lateral Sud
4897976 | Annex

# IfcBuildingElementProxy: L3J_DIFUSOR LINEAL_TROX 500:VSD35-1/500 (6)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.50.20; 105.AMB.ClassificacioDescripcio: Difusors; 109.AMB.CodiTipus: CLI-DF
Classification: 50.30.50.20 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_DIFUSOR LINEAL_TROX 500:VSD35-1/500; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: VSD35-1/500; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.244823 m2; 509.AMB.Volum: 0.013325 m3
Name (L3J_DIFUSOR LINEAL_TROX 500:VSD35-1/500:...) | 117.AMB.Localitzacio | Group
3256502 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3256537 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3261401 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3261412 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3405142 | Nau Lateral Sud | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3405384 | Nau Lateral Sud | Mecánica L3J_3_CLIMA_IMP_AIRE 9

# IfcBuildingElementProxy: L3J_DIFUSOR LINEAL_TROX 750:VSD35-1/750 (14)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.50.20; 105.AMB.ClassificacioDescripcio: Difusors; 109.AMB.CodiTipus: CLI-DF
Classification: 50.30.50.20 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_DIFUSOR LINEAL_TROX 750:VSD35-1/750; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: VSD35-1/750; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.343823 m2; 509.AMB.Volum: 0.0197052 m3
Name (L3J_DIFUSOR LINEAL_TROX 750:VSD35-1/750:...) | 117.AMB.Localitzacio | Group
3201107 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3201224 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3201230 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3201393 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3201401 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3201411 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3261510 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3261515 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3261520 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3261529 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3261534 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3261539 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3261544 | Nau Santa Eulalia | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3405412 | Nau Lateral Sud | Mecánica L3J_3_CLIMA_RET_AIRE 2

# IfcBuildingElementProxy: L3J_ESCALFADOR_MBH4-002:Norm (2)
In: PLANTA BAIXA
Type - Material: 242_242_255
Type - Pset_ManufacturerTypeInformation - Manufacturer: Clage GmbH
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.10.30; 105.AMB.ClassificacioDescripcio: Dipòsits, acumuladors i escalfadors; 109.AMB.CodiTipus: ELE-ESC
Classification: 50.10.10.30 Uniformat (Uniformat); Material: 242_242_255, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: L3J_ESCALFADOR_MBH4-002:Norm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Norm; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0718786 m2; 509.AMB.Volum: 0.00185167 m3
Name (L3J_ESCALFADOR_MBH4-002:Norm:...) | Group
3033649 | L3J_2_AFS 1; L3J_2_ACS 1
3034489 | L3J_2_AFS 1; L3J_2_ACS 2

# IfcBuildingElementProxy: L3J_EXTINTOR_CO2:PCI.EXTINTOR (2)
In: PLANTA BAIXA
Type - Material: <Unnamed>, Metal - Paint Finish - Indian Red, Matte, Default
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.80; 105.AMB.ClassificacioDescripcio: Extintors; 109.AMB.CodiTipus: PCI-ECO5
Classification: 50.50.10.80 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_EXTINTOR_CO2:PCI.EXTINTOR; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: PCI.EXTINTOR; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.278786 m2; 509.AMB.Volum: 0.0194557 m3
Name (L3J_EXTINTOR_CO2:PCI.EXTINTOR:...)
4836704
4836711

# IfcBuildingElementProxy: L3J_EXTINTOR_MANUAL:PCI.EXTINTOR (5)
In: PLANTA BAIXA
Type - Material: <Unnamed>, Metal - Paint Finish - Indian Red, Matte, Default
Type - Pset_ManufacturerTypeInformation - Manufacturer: SEE SPECS
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.80; 105.AMB.ClassificacioDescripcio: Extintors; 109.AMB.CodiTipus: PCI-EP6; 111.AMB.DescripcioTipus: SEE DETAILS FOR MOUNTING HEIGHT
Classification: 50.50.10.80 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_EXTINTOR_MANUAL:PCI.EXTINTOR; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: PCI.EXTINTOR; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.278786 m2; 509.AMB.Volum: 0.0194557 m3
Name (L3J_EXTINTOR_MANUAL:PCI.EXTINTOR:...)
4796500
4796501
4836632
4836644
4836664

# IfcBuildingElementProxy: L3J_HIDRO-TANK:L3J_HIDRO-TANK, L3J_HIDRO-TANK:L3J_HIDRO-TANK:4850844
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.90.10.20; 105.AMB.ClassificacioDescripcio: Dipòsits d'instal·lacions especials; 109.AMB.CodiTipus: LAM
Classification: 50.90.10.20 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_HIDRO-TANK:L3J_HIDRO-TANK; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_HIDRO-TANK; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 503.AMB.Altura: 0.776151 m; 507.AMB.Area: 1.01424 m2; 509.AMB.Volum: 0.219449 m3

# IfcBuildingElementProxy: L3J_INTERRUPTORS:SIMPLE ESTANC SUPERFICIE, L3J_INTERRUPTORS:SIMPLE ESTANC SUPERFICIE:4849894
In: PLANTA BAIXA
Type - Material: Nuevo material por defecto
Type - Pset_ManufacturerTypeInformation - Manufacturer: JUNG
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.40.10; 105.AMB.ClassificacioDescripcio: Mecanismes; 109.AMB.CodiTipus: ELE-INT
Classification: 50.60.40.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_INTERRUPTORS:SIMPLE ESTANC SUPERFICIE; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: SIMPLE ESTANC SUPERFICIE; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0161596 m2; 509.AMB.Volum: 0.000161159 m3

# IfcBuildingElementProxy: L3J_INT_EMPOTRABLE:SIMPLE_10A (17)
In: PLANTA BAIXA
Type - Material: Nuevo material por defecto
Type - Pset_ManufacturerTypeInformation - Manufacturer: NIESSEN
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.40.10; 105.AMB.ClassificacioDescripcio: Mecanismes; 109.AMB.CodiTipus: ELE-INT
Classification: 50.60.40.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_INT_EMPOTRABLE:SIMPLE_10A; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: SIMPLE_10A; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0161596 m2; 509.AMB.Volum: 0.000161159 m3
Name (L3J_INT_EMPOTRABLE:SIMPLE_10A:...) | 117.AMB.Localitzacio
4836964 | Nau Santa Eulalia
4837461 | Nau Santa Eulalia
4838352 | Nau Lateral Sud
4895042 | Nau Santa Eulalia
4895045 | Nau Santa Eulalia
4896308 | Nau Santa Eulalia
4896338 | Nau Santa Eulalia
4896679 | Nau Santa Eulalia
4897188 | Nau Santa Eulalia
4897673 | Nau Santa Eulalia
4897680 | Nau Santa Eulalia
4897751 | Nau Santa Eulalia
4897816 | Nau Santa Eulalia
4897877 | Nau Santa Eulalia
4897902 | Nau Santa Eulalia
4921983 | Nau Lateral Sud
4921992 | Nau Lateral Sud

# IfcBuildingElementProxy: L3J_PRESA_CORRENT_EMPOTRABLE:EMPOTRABLE (26)
In: PLANTA BAIXA
Type - Material: Nuevo material por defecto
Type - Pset_ManufacturerTypeInformation - Manufacturer: NIESSEN
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.40.20; 105.AMB.ClassificacioDescripcio: Preses; 109.AMB.CodiTipus: COM-09; 111.AMB.DescripcioTipus: TIPUS SCHUCKO O EQUIVALENT
Classification: 50.60.40.20 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_PRESA_CORRENT_EMPOTRABLE:EMPOTRABLE; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: EMPOTRABLE; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0147745 m2; 509.AMB.Volum: 0.000151145 m3
Name (L3J_PRESA_CORRENT_EMPOTRABLE:EMPOTRABLE:...) | 117.AMB.Localitzacio
3191432 | Nau Lateral Sud
3193209 | Nau Santa Eulalia
3193320 | Nau Santa Eulalia
3193354 | Nau Santa Eulalia
3193448 | Nau Santa Eulalia
3193573 | Nau Santa Eulalia
3193678 | Nau Santa Eulalia
3193697 | Nau Santa Eulalia
3194036 | Nau Santa Eulalia
3194070 | Nau Santa Eulalia
3194142 | Nau Santa Eulalia
3194231 | Nau Santa Eulalia
3195289 | Annex
3715137 | Nau Santa Eulalia
3887843 | Nau Santa Eulalia
3890861 | Nau Santa Eulalia
3891043 | Nau Santa Eulalia
3891056 | Nau Santa Eulalia
3891221 | Nau Santa Eulalia
3899319 | Nau Santa Eulalia
3899328 | Nau Santa Eulalia
3900040 | Nau Santa Eulalia
3900047 | Nau Santa Eulalia
3900763 | Nau Santa Eulalia
5088679 | Nau Santa Eulalia
5190935 | Nau Lateral Sud

# IfcBuildingElementProxy: L3J_PRESA_CORRENT_EMPOTRABLE:ESTANC (2)
In: PLANTA BAIXA
Type - Material: Nuevo material por defecto
Type - Pset_ManufacturerTypeInformation - Manufacturer: NIESSEN
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.40.20; 105.AMB.ClassificacioDescripcio: Preses; 109.AMB.CodiTipus: COM-10; 111.AMB.DescripcioTipus: TIPUS SCHUCKO O EQUIVALENT
Classification: 50.60.40.20 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_PRESA_CORRENT_EMPOTRABLE:ESTANC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: ESTANC; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0147745 m2; 509.AMB.Volum: 0.000151145 m3
Name (L3J_PRESA_CORRENT_EMPOTRABLE:ESTANC:...)
3195241
3195260

# IfcBuildingElementProxy: L3J_PlACA VIDEOPORTERO:PORTER AUTOMÀTIC.TELÈFON.GEN (4)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.70.50.10; 105.AMB.ClassificacioDescripcio: Equips de telecomunicacions; 109.AMB.CodiTipus: COM
Classification: 50.70.50.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_PlACA VIDEOPORTERO:PORTER AUTOMÀTIC.TELÈFON.GEN; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: PORTER AUTOMÀTIC.TELÈFON.GEN; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0977262 m2; 509.AMB.Volum: 0.00307274 m3
Name (L3J_PlACA VIDEOPORTERO:PORTER AUTOMÀTIC.TELÈFON.GEN:...)
3893271
3898268
3898909
3898937

# IfcBuildingElementProxy: L3J_QUAD_ELEC_GENERAL_BT:100 A (2)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.10.10; 105.AMB.ClassificacioDescripcio: Quadres elèctrics; 109.AMB.CodiTipus: ELE-QE
Classification: 50.60.10.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_QUAD_ELEC_GENERAL_BT:100 A; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: 100 A; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 509.AMB.Volum: 0.186084 m3
Name (L3J_QUAD_ELEC_GENERAL_BT:100 A, 120 V/208 V, Three Phase, 4 Wires, Wye:...) | 117.AMB.Localitzacio
3191603 | Nau Santa Eulalia
3235286 | Annex

# IfcBuildingElementProxy: L3J_QUAD_ELEC_GENERAL_BT:OAC, L3J_QUAD_ELEC_GENERAL_BT:OAC, 120 V/208 V, Three Phase, 4 Wires, Wye:3191632
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.10.10; 105.AMB.ClassificacioDescripcio: Quadres elèctrics; 109.AMB.CodiTipus: ELE-QE
Classification: 50.60.10.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_QUAD_ELEC_GENERAL_BT:OAC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: OAC; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 509.AMB.Volum: 0.1155 m3

# IfcBuildingElementProxy: L3J_SPLIT_PARET:Panasonic_S-60PK2E5B (2)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-UIRS
Classification: 50.30.10.30 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_SPLIT_PARET:Panasonic_S-60PK2E5B; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Panasonic_S-60PK2E5B; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.558806 m2; 509.AMB.Volum: 0.0645775 m3
Name (L3J_SPLIT_PARET:Panasonic_S-60PK2E5B:...) | 117.AMB.Localitzacio | Group
3235928 | Nau Santa Eulalia | L3J_4_SAN_FECAL 3; L3J_3_CALEF_RET 4; L3J_3_CALEF_IMP 4
4946902 | Nau Lateral Sud | L3J_3_CALEF_IMP 23; L3J_3_CALEF_RET 17; L3J_4_SAN_FECAL 1

# IfcBuildingElementProxy: L3J_SUBQUAD_ELEC:100 A, L3J_SUBQUAD_ELEC:100 A:3235380
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.60.10.10; 105.AMB.ClassificacioDescripcio: Quadres elèctrics; 109.AMB.CodiTipus: ELE-QE
Classification: 50.60.10.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_SUBQUAD_ELEC:100 A; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: 100 A; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 509.AMB.Volum: 0.468 m3

# IfcBuildingElementProxy: L3J_TERMOSTAT_CLIMA:TERMOSTAT CLIMA 1 (7)
In: PLANTA BAIXA
Type - Material: Nuevo material por defecto
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.60.10; 105.AMB.ClassificacioDescripcio: Cablejat / BUS de climatització; 109.AMB.CodiTipus: CLI-TERM
Classification: 50.30.60.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_TERMOSTAT_CLIMA:TERMOSTAT CLIMA 1; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: TERMOSTAT CLIMA 1; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0486287 m2; 509.AMB.Volum: 0.000614156 m3
Name (L3J_TERMOSTAT_CLIMA:TERMOSTAT CLIMA 1:...)
3231367
3231377
3231427
3231933
4537319
4537354
4537939

# IfcBuildingElementProxy: L3J_TERMOSTAT_CLIMA_2:TERMOSTAT CLIMA 2 (4)
In: PLANTA BAIXA
Type - Material: Nuevo material por defecto
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.60.10; 105.AMB.ClassificacioDescripcio: Cablejat / BUS de climatització; 109.AMB.CodiTipus: CLI-TERM2
Classification: 50.30.60.10 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_TERMOSTAT_CLIMA_2:TERMOSTAT CLIMA 2; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: TERMOSTAT CLIMA 2; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.0486287 m2; 509.AMB.Volum: 0.000614156 m3
Name (L3J_TERMOSTAT_CLIMA_2:TERMOSTAT CLIMA 2:...) | 117.AMB.Localitzacio
3232108 | Nau Santa Eulalia
3236739 | Nau Santa Eulalia
4951158 | Nau Lateral Sud
4951222 | Nau Lateral Sud

# IfcBuildingElementProxy: L3J_UNIDAD INTERIOR_LG:L3J_CM18F-N11_LG_270X900X700, L3J_UNIDAD INTERIOR_LG:L3J_CM18F-N11_LG_270X900X700:2993212
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-UI
Classification: 50.30.10.30 Uniformat (Uniformat); Group: L3J_4_SAN_FECAL 3; L3J_3_CALEF_IMP 3; L3J_3_CALEF_RET 5; Mecánica L3J_3_CLIMA_IMP_AIRE 8; Mecánica L3J_3_CLIMA_RET_AIRE 12
Pset_BuildingElementProxyCommon - Reference: L3J_UNIDAD INTERIOR_LG:L3J_CM18F-N11_LG_270X900X700; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CM18F-N11_LG_270X900X700; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.52242 m2; 509.AMB.Volum: 0.180895 m3

# IfcBuildingElementProxy: L3J_UNIDAD INTERIOR_LG:L3J_CM18F-N11_LG_270X900X700_REGIDURIA, L3J_UNIDAD INTERIOR_LG:L3J_CM18F-N11_LG_270X900X700_REGIDURIA:3384852
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-UI
Classification: 50.30.10.30 Uniformat (Uniformat); Group: L3J_4_SAN_FECAL 1 (2); L3J_3_CALEF_IMP 25; L3J_3_CALEF_RET 19; Mecánica L3J_3_CLIMA_IMP_AIRE 9; Mecánica L3J_3_CLIMA_RET_AIRE 2
Pset_BuildingElementProxyCommon - Reference: L3J_UNIDAD INTERIOR_LG:L3J_CM18F-N11_LG_270X900X700_REGIDURIA; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_CM18F-N11_LG_270X900X700_REGIDURIA; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.52242 m2; 509.AMB.Volum: 0.180895 m3

# IfcBuildingElementProxy: L3J_UNIDAD INTERIOR_LG:L3J_UM60F.N30_LG_1250x360x700, L3J_UNIDAD INTERIOR_LG:L3J_UM60F.N30_LG_1250x360x700:2993228
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-UI
Classification: 50.30.10.30 Uniformat (Uniformat); Group: L3J_4_SAN_FECAL 1 (2); L3J_3_CALEF_IMP 13; L3J_3_CALEF_RET 13; Mecánica L3J_3_CLIMA_IMP_AIRE 10; Mecánica L3J_3_CLIMA_RET_AIRE 1
Pset_BuildingElementProxyCommon - Reference: L3J_UNIDAD INTERIOR_LG:L3J_UM60F.N30_LG_1250x360x700; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_UM60F.N30_LG_1250x360x700; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 2.42903 m2; 509.AMB.Volum: 0.336288 m3

# IfcBuildingElementProxy: L3J_UNITAT_EXTERIOR_1x1:Panasonic_U-60PZH2E5 (2)
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.20; 105.AMB.ClassificacioDescripcio: Unitats exteriors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: H09S1D.U12
Classification: 50.30.10.20 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_UNITAT_EXTERIOR_1x1:Panasonic_U-60PZH2E5; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: Panasonic_U-60PZH2E5; 115.AMB.Nivell: PLANTA COBERTA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.634363 m2; 509.AMB.Volum: 0.0816332 m3
Name (L3J_UNITAT_EXTERIOR_1x1:Panasonic_U-60PZH2E5:...) | 117.AMB.Localitzacio | Group
3746639 | Nau Santa Eulalia | L3J_3_CALEF_IMP 21; L3J_3_CALEF_RET 7
4893760 | Nau Lateral Sud | L3J_3_CALEF_IMP 23; L3J_3_CALEF_RET 17

# IfcBuildingElementProxy: L3J_VENTILADOR:TraceParts (4)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Soler & Palau
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.80; 105.AMB.ClassificacioDescripcio: Ventiladors; 109.AMB.CodiTipus: CLI-VE
Classification: 50.30.10.80 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: L3J_VENTILADOR:TraceParts; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: TraceParts; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.390564 m2; 509.AMB.Volum: 0.00329908 m3
Name (L3J_VENTILADOR:TraceParts:...) | 117.AMB.Localitzacio | Group
3015141 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3; Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
3016772 | Annex | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1; Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
3016844 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6; Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
3016866 | Nau Santa Eulalia | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4; Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5

# IfcBuildingElementProxy: LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU07GL4G4- 286x463x300 (2)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG Electronics
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-UE
Classification: 50.30.10.30 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU07GL4G4- 286x463x300; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: ARNU07GL4G4- 286x463x300; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.62632 m2; 509.AMB.Volum: 0.18181 m3
Name (LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU07GL4G4- 286x463x300:...) | Group
2971178 | L3J_4_SAN_FECAL 3; Mecánica L3J_3_CLIMA_RET_AIRE 9; L3J_3_CALEF_IMP 2; L3J_3_CALEF_RET 2
2995140 | L3J_4_SAN_FECAL 3; L3J_3_CALEF_IMP 1; L3J_3_CALEF_RET 1; Mecánica L3J_3_CLIMA_IMP_AIRE 7; Mecánica L3J_3_CLIMA_RET_AIRE 6

# IfcBuildingElementProxy: LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU12GM1A4- 286x463x300, LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU12GM1A4- 286x463x300:2991668
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG Electronics
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-UE
Classification: 50.30.10.30 Uniformat (Uniformat); Group: L3J_4_SAN_FECAL 3; L3J_3_CALEF_IMP 2; L3J_3_CALEF_RET 2; Mecánica L3J_3_CLIMA_RET_AIRE 10; Mecánica L3J_3_CLIMA_IMP_AIRE 4
Pset_BuildingElementProxyCommon - Reference: LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU12GM1A4- 286x463x300; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: ARNU12GM1A4- 286x463x300; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.62632 m2; 509.AMB.Volum: 0.18181 m3

# IfcBuildingElementProxy: LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU15GM1A4- 286x463x300, LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU15GM1A4- 286x463x300:2991812
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG Electronics
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-UE
Classification: 50.30.10.30 Uniformat (Uniformat); Group: L3J_4_SAN_FECAL 3; L3J_3_CALEF_IMP 2; L3J_3_CALEF_RET 2; Mecánica L3J_3_CLIMA_RET_AIRE 11; Mecánica L3J_3_CLIMA_IMP_AIRE 2
Pset_BuildingElementProxyCommon - Reference: LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU15GM1A4- 286x463x300; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: ARNU15GM1A4- 286x463x300; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.62632 m2; 509.AMB.Volum: 0.18181 m3

# IfcBuildingElementProxy: LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU18GM1A4- 286x463x301 (2)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG Electronics
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-UE
Classification: 50.30.10.30 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU18GM1A4- 286x463x301; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: ARNU18GM1A4- 286x463x301; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.62632 m2; 509.AMB.Volum: 0.18181 m3
Name (LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU18GM1A4- 286x463x301:...) | Group
2991844 | L3J_4_SAN_FECAL 3; Mecánica L3J_3_CLIMA_IMP_AIRE 1; Mecánica L3J_3_CLIMA_RET_AIRE 4; L3J_3_CALEF_IMP 1; L3J_3_CALEF_RET 1
2995104 | L3J_4_SAN_FECAL 3; L3J_3_CALEF_IMP 1; L3J_3_CALEF_RET 1; Mecánica L3J_3_CLIMA_IMP_AIRE 6; Mecánica L3J_3_CLIMA_RET_AIRE 5

# IfcBuildingElementProxy: LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU24GM1A4- 286x463x302, LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU24GM1A4- 286x463x302:2993064
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG Electronics
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-UE
Classification: 50.30.10.30 Uniformat (Uniformat); Group: L3J_4_SAN_FECAL 3; L3J_3_CALEF_IMP 2; L3J_3_CALEF_RET 2; Mecánica L3J_3_CLIMA_RET_AIRE 3; Mecánica L3J_3_CLIMA_IMP_AIRE 5
Pset_BuildingElementProxyCommon - Reference: LG_MultiV_Indoor_Low_Static_Duct_1.7-2.8kW_L1_EU_v1.0:ARNU24GM1A4- 286x463x302; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: ARNU24GM1A4- 286x463x302; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.62632 m2; 509.AMB.Volum: 0.18181 m3

# IfcBuildingElementProxy: LG_Single_R32_Free_Combi_Outdoor_U3_48MBh_EU:UUD1.U30 950 x 1380 x 330, LG_Single_R32_Free_Combi_Outdoor_U3_48MBh_EU:UUD1.U30 950 x 1380 x 330:3123296
In: PLANTA COBERTA
Type - Material: LG Outdoor, LG-Forming, LG-Fan, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG Electronics
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.20; 105.AMB.ClassificacioDescripcio: Unitats exteriors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-1x1
Classification: 50.30.10.20 Uniformat (Uniformat); Group: L3J_3_CALEF_RET 15; L3J_3_CALEF_IMP 22
Pset_BuildingElementProxyCommon - Reference: LG_Single_R32_Free_Combi_Outdoor_U3_48MBh_EU:UUD1.U30 950 x 1380 x 330; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: UUD1.U30 950 x 1380 x 330; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 3.11712 m2; 509.AMB.Volum: 0.440788 m3

# IfcBuildingElementProxy: LG_Single_R32_Free_Combi_Outdoor_UL2_12MBh_EU:UUA1.UL0 770 x 545 x 288 (2)
In: PLANTA COBERTA
Type - Material: LG Outdoor, LG-Forming, LG-Fan, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG Electronics
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.20; 105.AMB.ClassificacioDescripcio: Unitats exteriors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-1x1
Classification: 50.30.10.20 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: LG_Single_R32_Free_Combi_Outdoor_UL2_12MBh_EU:UUA1.UL0 770 x 545 x 288; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: UUA1.UL0 770 x 545 x 288; 115.AMB.Nivell: PLANTA COBERTA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.07317 m2; 509.AMB.Volum: 0.121601 m3
Name (LG_Single_R32_Free_Combi_Outdoor_UL2_12MBh_EU:UUA1.UL0 770 x 545 x 288:...) | 117.AMB.Localitzacio | Group
3124397 | Nau Lateral Sud | L3J_3_CALEF_RET 18; L3J_3_CALEF_IMP 24
3125472 | Nau Santa Eulalia | L3J_3_CALEF_RET 6; L3J_3_CALEF_IMP 5

# IfcBuildingElementProxy: LG_VRF_Air_Source_HR_MV_S_15.5kW_EU_v2.1:LG_VRF_Air_Source_HR_MV_S_15.5kW_EU_v2.1 (2)
In: PLANTA COBERTA
Type - Material: LG Outdoor, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG Electronics
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.30; 105.AMB.ClassificacioDescripcio: Unitats interiors d'instal·lacions tèrmiques; 109.AMB.CodiTipus: CLI-VRF
Classification: 50.30.10.30 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: LG_VRF_Air_Source_HR_MV_S_15.5kW_EU_v2.1:LG_VRF_Air_Source_HR_MV_S_15.5kW_EU_v2.1; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: LG_VRF_Air_Source_HR_MV_S_15.5kW_EU_v2.1; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 10.2395 m2; 509.AMB.Volum: 0.440948 m3
Name (LG_VRF_Air_Source_HR_MV_S_15.5kW_EU_v2.1:LG_VRF_Air_Source_HR_MV_S_15.5kW_EU_v2.1:...) | Group
3711368 | L3J_3_CALEF_RET 3; L3J_3_CALEF_IMP 14; L3J_3_CALEF_IMP 11
3719803 | L3J_3_CALEF_RET 16; L3J_3_CALEF_IMP 19; L3J_3_CALEF_IMP 17

# IfcBuildingElementProxy: LG_VRF_HR_Unit_Serial3_3_Port_Global:PRHR033A, LG_VRF_HR_Unit_Serial3_3_Port_Global:PRHR033A:3705739
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG Electronics
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.10; 105.AMB.ClassificacioDescripcio: Línies frigorífiques; 109.AMB.CodiTipus: CLI-VRF
Classification: 50.30.30.10 Uniformat (Uniformat); Group: L3J_3_CALEF_IMP 1; L3J_3_CALEF_RET 1; L3J_3_CALEF_IMP 8; L3J_3_CALEF_IMP 10; L3J_3_CALEF_RET 9
Pset_BuildingElementProxyCommon - Reference: LG_VRF_HR_Unit_Serial3_3_Port_Global:PRHR033A; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: PRHR033A; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.707736 m2; 509.AMB.Volum: 0.0510759 m3

# IfcBuildingElementProxy: LG_VRF_HR_Unit_Serial3_4_Port_Global:PRHR043A, LG_VRF_HR_Unit_Serial3_4_Port_Global:PRHR043A:3705318
In: PLANTA COBERTA
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: LG Electronics
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.10; 105.AMB.ClassificacioDescripcio: Línies frigorífiques; 109.AMB.CodiTipus: CLI-VRF
Classification: 50.30.30.10 Uniformat (Uniformat); Group: L3J_3_CALEF_IMP 2; L3J_3_CALEF_RET 2; L3J_3_CALEF_IMP 16; L3J_3_CALEF_IMP 18; L3J_3_CALEF_RET 14
Pset_BuildingElementProxyCommon - Reference: LG_VRF_HR_Unit_Serial3_4_Port_Global:PRHR043A; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: PRHR043A; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.715663 m2; 509.AMB.Volum: 0.0511292 m3

# IfcBuildingElementProxy: SIT_OriginLocation_RVT24:SIT_OriginLocation_RVT24 (2)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 00.10.20; 105.AMB.ClassificacioDescripcio: Elements d'alineació de model
Classification: 00.10.20 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: SIT_OriginLocation_RVT24:SIT_OriginLocation_RVT24; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: SIT_OriginLocation_RVT24; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 1.18301 m2; 509.AMB.Volum: 0.166667 m3
Name (SIT_OriginLocation_RVT24:SIT_OriginLocation_RVT24:...)
2967181 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau de Sta. Eulalia
2967505

# IfcCovering: Pipe Insulation:L3J_ARMAFLEX (15)
In: PLANTA COBERTA
Type - Pset_CoveringCommon - Material: L3J_Armaflex
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.20; 105.AMB.ClassificacioDescripcio: Línies hidràuliques; 109.AMB.CodiTipus: CLI-AIS
Classification: 50.30.30.20 Uniformat (Uniformat); Material: L3J_Armaflex
Pset_CoveringCommon - Reference: Pipe Insulation:L3J_ARMAFLEX; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_ARMAFLEX; 112.AMB.Servei: L3J_3_CALEF_IMP; 119.AMB.FaseCreacio: Obra
Name (Pipe Insulation:L3J_ARMAFLEX:...) | 504.AMB.Gruix (m)
3728460 | 0.015
3728461 | 0.015 | 5 AMB.Geometria - 507.AMB.Area: 0.0553777 m2; 509.AMB.Volum: 0.000830666 m3
3728602 | 0.015
3728607 | 0.015
3743308 | 0.01 | 5 AMB.Geometria - 507.AMB.Area: 0.120831 m2; 509.AMB.Volum: 0.00120831 m3
3743333 | 0.01 | 5 AMB.Geometria - 507.AMB.Area: 0.097947 m2; 509.AMB.Volum: 0.00097947 m3
3743929 | 0.01 | 5 AMB.Geometria - 507.AMB.Area: 0.0516757 m2; 509.AMB.Volum: 0.000516757 m3
3743934 | 0.01
3743963 | 0.01 | 5 AMB.Geometria - 507.AMB.Area: 0.0423124 m2; 509.AMB.Volum: 0.000423124 m3
3743968 | 0.01
3746516 | 0.015
3746591 | 0.015
3748728 | 0.01 | 5 AMB.Geometria - 507.AMB.Area: 0.297164 m2; 509.AMB.Volum: 0.00297164 m3
3748775 | 0.01 | 5 AMB.Geometria - 507.AMB.Area: 0.372995 m2; 509.AMB.Volum: 0.00372995 m3
3751078 | 0.01

# IfcDistributionControlElement: L3J_CENTRAL_DETECCIO_INCENDIS:GENERIC, L3J_CENTRAL_DETECCIO_INCENDIS:GENERIC:4893761
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.20.10; 105.AMB.ClassificacioDescripcio: Centraletes i racks de detecció d'incendis; 109.AMB.CodiTipus: PCI-CEN
Classification: 50.50.20.10 Uniformat (Uniformat)
Pset_QuantityTakeOff - Reference: L3J_CENTRAL_DETECCIO_INCENDIS:GENERIC
1 AMB.Identificacio - 107.AMB.NomTipus: GENERIC; 115.AMB.Nivell: PLANTA BAIXA; 117.AMB.Localitzacio: Annex; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 0.12 m2; 509.AMB.Volum: 0.0045 m3

# IfcDistributionPort (4427)
Description: Flow
Name | FlowDirection | Group
InPort_2969144_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_2969474_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683152_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_2969144_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_2969474_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_2969387_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_2969387_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683187_1 | SOURCE | L3J_4_SAN_FECAL 3
Port_2971178_4 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 9
Port_2971178_5 | SOURCEANDSINK
Port_2971178_6 | SOURCEANDSINK
InPort_2971178_7 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735354_0 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735721_0 | SINK | L3J_3_CALEF_RET 2
OutPort_2971178_8 | SOURCE | L3J_3_CALEF_RET 2
Port_2971178_9 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691966_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_2971178_10 | SOURCEANDSINK
InPort_2974285_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_2974810_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3684970_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_2974285_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_2974810_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_2974658_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_2974658_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3061550_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3364981_2 | SINK | L3J_2_AFS 1
OutPort_2975569_0 | SOURCE | L3J_2_AFS 1
InPort_2975569_1 | SINK | L3J_2_AFS 1
OutPort_3349338_2 | SOURCE | L3J_2_AFS 1
Port_2975691_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009726_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_2975691_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009685_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_2975754_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064706_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_2975754_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065371_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_2975768_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009620_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_2975768_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009624_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_2975786_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009657_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_2975786_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009620_1 | SOURCEANDSINK | L3J_2_AFS 1
InPort_2976014_1 | SINK | L3J_2_AFS 1
OutPort_4059643_1 | SOURCE | L3J_2_AFS 1
InPort_3985687_1 | SINK | L3J_2_AFS 1
OutPort_2976014_2 | SOURCE | L3J_2_AFS 1
InPort_2976246_0 | SINK | L3J_2_AFS 1
OutPort_3674490_2 | SOURCE | L3J_2_AFS 1
InPort_4060942_1 | SINK | L3J_2_AFS 1
OutPort_2976246_1 | SOURCE | L3J_2_AFS 1
InPort_2976255_0 | SINK | L3J_2_AFS 1
OutPort_3364500_1 | SOURCE | L3J_2_AFS 1
InPort_3674490_1 | SINK | L3J_2_AFS 1
OutPort_2976255_1 | SOURCE | L3J_2_AFS 1
InPort_2976393_0 | SINK | L3J_2_AFS 1
OutPort_2976409_2 | SOURCE | L3J_2_AFS 1
InPort_3037314_1 | SINK | L3J_2_AFS 1
OutPort_2976393_1 | SOURCE | L3J_2_AFS 1
InPort_2976402_0 | SINK | L3J_2_AFS 1
OutPort_3349340_2 | SOURCE | L3J_2_AFS 1
InPort_2976409_1 | SINK | L3J_2_AFS 1
OutPort_2976402_1 | SOURCE | L3J_2_AFS 1
InPort_3349338_1 | SINK | L3J_2_AFS 1
OutPort_2976404_1 | SOURCE | L3J_2_AFS 1
InPort_2976404_2 | SINK | L3J_2_AFS 1
OutPort_3356023_1 | SOURCE | L3J_2_AFS 1
InPort_3349340_1 | SINK | L3J_2_AFS 1
OutPort_2976404_3 | SOURCE | L3J_2_AFS 1
InPort_3356023_2 | SINK | L3J_2_AFS 1
OutPort_2976405_0 | SOURCE | L3J_2_AFS 1
InPort_2976405_1 | SINK | L3J_2_AFS 1
OutPort_4059631_1 | SOURCE | L3J_2_AFS 1
Port_2976528_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012177_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_2976528_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009657_1 | SOURCEANDSINK | L3J_2_AFS 1
InPort_2976636_0 | SINK | L3J_2_AFS 2
InPort_4057573_1 | SINK | L3J_2_AFS 2
OutPort_2976636_1 | SOURCE | L3J_2_AFS 2
InPort_4065941_1 | SINK | L3J_2_AFS 1
OutPort_2976747_0 | SOURCE | L3J_2_AFS 1
InPort_2976747_1 | SINK | L3J_2_AFS 1
OutPort_2976785_1 | SOURCE | L3J_2_AFS 1
InPort_2976785_2 | SINK | L3J_2_AFS 1
OutPort_2976783_0 | SOURCE | L3J_2_AFS 1
InPort_2976783_1 | SINK | L3J_2_AFS 1
OutPort_2977228_1 | SOURCE | L3J_2_AFS 1
InPort_4065350_2 | SINK | L3J_2_AFS 1
OutPort_2976849_0 | SOURCE | L3J_2_AFS 1
InPort_2976849_1 | SINK | L3J_2_AFS 1
OutPort_4065353_1 | SOURCE | L3J_2_AFS 1
InPort_2977024_2 | SINK | L3J_2_AFS 1
OutPort_2976862_0 | SOURCE | L3J_2_AFS 1
InPort_2976862_1 | SINK | L3J_2_AFS 1
OutPort_2976868_1 | SOURCE | L3J_2_AFS 1
InPort_2976865_0 | SINK | L3J_2_AFS 1
OutPort_2977024_1 | SOURCE | L3J_2_AFS 1
InPort_3206904_1 | SINK | L3J_2_AFS 1
OutPort_2976865_1 | SOURCE | L3J_2_AFS 1
InPort_2976868_2 | SINK | L3J_2_AFS 1
OutPort_4065265_0 | SOURCE | L3J_2_AFS 1
InPort_2977228_2 | SINK | L3J_2_AFS 1
OutPort_2977261_0 | SOURCE | L3J_2_AFS 1
InPort_2977261_1 | SINK | L3J_2_AFS 1
OutPort_4065350_1 | SOURCE | L3J_2_AFS 1
Port_2977579_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064605_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_2977579_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4066094_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_2977581_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064601_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_2977581_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064605_1 | SOURCEANDSINK | L3J_2_AFS 1
InPort_2977890_0 | SINK | L3J_2_AFS 1
OutPort_2978403_1 | SOURCE | L3J_2_AFS 1
InPort_3199111_1 | SINK | L3J_2_AFS 1
OutPort_2977890_1 | SOURCE | L3J_2_AFS 1
InPort_3035997_1 | SINK | L3J_2_AFS 1
OutPort_2977914_0 | SOURCE | L3J_2_AFS 1
InPort_2977914_1 | SINK | L3J_2_AFS 1
OutPort_3293735_2 | SOURCE | L3J_2_AFS 1
Port_2977937_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_5117439_3 | SOURCEANDSINK | L3J_2_AFS 1
Port_2977937_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_3991753_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_2977946_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4059679_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_2977946_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058892_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_2978053_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009892_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_2978053_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058892_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_2978055_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_2978055_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009892_1 | SOURCEANDSINK | L3J_2_AFS 1
InPort_2978253_2 | SINK | L3J_2_AFS 1
OutPort_2978219_0 | SOURCE | L3J_2_AFS 1
InPort_2978219_1 | SINK | L3J_2_AFS 1
OutPort_3991344_1 | SOURCE | L3J_2_AFS 1
InPort_2978222_0 | SINK | L3J_2_AFS 1
OutPort_2978253_1 | SOURCE | L3J_2_AFS 1
InPort_3199154_1 | SINK | L3J_2_AFS 1
OutPort_2978222_1 | SOURCE | L3J_2_AFS 1
InPort_2978282_0 | SINK | L3J_2_AFS 1
OutPort_3991553_1 | SOURCE | L3J_2_AFS 1
InPort_3921395_1 | SINK | L3J_2_AFS 1
OutPort_2978282_1 | SOURCE | L3J_2_AFS 1
InPort_2978352_0 | SINK | L3J_2_AFS 1
OutPort_3991342_2 | SOURCE | L3J_2_AFS 1
InPort_3991344_2 | SINK | L3J_2_AFS 1
OutPort_2978352_1 | SOURCE | L3J_2_AFS 1
InPort_2978381_2 | SINK | L3J_2_AFS 1
OutPort_2978356_0 | SOURCE | L3J_2_AFS 1
InPort_2978356_1 | SINK | L3J_2_AFS 1
OutPort_3921190_1 | SOURCE | L3J_2_AFS 1
InPort_2978403_2 | SINK | L3J_2_AFS 1
OutPort_2978375_0 | SOURCE | L3J_2_AFS 1
InPort_2978375_1 | SINK | L3J_2_AFS 1
OutPort_2978381_1 | SOURCE | L3J_2_AFS 1
Port_2991668_4 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3445698_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_2991668_5 | SOURCEANDSINK
InPort_3117014_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_2991668_6 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_2991668_7 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735135_0 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3731171_0 | SINK | L3J_3_CALEF_RET 2
OutPort_2991668_8 | SOURCE | L3J_3_CALEF_RET 2
Port_2991668_9 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285547_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_2991668_10 | SOURCEANDSINK
Port_2991812_4 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_3439225_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_2991812_5 | SOURCEANDSINK
Port_2991812_6 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
Port_3433205_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_2991812_7 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735501_0 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3737479_1 | SINK | L3J_3_CALEF_RET 2
OutPort_2991812_8 | SOURCE | L3J_3_CALEF_RET 2
Port_2991812_9 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455157_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_2991812_10 | SOURCEANDSINK
Port_2991844_4 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483074_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_2991844_5 | SOURCEANDSINK
Port_2991844_6 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482314_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
InPort_2991844_7 | SINK | L3J_3_CALEF_IMP 1
OutPort_3755735_0 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756193_0 | SINK | L3J_3_CALEF_RET 1
OutPort_2991844_8 | SOURCE | L3J_3_CALEF_RET 1
Port_2991844_9 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3491798_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_2991844_10 | SOURCEANDSINK
Port_2993064_4 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760673_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_2993064_5 | SOURCEANDSINK
InPort_3445608_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_2993064_6 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_2993064_7 | SINK | L3J_3_CALEF_IMP 2
OutPort_3734014_0 | SOURCE | L3J_3_CALEF_IMP 2
Port_2993064_8 | SOURCEANDSINK | L3J_3_CALEF_RET 2
Port_3730123_0 | SOURCEANDSINK | L3J_3_CALEF_RET 2
Port_2993064_9 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3493113_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_2993064_10 | SOURCEANDSINK
Port_2993212_1 | SOURCEANDSINK
InPort_3765939_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_2993212_4 | SOURCE | L3J_4_SAN_FECAL 3
Port_2993212_5 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3738301_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_2993212_6 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3738266_1 | SOURCEANDSINK | L3J_3_CALEF_RET 5
InPort_4957273_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 8
OutPort_2993212_7 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 8
InPort_2993212_8 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
OutPort_3871686_1 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_2993212_9 | SOURCEANDSINK
Port_2993228_1 | SOURCEANDSINK
InPort_3663742_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_2993228_4 | SOURCE | L3J_4_SAN_FECAL 1 (2)
Port_2993228_5 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947279_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_2993228_6 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948181_0 | SOURCEANDSINK | L3J_3_CALEF_RET 13
InPort_3646924_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_2993228_7 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_2993228_8 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
OutPort_3655637_0 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_2993228_9 | SOURCEANDSINK
InPort_3869734_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_2995104_4 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
Port_2995104_5 | SOURCEANDSINK
Port_2995104_6 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485388_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
InPort_2995104_7 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756652_0 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756678_0 | SINK | L3J_3_CALEF_RET 1
OutPort_2995104_8 | SOURCE | L3J_3_CALEF_RET 1
Port_2995104_9 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490213_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_2995104_10 | SOURCEANDSINK
InPort_3867051_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_2995140_4 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
Port_2995140_5 | SOURCEANDSINK
Port_2995140_6 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3487374_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
InPort_2995140_7 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756757_1 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756785_1 | SINK | L3J_3_CALEF_RET 1
OutPort_2995140_8 | SOURCE | L3J_3_CALEF_RET 1
Port_2995140_9 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3254769_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_2995140_10 | SOURCEANDSINK
InPort_2997532_5 | SINK | L3J_4_SAN_FECAL 3
OutPort_3824582_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_2997532_6 | SINK | L3J_4_SAN_PLUVIAL 4
InPort_2997532_7 | SINK | L3J_4_SAN_PLUVIAL 2
InPort_2997532_8 | SINK | L3J_4_SAN_PLUVIAL 1
OutPort_3825602_0 | SOURCE | L3J_4_SAN_PLUVIAL 1
InPort_2997532_9 | SINK
InPort_2997532_10 | SINK
InPort_2997532_11 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_4838804_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_2997532_12 | SINK
OutPort_2997532_13 | SOURCE
OutPort_2997532_14 | SOURCE
OutPort_2997532_15 | SOURCE
OutPort_2997532_16 | SOURCE
OutPort_2997532_17 | SOURCE
OutPort_2997532_18 | SOURCE
OutPort_2997532_19 | SOURCE
OutPort_2997532_20 | SOURCE
Port_3002897_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5213151_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_3002897_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_3013282_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3789286_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3013282_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
InPort_3015141_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
OutPort_3771288_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
InPort_3770598_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
OutPort_3015141_2 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
InPort_3016772_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1
OutPort_3016984_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1
InPort_3363240_0 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
OutPort_3016772_2 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
InPort_3016844_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
OutPort_3020589_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
InPort_3306781_0 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
OutPort_3016844_2 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
InPort_3016866_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
OutPort_3673663_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
InPort_3306897_0 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
OutPort_3016866_2 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
InPort_3016984_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1
OutPort_4968959_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1
InPort_4968959_2 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1
OutPort_3017006_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1
InPort_3017006_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 1
InPort_3019357_0 | SINK | L3J_2_AFS 1
OutPort_3768794_2 | SOURCE | L3J_2_AFS 1
InPort_3768870_1 | SINK | L3J_2_AFS 1
OutPort_3019357_1 | SOURCE | L3J_2_AFS 1
InPort_3019403_0 | SINK | L3J_2_AFS 1
OutPort_3019407_2 | SOURCE | L3J_2_AFS 1
InPort_3019542_1 | SINK | L3J_2_AFS 1
OutPort_3019403_1 | SOURCE | L3J_2_AFS 1
InPort_3019407_1 | SINK | L3J_2_AFS 1
OutPort_3019782_1 | SOURCE | L3J_2_AFS 1
InPort_3019469_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767289_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3690673_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3019469_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3019471_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3054676_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767289_3 | SINK | L3J_4_SAN_FECAL 3
OutPort_3019471_1 | SOURCE | L3J_4_SAN_FECAL 3
Port_3019711_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4011830_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_3019711_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012177_2 | SOURCEANDSINK | L3J_2_AFS 1
InPort_3019753_0 | SINK | L3J_2_AFS 1
OutPort_3772358_1 | SOURCE | L3J_2_AFS 1
InPort_3768794_1 | SINK | L3J_2_AFS 1
OutPort_3019753_1 | SOURCE | L3J_2_AFS 1
InPort_3019755_0 | SINK | L3J_2_AFS 1
OutPort_3019940_2 | SOURCE | L3J_2_AFS 1
InPort_3772392_1 | SINK | L3J_2_AFS 1
OutPort_3019755_1 | SOURCE | L3J_2_AFS 1
InPort_3019782_0 | SINK | L3J_2_AFS 1
OutPort_3019936_1 | SOURCE | L3J_2_AFS 1
InPort_3019936_2 | SINK | L3J_2_AFS 1
OutPort_3019784_0 | SOURCE | L3J_2_AFS 1
InPort_3019784_1 | SINK | L3J_2_AFS 1
OutPort_3019940_3 | SOURCE | L3J_2_AFS 1
InPort_3019940_1 | SINK | L3J_2_AFS 1
OutPort_4012053_0 | SOURCE | L3J_2_AFS 1
InPort_3020435_0 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
OutPort_4968917_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
