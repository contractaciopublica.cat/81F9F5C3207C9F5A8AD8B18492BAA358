Properties of the parts of a building model (IFC2X3), part 5 of 10

# IfcDistributionPort (4427)
Name | FlowDirection | Group
Port_4839472_1 | SOURCEANDSINK
Port_4849894_1 | SOURCEANDSINK
InPort_4893760_1 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949143_0 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949985_1 | SINK | L3J_3_CALEF_RET 17
OutPort_4893760_2 | SOURCE | L3J_3_CALEF_RET 17
Port_4895041_1 | SOURCEANDSINK
Port_4895042_1 | SOURCEANDSINK
Port_4895045_1 | SOURCEANDSINK
Port_4896308_1 | SOURCEANDSINK
Port_4896338_1 | SOURCEANDSINK
Port_4896656_1 | SOURCEANDSINK
Port_4896679_1 | SOURCEANDSINK
Port_4897188_1 | SOURCEANDSINK
Port_4897673_1 | SOURCEANDSINK
Port_4897680_1 | SOURCEANDSINK
Port_4897751_1 | SOURCEANDSINK
Port_4897816_1 | SOURCEANDSINK
Port_4897852_1 | SOURCEANDSINK
Port_4897877_1 | SOURCEANDSINK
Port_4897902_1 | SOURCEANDSINK
Port_4897965_1 | SOURCEANDSINK
Port_4897976_1 | SOURCEANDSINK
Port_4921983_1 | SOURCEANDSINK
Port_4921992_1 | SOURCEANDSINK
Port_4942560_1 | SOURCEANDSINK
Port_4942560_2 | SOURCEANDSINK
Port_4942560_3 | SOURCEANDSINK
Port_4942560_4 | SOURCEANDSINK
Port_4945627_1 | SOURCEANDSINK
Port_4945659_1 | SOURCEANDSINK
Port_4945678_1 | SOURCEANDSINK
InPort_4946902_1 | SINK | L3J_3_CALEF_RET 17
OutPort_4949987_1 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949862_1 | SINK | L3J_3_CALEF_IMP 23
OutPort_4946902_2 | SOURCE | L3J_3_CALEF_IMP 23
Port_4946902_3 | SOURCEANDSINK
InPort_5208902_0 | SINK | L3J_4_SAN_FECAL 1
OutPort_4946902_4 | SOURCE | L3J_4_SAN_FECAL 1
Port_4947279_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947396_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947396_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947426_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947426_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947440_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947434_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947440_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947434_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947521_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947442_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947525_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947442_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947519_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947521_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947519_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
Port_4947525_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 13
InPort_4947764_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_4947978_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_4947978_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_4947964_0 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_4947964_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_4947989_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_4947989_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_4947983_0 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_4947983_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_4948024_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
Port_4948181_1 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948210_2 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948210_1 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948244_0 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948244_1 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948258_2 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948252_0 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948258_1 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948252_1 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948322_1 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948260_0 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948326_2 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948260_1 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948320_0 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948322_2 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948320_1 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948326_1 | SOURCEANDSINK | L3J_3_CALEF_RET 13
Port_4948363_0 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948561_2 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948363_1 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948527_1 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948393_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948564_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948393_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948457_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948444_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948457_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948444_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948465_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948459_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948465_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948459_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948494_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948483_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948494_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948483_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948513_0 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948527_2 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948513_1 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948536_1 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948530_0 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948536_2 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948530_1 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948544_1 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948538_0 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948544_2 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948538_1 | SOURCEANDSINK | L3J_3_CALEF_RET 15
InPort_4949143_1 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949204_1 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949166_0 | SINK | L3J_3_CALEF_RET 17
OutPort_4949985_2 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949243_1 | SINK | L3J_3_CALEF_RET 17
OutPort_4949166_1 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949204_2 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949193_0 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949193_1 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949216_2 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949216_1 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949419_0 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949235_0 | SINK | L3J_3_CALEF_RET 17
OutPort_4949243_2 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949251_2 | SINK | L3J_3_CALEF_RET 17
OutPort_4949235_1 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949245_0 | SINK | L3J_3_CALEF_RET 17
OutPort_4949251_1 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949373_1 | SINK | L3J_3_CALEF_RET 17
OutPort_4949245_1 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949365_0 | SINK | L3J_3_CALEF_RET 17
OutPort_4949373_2 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949397_1 | SINK | L3J_3_CALEF_RET 17
OutPort_4949365_1 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949395_0 | SINK | L3J_3_CALEF_RET 17
OutPort_4949397_2 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949974_1 | SINK | L3J_3_CALEF_RET 17
OutPort_4949395_1 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949419_1 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949433_1 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949433_2 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949427_0 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949427_1 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949646_1 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949436_0 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949904_1 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949906_1 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949436_1 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949646_2 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949644_0 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949644_1 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949906_2 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949967_1 | SINK | L3J_3_CALEF_RET 17
OutPort_4949723_0 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949723_1 | SINK | L3J_3_CALEF_RET 17
OutPort_4949974_2 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949987_2 | SINK | L3J_3_CALEF_RET 17
OutPort_4949799_0 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949799_1 | SINK | L3J_3_CALEF_RET 17
OutPort_4949967_2 | SOURCE | L3J_3_CALEF_RET 17
InPort_4949826_0 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949862_2 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4949904_2 | SINK | L3J_3_CALEF_IMP 23
OutPort_4949826_1 | SOURCE | L3J_3_CALEF_IMP 23
InPort_4950185_1 | SINK | L3J_3_CALEF_IMP 24
OutPort_4950043_1 | SOURCE | L3J_3_CALEF_IMP 24
InPort_4950124_2 | SINK | L3J_3_CALEF_IMP 25
OutPort_4950073_0 | SOURCE | L3J_3_CALEF_IMP 25
InPort_4950073_1 | SINK | L3J_3_CALEF_IMP 25
OutPort_4950149_1 | SOURCE | L3J_3_CALEF_IMP 25
InPort_4950151_2 | SINK | L3J_3_CALEF_IMP 25
OutPort_4950135_0 | SOURCE | L3J_3_CALEF_IMP 25
InPort_4950135_1 | SINK | L3J_3_CALEF_IMP 25
OutPort_4950308_1 | SOURCE | L3J_3_CALEF_IMP 25
InPort_4950149_2 | SINK | L3J_3_CALEF_IMP 25
OutPort_4950147_0 | SOURCE | L3J_3_CALEF_IMP 25
InPort_4950147_1 | SINK | L3J_3_CALEF_IMP 25
OutPort_4950151_1 | SOURCE | L3J_3_CALEF_IMP 25
InPort_4950171_0 | SINK | L3J_3_CALEF_IMP 24
OutPort_4950187_2 | SOURCE | L3J_3_CALEF_IMP 24
InPort_4950591_1 | SINK | L3J_3_CALEF_IMP 24
OutPort_4950171_1 | SOURCE | L3J_3_CALEF_IMP 24
InPort_4950183_0 | SINK | L3J_3_CALEF_IMP 24
OutPort_4950185_2 | SOURCE | L3J_3_CALEF_IMP 24
InPort_4950187_1 | SINK | L3J_3_CALEF_IMP 24
OutPort_4950183_1 | SOURCE | L3J_3_CALEF_IMP 24
InPort_4950587_2 | SINK | L3J_3_CALEF_IMP 24
OutPort_4950217_0 | SOURCE | L3J_3_CALEF_IMP 24
InPort_4950217_1 | SINK | L3J_3_CALEF_IMP 24
OutPort_4950591_2 | SOURCE | L3J_3_CALEF_IMP 24
InPort_4950308_2 | SINK | L3J_3_CALEF_IMP 25
OutPort_4950306_0 | SOURCE | L3J_3_CALEF_IMP 25
InPort_4950306_1 | SINK | L3J_3_CALEF_IMP 25
OutPort_4950603_1 | SOURCE | L3J_3_CALEF_IMP 25
InPort_4950331_1 | SINK | L3J_3_CALEF_RET 19
OutPort_4950587_1 | SOURCE | L3J_3_CALEF_RET 19
InPort_4950601_2 | SINK | L3J_3_CALEF_IMP 25
OutPort_4950393_0 | SOURCE | L3J_3_CALEF_IMP 25
InPort_4950603_2 | SINK | L3J_3_CALEF_IMP 25
OutPort_4950601_1 | SOURCE | L3J_3_CALEF_IMP 25
Port_4951158_1 | SOURCEANDSINK
Port_4951222_1 | SOURCEANDSINK
Port_4954893_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956045_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4954893_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4954898_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4954898_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4954955_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 11
Port_4957056_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 11
Port_4954955_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 11
Port_4954960_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 11
Port_4954960_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 11
Port_4956042_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956046_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956043_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956046_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956043_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956050_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956044_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956050_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956044_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956053_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956045_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_5259562_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956053_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_5259562_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4957056_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 11
Port_4957059_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 11
Port_4957059_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 11
Port_5257597_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 11
InPort_4957219_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 8
OutPort_4957280_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 8
InPort_4957284_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 8
OutPort_4957219_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 8
OutPort_4957284_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 8
InPort_5051624_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5051464_0 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5051464_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5051647_2 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5241974_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5051474_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5051474_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5241976_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5051474_3 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5051624_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5051642_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5051645_2 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5052026_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5051867_0 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5051867_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5052149_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5052149_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5052038_0 | SOURCE | L3J_4_SAN_PLUVIAL 3
Port_5052329_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5052455_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5052329_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056453_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5052337_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056965_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
InPort_5052337_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5241978_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
Port_5052337_3 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5052455_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
InPort_5052338_0 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5241974_2 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5241978_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5052338_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5056453_3 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5052508_0 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5052508_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5052541_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5056325_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5052516_0 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5052516_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5056330_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5056364_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5052539_0 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5052539_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5056325_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5052541_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5056364_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5056302_0 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5052655_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5056330_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5056302_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
Port_5056453_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056533_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056533_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056644_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056644_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056706_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056701_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056703_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056746_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056965_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056746_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5213157_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056880_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5213154_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056880_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5213157_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
InPort_5061834_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_5057254_1 | SOURCE | L3J_4_SAN_FECAL 3
Port_5058555_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059488_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5058555_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059561_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059215_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214764_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059215_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059561_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059299_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059488_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059554_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059559_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059559_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215321_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060093_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060342_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060337_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214093_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060342_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060343_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060342_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060351_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060384_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060431_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5075041_1 | SOURCEANDSINK
Port_5077903_1 | SOURCEANDSINK
Port_5077999_1 | SOURCEANDSINK
Port_5088679_1 | SOURCEANDSINK
Port_5088740_1 | SOURCEANDSINK
Port_5089058_1 | SOURCEANDSINK
Port_5089400_1 | SOURCEANDSINK
Port_5089440_1 | SOURCEANDSINK
Port_5089506_1 | SOURCEANDSINK
Port_5089524_1 | SOURCEANDSINK
Port_5089524_2 | SOURCEANDSINK
Port_5089524_3 | SOURCEANDSINK
Port_5089524_4 | SOURCEANDSINK
Port_5089546_1 | SOURCEANDSINK
Port_5089595_1 | SOURCEANDSINK
Port_5089861_1 | SOURCEANDSINK
InPort_5110106_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_5110090_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_5110090_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_5110152_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
Port_5117439_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_5117440_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_5117440_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_5117656_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5117657_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_5117656_3 | SINK | L3J_4_SAN_FECAL 3
OutPort_5117974_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_5117950_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_5117944_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_5117945_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_5117950_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_5117954_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_5117945_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_5117946_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_5117954_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_5117974_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_5117946_1 | SOURCE | L3J_4_SAN_FECAL 3
Port_5166806_0 | SOURCEANDSINK
Port_5167129_2 | SOURCEANDSINK
Port_5166806_1 | SOURCEANDSINK
Port_5167733_1 | SOURCEANDSINK
Port_5166988_0 | SOURCEANDSINK
Port_5167757_1 | SOURCEANDSINK
Port_5166988_1 | SOURCEANDSINK
Port_5167733_2 | SOURCEANDSINK
Port_5167000_0 | SOURCEANDSINK
Port_5167757_2 | SOURCEANDSINK
Port_5167000_1 | SOURCEANDSINK
Port_5167754_3 | SOURCEANDSINK
Port_5167123_0 | SOURCEANDSINK
Port_5167129_1 | SOURCEANDSINK
Port_5167123_1 | SOURCEANDSINK
Port_5167345_1 | SOURCEANDSINK
Port_5167131_0 | SOURCEANDSINK
Port_5167345_2 | SOURCEANDSINK
Port_5167131_1 | SOURCEANDSINK
Port_5167346_2 | SOURCEANDSINK
Port_5167332_1 | SOURCEANDSINK
Port_5167334_1 | SOURCEANDSINK
Port_5167333_0 | SOURCEANDSINK
Port_5167334_2 | SOURCEANDSINK
Port_5167333_1 | SOURCEANDSINK
Port_5167346_1 | SOURCEANDSINK
Port_5167754_2 | SOURCEANDSINK
Port_5167755_1 | SOURCEANDSINK
Port_5167755_0 | SOURCEANDSINK
Port_5190923_1 | SOURCEANDSINK
Port_5190935_1 | SOURCEANDSINK
InPort_5208928_1 | SINK | L3J_4_SAN_FECAL 1
OutPort_5208902_1 | SOURCE | L3J_4_SAN_FECAL 1
InPort_5208911_0 | SINK | L3J_4_SAN_FECAL 1
OutPort_5208928_2 | SOURCE | L3J_4_SAN_FECAL 1
InPort_5208937_1 | SINK | L3J_4_SAN_FECAL 1
OutPort_5208911_1 | SOURCE | L3J_4_SAN_FECAL 1
InPort_5208931_0 | SINK | L3J_4_SAN_FECAL 1
OutPort_5208937_2 | SOURCE | L3J_4_SAN_FECAL 1
InPort_5209410_2 | SINK | L3J_4_SAN_FECAL 1
OutPort_5208931_1 | SOURCE | L3J_4_SAN_FECAL 1
InPort_5208987_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_5208988_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
Port_5208987_3 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5209016_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5209016_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
InPort_5209032_0 | SINK | L3J_4_SAN_FECAL 1
OutPort_5209414_2 | SOURCE | L3J_4_SAN_FECAL 1
OutPort_5209032_1 | SOURCE | L3J_4_SAN_FECAL 1
InPort_5209408_0 | SINK | L3J_4_SAN_FECAL 1
OutPort_5209410_1 | SOURCE | L3J_4_SAN_FECAL 1
InPort_5209414_1 | SINK | L3J_4_SAN_FECAL 1
OutPort_5209408_1 | SOURCE | L3J_4_SAN_FECAL 1
Port_5213151_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5213154_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5213347_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213412_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213410_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213412_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213428_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213438_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213428_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213448_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213438_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213439_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213442_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213448_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213442_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213506_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213504_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213506_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213504_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213525_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213764_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213525_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213690_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213690_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213729_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213727_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213729_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213727_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213751_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213763_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213751_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213832_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213763_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213764_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213830_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213832_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213830_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213895_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213903_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213895_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214018_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213903_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213904_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213904_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214092_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214016_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214018_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214016_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214082_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214092_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214082_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214409_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214092_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214093_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214096_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214409_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214096_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214152_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214150_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214152_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214150_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214409_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214418_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214418_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214499_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214442_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214499_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214442_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214480_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214478_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214480_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214478_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214499_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214511_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214511_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214535_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214529_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214535_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214529_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214604_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214602_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214604_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214602_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214748_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214764_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214748_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214777_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214764_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214765_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214765_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215320_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214768_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214919_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214768_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214851_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214777_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215233_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214841_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214851_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214841_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214890_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214888_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214890_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214888_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214909_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214919_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214909_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215005_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214919_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214920_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5214920_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215075_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215003_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215005_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215003_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215063_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215075_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215063_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215126_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215075_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215076_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215076_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215157_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215124_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215126_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215124_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215149_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215157_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215149_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215200_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215157_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215158_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215158_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215232_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215198_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215200_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215198_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215222_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215232_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215222_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215291_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215232_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215233_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215289_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215291_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215289_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215312_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215320_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215312_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215383_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215320_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215321_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215381_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215383_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5215381_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5218132_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218809_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
InPort_5218136_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_5218591_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
Port_5218582_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218808_3 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218582_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218822_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
InPort_5218591_0 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_5218808_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
Port_5218808_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218809_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218814_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218822_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218814_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219592_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218852_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219588_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218852_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219735_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219367_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219578_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219367_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219588_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219393_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219578_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219393_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219592_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5219735_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
InPort_5251241_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_5251243_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_5251441_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_5251529_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
Port_5255558_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_5255710_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_5258277_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_5257597_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 11
InPort_5257724_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_5257811_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_5257814_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_5257724_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_5257813_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_5257814_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
Port_5258277_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_5258648_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3

# IfcEnergyConversionDevice: L3J_RECUPERADOR_SYSTEMAIR:WTU-1500-EC-E 2- OAC, L3J_RECUPERADOR_SYSTEMAIR:WTU-1500-EC-E 2- OAC:3043253
In: PLANTA COBERTA
Type - Material: Color RGB 221-221-221, Color RGB 074-074-074
Type - Pset_ManufacturerTypeInformation - Manufacturer: Orcon
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.90; 105.AMB.ClassificacioDescripcio: Recuperadors; 109.AMB.CodiTipus: CLI-RE
Classification: 50.30.10.90 Uniformat (Uniformat); Group: Mecánica L3J_3_VENT_APORT_AIRE 6; Mecánica L3J_VENTILACIÓ_CTE_HS3 5; Mecánica L3J_VENTILACIÓ_CTE_HS3 3; Mecánica L3J_3_VENT_APORT_AIRE 4
Pset_DistributionFlowElementCommon - Reference: L3J_RECUPERADOR_SYSTEMAIR:WTU-1500-EC-E 2- OAC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: WTU-1500-EC-E 2- OAC; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 7.17029 m2; 509.AMB.Volum: 1.67738 m3

# IfcEnergyConversionDevice: L3J_RECUPERADOR_SYSTEMAIR:WTU-1500-EC-E REGIDURIA, L3J_RECUPERADOR_SYSTEMAIR:WTU-1500-EC-E REGIDURIA:3715135
In: PLANTA COBERTA
Type - Material: Color RGB 221-221-221, Color RGB 074-074-074
Type - Pset_ManufacturerTypeInformation - Manufacturer: Orcon
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.90; 105.AMB.ClassificacioDescripcio: Recuperadors; 109.AMB.CodiTipus: CLI-RE
Classification: 50.30.10.90 Uniformat (Uniformat); Group: Mecánica L3J_3_VENT_APORT_AIRE 5; Mecánica L3J_VENTILACIÓ_CTE_HS3 11; Mecánica L3J_VENTILACIÓ_CTE_HS3 2
Pset_DistributionFlowElementCommon - Reference: L3J_RECUPERADOR_SYSTEMAIR:WTU-1500-EC-E REGIDURIA; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: WTU-1500-EC-E REGIDURIA; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Santa Eulalia; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 7.17029 m2; 509.AMB.Volum: 1.67738 m3

# IfcEnergyConversionDevice: L3J_RECUPERADOR_SYSTEMAIR:WTU-1500-EC-E_NAU LATERAL, L3J_RECUPERADOR_SYSTEMAIR:WTU-1500-EC-E_NAU LATERAL:3043702
In: PLANTA COBERTA
Type - Material: Color RGB 221-221-221, Color RGB 074-074-074
Type - Pset_ManufacturerTypeInformation - Manufacturer: Orcon
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.10.90; 105.AMB.ClassificacioDescripcio: Recuperadors; 109.AMB.CodiTipus: CLI-RE
Classification: 50.30.10.90 Uniformat (Uniformat); Group: Mecánica L3J_3_VENT_APORT_AIRE 1; Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Pset_DistributionFlowElementCommon - Reference: L3J_RECUPERADOR_SYSTEMAIR:WTU-1500-EC-E_NAU LATERAL; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: WTU-1500-EC-E_NAU LATERAL; 115.AMB.Nivell: PLANTA COBERTA; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
5 AMB.Geometria - 507.AMB.Area: 7.17029 m2; 509.AMB.Volum: 1.67738 m3

# IfcFlowController: L3J_CLAU DE PAS_FONT:25 mm (10)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.10; 105.AMB.ClassificacioDescripcio: Vàlvules i instruments de mesura i control de fluxe de fontaneria; 109.AMB.CodiTipus: LAM
Classification: 50.10.20.10 Uniformat (Uniformat); Group: L3J_2_AFS 1
Pset_DistributionFlowElementCommon - Reference: L3J_CLAU DE PAS_FONT:25 mm; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: 25 mm; 112.AMB.Servei: L3J_2_AFS; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 27 mmø-27 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.000265227 m3
Name (L3J_CLAU DE PAS_FONT:25 mm:...) | 117.AMB.Localitzacio
2976014 | Nau Santa Eulalia
2976528 | Nau Santa Eulalia
2977579 | Annex
2978053 | Nau Santa Eulalia
4011457 | Nau Santa Eulalia
4012854 | Nau Santa Eulalia
4058213 | Nau Santa Eulalia
4059889 | Nau Santa Eulalia
4065601 | Annex
4065668 | Annex

# IfcFlowFitting: L3J_COLZE:GENERIC (99)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.10.20.30; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigua sanitària; 109.AMB.CodiTipus: LAM-PEX
Classification: 50.10.20.30 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_COLZE:GENERIC; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: GENERIC; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (L3J_COLZE:GENERIC:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
2976409 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
2976785 | L3J_2_AFS | Annex | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
2976868 | L3J_2_AFS | Annex | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
2977024 | L3J_2_AFS | Annex | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
2977228 | L3J_2_AFS | Annex | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
2978253 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
2978381 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
2978403 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3019407 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3019936 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3034244 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_ACS 1
3034343 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_ACS 1
3034360 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_ACS 1
3034724 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
3035747 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
3035903 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_ACS 2
3035941 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_ACS 2
3035951 | L3J_2_ACS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_ACS 2
3293735 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
3293868 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
3349211 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
3349221 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
3349754 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
3364500 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3364979 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3364981 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3365976 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3366201 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3674490 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3768794 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3769578 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
3769825 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
3769967 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
3772358 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722915 | L3J_2_AFS 1
3772390 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3772392 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3921190 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3921395 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 9.03629e-07 | L3J_2_AFS 1
3921413 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000753038 | L3J_2_AFS 1
3991342 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3991344 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
3991553 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000601552 | L3J_2_AFS 1
3993795 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
3994324 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
3994332 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
3994336 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4009153 | L3J_2_AFS |  | 25 mmø-25 mmø | 0.0000207886 | AFS 3
4009196 | L3J_2_AFS |  | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4009215 | L3J_2_AFS |  | 32 mmø-32 mmø | 0.0000358323 | L3J_2_AFS 1
4009512 | L3J_2_AFS |  | 25 mmø-25 mmø | 0.0000207886 | AFS 3
4009620 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4009624 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4009639 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4009641 | L3J_2_AFS |  | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4009685 | L3J_2_AFS | Capella | 32 mmø-32 mmø | 0.0000358323 | L3J_2_AFS 1
4009702 | L3J_2_AFS |  | 32 mmø-32 mmø | 0.0000358323 | L3J_2_AFS 1
4009726 | L3J_2_AFS |  | 32 mmø-32 mmø | 0.0000358323 | L3J_2_AFS 1
4009728 | L3J_2_AFS |  | 32 mmø-32 mmø | 0.0000358323 | L3J_2_AFS 1
4009888 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | AFS 3
4011307 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4011315 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4011782 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4012112 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
4012114 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
4012134 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207884 | L3J_2_AFS 1
4012746 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4012759 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4012770 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4012811 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4013244 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4058073 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4058081 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4058107 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4058539 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4058560 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4058616 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4058888 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4059521 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4059525 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000361453 | L3J_2_AFS 1
4059531 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207273 | L3J_2_AFS 1
4059557 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4059631 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4059635 | L3J_2_AFS | Nau Santa Eulalia | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4059835 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
4060635 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
4060639 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
4061064 | L3J_2_AFS | Nau Santa Eulalia | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
4061465 | L3J_2_AFS | Nau Santa Eulalia | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4064588 | L3J_2_AFS | Annex | 32 mmø-32 mmø | 0.0000358323 | L3J_2_AFS 1
4064601 | L3J_2_AFS | Annex | 32 mmø-32 mmø | 0.0000358323 | L3J_2_AFS 1
4065290 | L3J_2_AFS | Annex | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4065350 | L3J_2_AFS | Annex | 16 mmø-16 mmø | 0.00000722916 | L3J_2_AFS 1
4065371 | L3J_2_AFS | Annex | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4065513 | L3J_2_AFS | Annex | 25 mmø-25 mmø | 0.0000207765 | L3J_2_AFS 1
4065522 | L3J_2_AFS | Annex | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4065578 | L3J_2_AFS | Annex | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4065580 | L3J_2_AFS | Annex | 25 mmø-25 mmø | 0.0000207886 | L3J_2_AFS 1
4065742 | L3J_2_AFS | Annex | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1
4065810 | L3J_2_AFS | Annex | 20 mmø-20 mmø | 0.0000106411 | L3J_2_AFS 1

# IfcFlowFitting: L3J_COLZE:GENERIC_BIES (4)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.50; 105.AMB.ClassificacioDescripcio: Canalitzacions d'extinció d'incendis; 109.AMB.CodiTipus: PCI-CAN
Classification: 50.50.10.50 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_COLZE:GENERIC_BIES; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: GENERIC_BIES; 112.AMB.Servei: L3J_6_PCI - HUMIDA; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 40 mmø-40 mmø
5 AMB.Geometria - 509.AMB.Volum: 0.0000567196 m3
Name (L3J_COLZE:GENERIC_BIES:...) | 117.AMB.Localitzacio | Group
3903474 | Nau Santa Eulalia | L3J_6_PCI - HUMIDA 1
3903591 | Nau Santa Eulalia | L3J_6_PCI - HUMIDA 1
3903730 | Nau Santa Eulalia | L3J_6_PCI - HUMIDA 2
3904576 | Nau Lateral Sud | L3J_6_PCI - HUMIDA 3

# IfcFlowFitting: L3J_COLZE_SOLDAT:COLZE_FRIGORÍFIQUES (177)
In: PLANTA BAIXA
Type - Material: <Unnamed>
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.30.10; 105.AMB.ClassificacioDescripcio: Línies frigorífiques; 109.AMB.CodiTipus: CLI-CFRI
Classification: 50.30.30.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: L3J_COLZE_SOLDAT:COLZE_FRIGORÍFIQUES; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: COLZE_FRIGORÍFIQUES; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (L3J_COLZE_SOLDAT:COLZE_FRIGORÍFIQUES:...) | 112.AMB.Servei | 117.AMB.Localitzacio | 242.AMB.Mida | 509.AMB.Volum (m3) | Group
3519884 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 4
3519894 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 4
3519902 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000400147 | L3J_3_CALEF_IMP 4
3521160 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3521170 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3521178 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3521285 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3521289 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3709059 | L3J_3_CALEF_RET | Nau Santa Eulalia | 49 mmø-49 mmø | 0.0000192214 | L3J_3_CALEF_RET 9
3709252 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 46 mmø-46 mmø | 0.0000139784 | L3J_3_CALEF_IMP 8
3717942 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 30 mmø-30 mmø | 0.00000644035 | L3J_3_CALEF_IMP 10
3719377 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 40 mmø-40 mmø | 0.00000644035 | L3J_3_CALEF_IMP 14
3719524 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 40 mmø-40 mmø | 0.00000644035 | L3J_3_CALEF_IMP 14
3719526 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 40 mmø-40 mmø | 0.00000644035 | L3J_3_CALEF_IMP 14
3719621 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 56 mmø-56 mmø | 0.0000139784 | L3J_3_CALEF_IMP 12
3719657 | L3J_3_CALEF_RET | Nau Santa Eulalia | 59 mmø-59 mmø | 0.0000192214 | L3J_3_CALEF_RET 12
3719675 | L3J_3_CALEF_RET | Nau Santa Eulalia | 56 mmø-56 mmø | 0.0000139784 | L3J_3_CALEF_RET 3
3719677 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 56 mmø-56 mmø | 0.0000139784 | L3J_3_CALEF_IMP 12
3719681 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 59 mmø-59 mmø | 0.0000192214 | L3J_3_CALEF_IMP 11; L3J_3_CALEF_RET 12
3719686 | L3J_3_CALEF_RET | Nau Santa Eulalia | 59 mmø-59 mmø | 0.0000192214 | L3J_3_CALEF_RET 12
3725031 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 30 mmø-30 mmø | 0.00000644035 | L3J_3_CALEF_IMP 10
3725041 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 46 mmø-46 mmø | 0.0000151927 | L3J_3_CALEF_IMP 8
3725044 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 46 mmø-46 mmø | 0.0000139784 | L3J_3_CALEF_IMP 8
3725052 | L3J_3_CALEF_RET | Nau Santa Eulalia | 49 mmø-49 mmø | 0.000023202 | L3J_3_CALEF_RET 9
3725055 | L3J_3_CALEF_RET | Nau Santa Eulalia | 49 mmø-49 mmø | 0.0000192214 | L3J_3_CALEF_RET 9
3725420 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 30 mmø-30 mmø | 0.00000484542 | L3J_3_CALEF_IMP 10
3727138 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 30 mmø-30 mmø | 0.00000644035 | L3J_3_CALEF_IMP 18
3727221 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 46 mmø-46 mmø | 0.0000139784 | L3J_3_CALEF_IMP 16
3727366 | L3J_3_CALEF_RET | Nau Santa Eulalia | 46 mmø-46 mmø | 0.0000139784 | L3J_3_CALEF_RET 11
3727402 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 30 mmø-30 mmø | 0.00000644035 | L3J_3_CALEF_IMP 18
3728456 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 40 mmø-40 mmø | 0.00000644035 | L3J_3_CALEF_IMP 19
3728488 | L3J_3_CALEF_RET | Nau Santa Eulalia | 56 mmø-56 mmø | 0.0000139784 | L3J_3_CALEF_RET 16
3728535 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 59 mmø-59 mmø | 0.0000192214 | L3J_3_CALEF_IMP 17
3728581 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 59 mmø-59 mmø | 0.0000192214 | L3J_3_CALEF_IMP 17
3728586 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 59 mmø-59 mmø | 0.0000192214 | L3J_3_CALEF_IMP 17
3728591 | L3J_3_CALEF_RET | Nau Santa Eulalia | 56 mmø-56 mmø | 0.0000139784 | L3J_3_CALEF_RET 16
3728595 | L3J_3_CALEF_RET | Nau Santa Eulalia | 56 mmø-56 mmø | 0.0000139784 | L3J_3_CALEF_RET 16
3728600 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 40 mmø-40 mmø | 0.00000644035 | L3J_3_CALEF_IMP 19
3728603 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 40 mmø-40 mmø | 0.00000644035 | L3J_3_CALEF_IMP 19
3730236 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3730407 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3730712 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3730714 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3731300 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3731317 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3731319 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3731323 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3733912 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401808 | L3J_3_CALEF_IMP 2
3734645 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3734660 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3734666 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3735178 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3735195 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3735197 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3735201 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3735291 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3735375 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3735377 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3735381 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3735524 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3735692 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3735742 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3736820 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3737031 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3737084 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3737086 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3737090 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3737383 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3737446 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3737513 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3737515 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 2
3737658 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 2
3737663 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000402173 | L3J_3_CALEF_IMP 2
3739400 | L3J_3_CALEF_RET | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_RET 5
3739467 | L3J_3_CALEF_RET | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_RET 5
3739469 | L3J_3_CALEF_RET | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_RET 5
3739508 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_IMP 3
3739565 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_IMP 3
3739567 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_IMP 3
3740562 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.0000021874 | L3J_3_CALEF_IMP 4
3740567 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 4
3740577 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000955672 | L3J_3_CALEF_RET 4
3740582 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3740641 | L3J_3_CALEF_RET | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_RET 5
3740646 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_IMP 3
3740678 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3740688 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3740779 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 4
3740787 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 4
3741096 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3741133 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 4
3741162 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 4
3741549 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401821 | L3J_3_CALEF_IMP 4
3741553 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 4
3741663 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3742899 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000400147 | L3J_3_CALEF_IMP 4
3742901 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 4
3742959 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000969342 | L3J_3_CALEF_RET 4
3742961 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 4
3743860 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 36 mmø-36 mmø | 0.00000401805 | L3J_3_CALEF_IMP 5
3743891 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 43 mmø-43 mmø | 0.00000973089 | L3J_3_CALEF_IMP 9
3743930 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_IMP 6
3743964 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 21
3746467 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 36 mmø-36 mmø | 0.00000401805 | L3J_3_CALEF_IMP 5
3746477 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 36 mmø-36 mmø | 0.00000401805 | L3J_3_CALEF_IMP 5
3746500 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 36 mmø-36 mmø | 0.00000401805 | L3J_3_CALEF_IMP 5
3746502 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 36 mmø-36 mmø | 0.00000208875 | L3J_3_CALEF_IMP 5
3746506 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 36 mmø-36 mmø | 0.00000208875 | L3J_3_CALEF_IMP 5
3746512 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 36 mmø-36 mmø | 0.00000401805 | L3J_3_CALEF_IMP 5
3746550 | L3J_3_CALEF_RET | Nau Santa Eulalia | 43 mmø-43 mmø | 0.00000973089 | L3J_3_CALEF_RET 10
3746560 | L3J_3_CALEF_RET | Nau Santa Eulalia | 43 mmø-43 mmø | 0.00000973089 | L3J_3_CALEF_RET 10
3746579 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 43 mmø-43 mmø | 0.00000973089 | L3J_3_CALEF_IMP 9; L3J_3_CALEF_RET 10
3746581 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 43 mmø-43 mmø | 0.00000973089 | L3J_3_CALEF_IMP 9
3746587 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 43 mmø-43 mmø | 0.00000973089 | L3J_3_CALEF_IMP 9
3749943 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 36 mmø-36 mmø | 0.00000401805 | L3J_3_CALEF_IMP 21
3749947 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 21
3750729 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 36 mmø-36 mmø | 0.00000401805 | L3J_3_CALEF_IMP 21
3750733 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 36 mmø-36 mmø | 0.00000401805 | L3J_3_CALEF_IMP 21
3750844 | L3J_3_CALEF_RET | Nau Santa Eulalia | 43 mmø-43 mmø | 0.00000973089 | L3J_3_CALEF_RET 7
3751066 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 43 mmø-43 mmø | 0.00000973089 | L3J_3_CALEF_IMP 6; L3J_3_CALEF_RET 7
3751068 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 43 mmø-43 mmø | 0.00000973089 | L3J_3_CALEF_IMP 6
3751074 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_IMP 6
3755870 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 1
3756045 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 1
3756047 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 1
3756051 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 1
3756392 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000972965 | L3J_3_CALEF_RET 1
3756397 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 1
3756497 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 1
3756502 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 1
3756707 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 1
3756709 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 1
3756720 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 1
3756724 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 1
3756813 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 1
3756825 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 1
3757217 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 49 mmø-49 mmø | 0.0000192214 | L3J_3_CALEF_IMP 15
3758055 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 30 mmø-30 mmø | 0.00000644035 | L3J_3_CALEF_IMP 18
3758064 | L3J_3_CALEF_RET | Nau Santa Eulalia | 46 mmø-46 mmø | 0.0000139784 | L3J_3_CALEF_RET 11
3758133 | L3J_3_CALEF_RET | Nau Santa Eulalia | 49 mmø-49 mmø | 0.0000192214 | L3J_3_CALEF_RET 14
3758143 | L3J_3_CALEF_RET | Nau Santa Eulalia | 49 mmø-49 mmø | 0.0000192214 | L3J_3_CALEF_RET 14
3868730 | L3J_3_CALEF_IMP | Nau Santa Eulalia | 26 mmø-26 mmø | 0.00000401805 | L3J_3_CALEF_IMP 1
3868742 | L3J_3_CALEF_RET | Nau Santa Eulalia | 33 mmø-33 mmø | 0.00000973089 | L3J_3_CALEF_RET 1
4947396 | L3J_3_CALEF_IMP | Nau Lateral Sud | 13 mmø-13 mmø | 0.00000973089 | L3J_3_CALEF_IMP 13
4947440 | L3J_3_CALEF_IMP | Nau Lateral Sud | 13 mmø-13 mmø | 0.00000973089 | L3J_3_CALEF_IMP 13
4947521 | L3J_3_CALEF_IMP | Nau Lateral Sud | 13 mmø-13 mmø | 0.00000973089 | L3J_3_CALEF_IMP 13
4947525 | L3J_3_CALEF_IMP | Nau Lateral Sud | 13 mmø-13 mmø | 0.00000973089 | L3J_3_CALEF_IMP 13
4948210 | L3J_3_CALEF_RET | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_RET 13
4948258 | L3J_3_CALEF_RET | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_RET 13
4948322 | L3J_3_CALEF_RET | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_RET 13
4948326 | L3J_3_CALEF_RET | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_RET 13
4948457 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 22
4948465 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 22
4948494 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000402239 | L3J_3_CALEF_IMP 22
4948527 | L3J_3_CALEF_RET | Nau Lateral Sud | 13 mmø-13 mmø | 0.00000974139 | L3J_3_CALEF_RET 15
4948536 | L3J_3_CALEF_RET | Nau Lateral Sud | 13 mmø-13 mmø | 0.00000973089 | L3J_3_CALEF_RET 15
4948544 | L3J_3_CALEF_RET | Nau Lateral Sud | 13 mmø-13 mmø | 0.00000973089 | L3J_3_CALEF_RET 15
4949204 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 23
4949216 | L3J_3_CALEF_IMP | Nau Lateral Sud | 6 mmø-6 mmø | 0.00000401805 | L3J_3_CALEF_IMP 23
4949243 | L3J_3_CALEF_RET | Nau Lateral Sud | 10 mmø-10 mmø | 0.00000644035 | L3J_3_CALEF_RET 17
