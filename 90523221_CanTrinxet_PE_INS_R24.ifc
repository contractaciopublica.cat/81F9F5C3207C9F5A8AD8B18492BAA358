Properties of the parts of a building model (IFC2X3), part 3 of 10

# IfcDistributionPort (4427)
Name | FlowDirection | Group
OutPort_3478051_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
Port_3480163_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482365_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3480163_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482223_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482314_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482325_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482316_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482365_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482316_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482325_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482365_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482423_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3482437_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3482430_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3482437_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3482430_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3483074_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483136_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483527_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483136_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483491_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483917_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483527_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483531_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483531_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483673_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483673_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483921_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483901_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483917_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483901_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483921_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3484189_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485466_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
InPort_3484975_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3484960_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3484960_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_5251171_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3485085_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_5257813_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
Port_3485377_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485388_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485377_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485548_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485427_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485466_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485427_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485548_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485548_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3485574_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3485594_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3485589_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3485594_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3485589_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3485995_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 7
Port_3868135_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 7
Port_3485995_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 7
Port_3486012_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 7
Port_3486003_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 7
Port_3486012_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 7
Port_3486003_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 7
Port_3487374_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3866906_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3490198_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490213_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490198_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490274_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490274_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490870_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490870_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490878_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490871_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490878_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3490871_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679049_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3491798_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3491800_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3491800_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3491985_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3491980_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3491982_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3491980_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678626_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3491982_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3491985_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3493074_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3493113_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3493074_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3493086_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3493086_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3695046_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3513796_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3764278_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3513796_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3513926_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3513926_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3873241_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3513926_3 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3873243_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3513996_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3873243_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3513996_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3514040_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3514029_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3514043_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3514029_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3514039_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3514040_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3514039_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3514043_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3514376_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515403_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3514376_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515834_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515028_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515324_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515324_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515403_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515732_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515834_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515732_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515836_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515799_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3873241_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515799_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515801_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515800_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515801_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515800_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515836_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3519722_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3743008_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519722_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3742899_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519868_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519884_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519868_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519894_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519878_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3742901_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519878_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519884_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519888_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519894_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519888_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519902_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519896_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519902_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519896_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741549_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519905_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741553_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3519905_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740567_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3520003_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741549_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3520003_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741553_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
InPort_3743013_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3520921_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3520921_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3742959_1 | SOURCE | L3J_3_CALEF_RET 4
InPort_3742959_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3520932_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3520932_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3742961_2 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521160_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3520947_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3520947_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3521170_1 | SOURCE | L3J_3_CALEF_RET 4
InPort_3742961_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3521156_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521156_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3521160_1 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521170_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3521164_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521164_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3521178_2 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521178_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3521172_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521172_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3521285_1 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521289_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3521271_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521271_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3740582_1 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521285_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3521283_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521283_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3521289_1 | SOURCE | L3J_3_CALEF_RET 4
InPort_3521986_0 | SINK | L3J_3_CALEF_RET 4
OutPort_3740577_2 | SOURCE | L3J_3_CALEF_RET 4
InPort_3740582_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3521986_1 | SOURCE | L3J_3_CALEF_RET 4
Port_3522013_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740562_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3522013_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740567_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
InPort_3740577_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3523000_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3523000_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3740678_1 | SOURCE | L3J_3_CALEF_RET 4
Port_3523139_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740562_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3523139_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740779_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
InPort_3528894_2 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3528200_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3528200_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3528896_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3528223_0 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
OutPort_4542012_3 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
InPort_3528506_0 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
OutPort_3528223_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_3528455_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_5255710_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
InPort_3641788_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3528863_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3528863_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3528894_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3659873_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3627965_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3627965_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3659877_2 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3633991_0 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_3638770_1 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
InPort_3643008_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_3633991_1 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
InPort_3663056_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3636689_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3636689_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3663063_2 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3638603_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3638437_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3638437_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3638440_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3638440_2 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3638438_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3638438_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3638444_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3638444_2 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3638439_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3638439_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3641914_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3639110_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3638603_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3639838_0 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_3638770_2 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
InPort_3638770_3 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_5249960_0 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
InPort_3639114_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3639110_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3639112_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3639114_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3644390_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3639112_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3639229_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3644390_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_5249960_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_3639229_1 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
InPort_3639460_0 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_3643008_2 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
InPort_3643338_0 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_3639838_1 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
InPort_3641958_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3641788_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3656920_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3641957_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3641957_2 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3641958_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_5250135_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3641957_3 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3643336_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_3643283_0 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
InPort_3643283_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_3643338_1 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
InPort_3644835_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3643768_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3644805_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3644835_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_5258123_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3644805_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3644850_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3644875_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3645017_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3644850_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3644902_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3644875_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3644875_3 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_5258123_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3645413_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3644902_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3645001_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3645017_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3645018_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3645001_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3645394_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3645413_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3645414_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3645394_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3646954_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3646924_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3647954_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3646954_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3647502_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_5253341_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_5253343_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3647502_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3647874_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3655277_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_5253341_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3647874_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3655277_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3647954_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3668512_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
OutPort_3655601_0 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 1
InPort_3655601_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
OutPort_5250114_2 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 1
InPort_3655637_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
OutPort_3668512_2 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656366_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656695_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656366_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3666571_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656384_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541606_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656384_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656695_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656543_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656718_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656543_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_5250115_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656718_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541607_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
InPort_3656812_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
OutPort_5250113_0 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 1
InPort_5250114_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
OutPort_3656812_2 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3656812_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_5250115_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
InPort_3656906_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3656921_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3656930_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3656906_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3656921_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3656920_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3657114_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3656930_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3656933_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_4541555_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_4541556_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3656933_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_4541555_2 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3657114_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3657214_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_4541556_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_5250113_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
OutPort_3657214_1 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3658276_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5208987_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3658276_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3661272_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3658852_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3661272_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3658852_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3658883_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3658883_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3658902_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3658891_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3658902_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_3658891_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
Port_5218132_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 6
InPort_3659190_3 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3659182_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3659182_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3659324_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_5208988_0 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3659190_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3659190_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3659191_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3659191_0 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3663148_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3659324_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3659277_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3659277_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3659343_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3659343_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3659335_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3659335_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3659873_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3663063_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3660697_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3660697_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3660769_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3660769_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3660822_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3660822_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_5110106_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3661185_0 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_5218136_2 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3662613_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3661185_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3661291_0 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3662613_2 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3662617_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3661291_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_5109685_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3663037_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3663037_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3663056_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3663148_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3663294_2 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3663148_3 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_5109685_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3663202_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3663292_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3663294_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3663202_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3663292_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3663212_0 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3663212_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3663465_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3663465_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3663363_0 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3663363_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3671178_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3663701_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3663742_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_4948031_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3663701_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_4948024_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3663954_0 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3663954_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_4948031_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3664465_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3664467_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3664471_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3664465_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3664467_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_4947764_0 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3669816_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3664471_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
Port_3666562_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3666571_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3666562_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3666917_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3666910_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3666917_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3666910_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3684231_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3666964_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3684231_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_3666964_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
InPort_3669851_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3669816_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3669824_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3669855_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670160_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3669824_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3669849_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3669851_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3669855_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3669849_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670152_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670160_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3672037_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670152_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670165_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3672037_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3672041_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670165_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3671928_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670293_0 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670293_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3671576_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670526_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670547_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670557_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670526_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670560_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670557_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670618_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670560_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670601_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670620_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3671576_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670601_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670616_0 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670618_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3670620_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3670616_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3671178_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3671176_0 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3671176_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3671571_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3671571_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3671929_0 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3671947_2 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3671918_0 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3671918_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3672041_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3671929_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3671928_2 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_3671928_3 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3671947_1 | SOURCE | L3J_4_SAN_FECAL 1 (2)
Port_3675343_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686663_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3675343_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3675774_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686102_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3675774_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3676947_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3676953_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3676947_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3676972_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3676953_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3684923_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3676970_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3676972_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3677207_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3677771_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3677207_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560530_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3677755_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3684922_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3677755_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3677771_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3677771_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5117657_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678626_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678809_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678798_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679519_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678798_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679062_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678808_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679203_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678808_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679517_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678808_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679519_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678809_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679517_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678813_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679062_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3678813_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679066_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679047_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679049_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679047_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679066_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679203_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679227_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679215_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679227_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679215_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679544_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679544_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680079_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679544_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679893_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679566_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679895_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679566_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679897_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679881_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679883_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679881_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679897_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679893_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679895_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680079_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680293_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680089_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680295_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680089_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685624_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680291_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680293_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680291_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685592_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680295_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685592_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680299_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685624_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3680299_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5117557_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_3682264_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3682795_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3682814_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3682264_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3682795_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3682454_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3682454_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3682864_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3682806_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3682814_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683844_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3682806_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683138_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683152_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683983_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683138_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683981_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683156_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683156_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683985_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683878_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683844_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3684008_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683877_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683877_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683878_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683877_3 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683925_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683925_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683882_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683882_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683894_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683894_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683888_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683888_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683904_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683904_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683898_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683898_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683981_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3683985_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3683983_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_5059961_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3684008_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3684922_3 | SINK | L3J_4_SAN_FECAL 3
OutPort_3684912_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3684912_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_5059859_1 | SOURCE | L3J_4_SAN_FECAL 3
Port_3684922_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3684923_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_5059859_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3684926_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3684926_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3684975_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3684936_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3684972_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3684975_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3684936_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3684972_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3684970_2 | SOURCE | L3J_4_SAN_FECAL 3
Port_3685855_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686573_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685855_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686237_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685967_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685975_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685967_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059824_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685975_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685976_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685975_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686120_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685976_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060337_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685981_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059824_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3685981_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686084_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686084_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686102_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_3686215_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3686111_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3686111_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3686131_1 | SOURCE | L3J_4_SAN_FECAL 3
Port_3686119_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686120_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686119_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686573_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_3686119_3 | SINK | L3J_4_SAN_FECAL 3
OutPort_3686215_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3686131_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3686125_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3686125_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3686141_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3686141_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3686135_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3686135_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3686188_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3686188_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3686217_1 | SOURCE | L3J_4_SAN_FECAL 3
Port_3686229_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686237_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686229_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686247_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686241_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686247_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686241_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3687545_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686251_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3687545_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686251_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686623_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686609_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686623_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686609_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3686663_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3687545_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3687567_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3687567_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3687694_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3687592_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3687694_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3687592_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3689322_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3690401_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3689322_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059750_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3689328_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059750_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3689328_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059757_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3689378_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059757_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3689378_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3690401_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059554_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3690401_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3690576_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3690439_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3690576_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3690439_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3690688_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_3690688_3 | SINK | L3J_4_SAN_FECAL 3
OutPort_3690529_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3690529_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3690547_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3690547_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3690551_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3690551_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3690678_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3690557_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3690675_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3690678_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3690557_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3690675_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3690673_2 | SOURCE | L3J_4_SAN_FECAL 3
Port_3690688_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213347_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691421_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691506_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691495_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691959_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691495_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691516_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691505_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692242_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691505_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691974_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691505_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691959_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691506_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691974_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691516_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691933_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691931_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691937_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691932_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691937_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691932_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691942_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691933_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691942_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692241_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3693216_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692241_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692242_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692241_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692676_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692655_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692661_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692656_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692661_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692656_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692665_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692657_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692665_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692657_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692676_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3693216_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694527_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694360_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694368_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694360_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213410_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694362_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694527_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694362_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694370_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694364_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694368_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694364_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694366_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694366_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3766592_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694366_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694370_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694372_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694698_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694372_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3766592_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694696_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694698_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3694696_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3765993_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3695046_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3695052_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3695047_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3695052_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3695047_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3766596_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3695048_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3766006_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3695048_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3765993_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3705318_1 | SOURCEANDSINK
OutPort_3705318_2 | SOURCE
InPort_3705318_3 | SINK
InPort_3726897_0 | SINK | L3J_3_CALEF_IMP 16
OutPort_3705318_4 | SOURCE | L3J_3_CALEF_IMP 16
InPort_3705318_5 | SINK | L3J_3_CALEF_IMP 18
OutPort_3727119_1 | SOURCE | L3J_3_CALEF_IMP 18
InPort_3726840_0 | SINK | L3J_3_CALEF_RET 14
OutPort_3705318_6 | SOURCE | L3J_3_CALEF_RET 14
InPort_3705318_7 | SINK | L3J_3_CALEF_RET 2
OutPort_3736717_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3705318_8 | SINK | L3J_3_CALEF_RET 2
OutPort_3729704_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3705318_9 | SINK | L3J_3_CALEF_RET 2
OutPort_3729706_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3705318_10 | SINK | L3J_3_CALEF_RET 2
OutPort_3729678_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3728900_0 | SINK | L3J_3_CALEF_IMP 2
OutPort_3705318_11 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3734703_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3705318_12 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3734705_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3705318_13 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3734707_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3705318_14 | SOURCE | L3J_3_CALEF_IMP 2
Port_3705318_15 | SOURCEANDSINK
Port_3705318_16 | SOURCEANDSINK
Port_3705739_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3718486_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
InPort_3705739_2 | SINK | L3J_3_CALEF_IMP 10
OutPort_3718771_1 | SOURCE | L3J_3_CALEF_IMP 10
InPort_3709054_0 | SINK | L3J_3_CALEF_RET 9
OutPort_3705739_3 | SOURCE | L3J_3_CALEF_RET 9
OutPort_3705739_4 | SOURCE
Port_3705739_5 | SOURCEANDSINK
InPort_3705739_6 | SINK
InPort_3705739_7 | SINK | L3J_3_CALEF_RET 1
OutPort_3756867_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3705739_8 | SINK | L3J_3_CALEF_RET 1
OutPort_3756869_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3705739_9 | SINK | L3J_3_CALEF_RET 1
OutPort_3756865_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3755665_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3705739_10 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3755552_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3705739_11 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3755669_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3705739_12 | SOURCE | L3J_3_CALEF_IMP 1
Port_3705739_13 | SOURCEANDSINK
Port_3705739_14 | SOURCEANDSINK
InPort_3725052_2 | SINK | L3J_3_CALEF_RET 9
OutPort_3709039_0 | SOURCE | L3J_3_CALEF_RET 9
InPort_3709039_1 | SINK | L3J_3_CALEF_RET 9
OutPort_3725055_2 | SOURCE | L3J_3_CALEF_RET 9
InPort_3709059_1 | SINK | L3J_3_CALEF_RET 9
OutPort_3709054_1 | SOURCE | L3J_3_CALEF_RET 9
InPort_3709055_0 | SINK | L3J_3_CALEF_RET 9
OutPort_3709059_2 | SOURCE | L3J_3_CALEF_RET 9
InPort_3725055_1 | SINK | L3J_3_CALEF_RET 9
OutPort_3709055_1 | SOURCE | L3J_3_CALEF_RET 9
Port_3709234_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3725041_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3709234_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3725044_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3709247_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3718486_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3709247_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3709252_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3709248_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3709252_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3709248_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3725044_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
InPort_3711368_1 | SINK | L3J_3_CALEF_RET 3
OutPort_3718602_1 | SOURCE | L3J_3_CALEF_RET 3
Port_3711368_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719259_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3711368_3 | SOURCEANDSINK
InPort_3719698_1 | SINK | L3J_3_CALEF_IMP 11
OutPort_3711368_4 | SOURCE | L3J_3_CALEF_IMP 11
Port_3711368_5 | SOURCEANDSINK
Port_3713695_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
Port_3715070_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
Port_3713695_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
Port_3713851_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
Port_3713851_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
InPort_3714247_0 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
OutPort_3713890_0 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
InPort_3713890_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
OutPort_3874440_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
InPort_3715433_2 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3713920_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
InPort_3713920_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3715436_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
Port_3714058_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3716694_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
InPort_3874526_2 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
OutPort_3714321_0 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
InPort_3714321_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
Port_3715063_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
Port_3715070_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
Port_3715063_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 1
Port_3715135_1 | SOURCEANDSINK
InPort_3722122_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 5
OutPort_3715135_10 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 5
InPort_3715135_11 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
OutPort_3721618_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
InPort_3720001_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
OutPort_3715135_14 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
InPort_3715135_15 | SINK
Port_3715137_1 | SOURCEANDSINK
Port_3715138_1 | SOURCEANDSINK
InPort_3715146_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
OutPort_3715139_0 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
InPort_3715139_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
OutPort_3720001_0 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
InPort_3721618_0 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
OutPort_3715141_0 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
InPort_3715141_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
OutPort_3721642_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
InPort_3715145_0 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
OutPort_3715146_2 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
OutPort_3715145_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 2
InPort_3715965_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3715433_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
InPort_3717100_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3715965_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
Port_3716559_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
InPort_3716598_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3716948_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3716598_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
Port_3716613_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3717441_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3716613_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3716694_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
InPort_3716948_2 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3716741_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
InPort_3716741_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3717140_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
InPort_3716952_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3717138_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
InPort_3717140_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3716952_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
InPort_3717082_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3717100_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
InPort_3717138_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3717082_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
Port_3717195_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3717441_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3717195_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
InPort_3718771_2 | SINK | L3J_3_CALEF_IMP 10
OutPort_3717936_0 | SOURCE | L3J_3_CALEF_IMP 10
InPort_3717936_1 | SINK | L3J_3_CALEF_IMP 10
OutPort_3717942_1 | SOURCE | L3J_3_CALEF_IMP 10
InPort_3717942_2 | SINK | L3J_3_CALEF_IMP 10
OutPort_3717937_0 | SOURCE | L3J_3_CALEF_IMP 10
InPort_3717937_1 | SINK | L3J_3_CALEF_IMP 10
OutPort_3725031_1 | SOURCE | L3J_3_CALEF_IMP 10
InPort_3717938_0 | SINK | L3J_3_CALEF_IMP 10
OutPort_3725420_2 | SOURCE | L3J_3_CALEF_IMP 10
InPort_3725031_2 | SINK | L3J_3_CALEF_IMP 10
OutPort_3717938_1 | SOURCE | L3J_3_CALEF_IMP 10
InPort_3718068_0 | SINK | L3J_3_CALEF_IMP 12
InPort_3719621_1 | SINK | L3J_3_CALEF_IMP 12
OutPort_3718068_1 | SOURCE | L3J_3_CALEF_IMP 12
OutPort_3718107_0 | SOURCE | L3J_3_CALEF_RET 12
InPort_3718107_1 | SINK | L3J_3_CALEF_RET 12
OutPort_3719657_1 | SOURCE | L3J_3_CALEF_RET 12
InPort_3718559_0 | SINK | L3J_3_CALEF_IMP 11
OutPort_3719698_2 | SOURCE | L3J_3_CALEF_IMP 11
InPort_3719681_2 | SINK | L3J_3_CALEF_IMP 11
OutPort_3718559_1 | SOURCE | L3J_3_CALEF_IMP 11
InPort_3718602_2 | SINK | L3J_3_CALEF_RET 3
OutPort_3718586_0 | SOURCE | L3J_3_CALEF_RET 3
InPort_3718586_1 | SINK | L3J_3_CALEF_RET 3
OutPort_3719675_2 | SOURCE | L3J_3_CALEF_RET 3
InPort_3725420_1 | SINK | L3J_3_CALEF_IMP 10
OutPort_3719036_0 | SOURCE | L3J_3_CALEF_IMP 10
InPort_3719036_1 | SINK | L3J_3_CALEF_IMP 10
Port_3719048_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3725041_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
Port_3719048_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 8
InPort_3719067_0 | SINK | L3J_3_CALEF_RET 9
OutPort_3725052_1 | SOURCE | L3J_3_CALEF_RET 9
OutPort_3719067_1 | SOURCE | L3J_3_CALEF_RET 9
Port_3719259_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719524_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719286_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719286_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719377_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719295_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719524_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719295_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719526_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719375_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719377_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719375_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
Port_3719526_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 14
InPort_3719675_1 | SINK | L3J_3_CALEF_RET 3
OutPort_3719609_0 | SOURCE | L3J_3_CALEF_RET 3
InPort_3719609_1 | SINK | L3J_3_CALEF_IMP 12
OutPort_3719677_2 | SOURCE | L3J_3_CALEF_IMP 12
InPort_3719619_0 | SINK | L3J_3_CALEF_IMP 12
OutPort_3719621_2 | SOURCE | L3J_3_CALEF_IMP 12
InPort_3719677_1 | SINK | L3J_3_CALEF_IMP 12
OutPort_3719619_1 | SOURCE | L3J_3_CALEF_IMP 12
InPort_3719645_0 | SINK | L3J_3_CALEF_RET 12
OutPort_3719681_1 | SOURCE | L3J_3_CALEF_RET 12
InPort_3719686_2 | SINK | L3J_3_CALEF_RET 12
OutPort_3719645_1 | SOURCE | L3J_3_CALEF_RET 12
InPort_3719657_2 | SINK | L3J_3_CALEF_RET 12
OutPort_3719655_0 | SOURCE | L3J_3_CALEF_RET 12
InPort_3719655_1 | SINK | L3J_3_CALEF_RET 12
OutPort_3719686_1 | SOURCE | L3J_3_CALEF_RET 12
Port_3719803_1 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728336_1 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3719803_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3724766_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3719803_3 | SOURCEANDSINK
Port_3719803_4 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3728573_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3719803_5 | SOURCEANDSINK
Port_3721345_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3721345_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5258030_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
InPort_3721642_2 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
OutPort_3721641_0 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
InPort_3721641_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
OutPort_3722509_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
InPort_3722082_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 5
OutPort_3722122_0 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 5
InPort_3722139_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 5
OutPort_3722082_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 5
InPort_3722138_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 5
OutPort_3722139_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 5
InPort_3722760_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 5
OutPort_3722138_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 5
InPort_3722483_0 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
OutPort_3722505_2 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
InPort_3722509_2 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
OutPort_3722483_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
InPort_3722505_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
OutPort_3722988_0 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
Port_3722746_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3722746_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3722801_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
InPort_3722963_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 5
OutPort_3722760_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 5
Port_3722780_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3758383_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3722780_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3722801_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
OutPort_3722963_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 5
InPort_3722988_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 11
Port_3724766_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3728600_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3725663_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3728535_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3725663_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3725691_0 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728488_1 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3725691_1 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3725705_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3728456_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3725705_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3726187_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3728600_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3726187_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3728603_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3726233_0 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728591_2 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3726233_1 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728595_2 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3726265_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3728581_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3726265_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3728586_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
InPort_3726574_0 | SINK | L3J_3_CALEF_RET 11
OutPort_3727366_2 | SOURCE | L3J_3_CALEF_RET 11
InPort_3758064_1 | SINK | L3J_3_CALEF_RET 11
OutPort_3726574_1 | SOURCE | L3J_3_CALEF_RET 11
InPort_3758055_2 | SINK | L3J_3_CALEF_IMP 18
OutPort_3726612_0 | SOURCE | L3J_3_CALEF_IMP 18
InPort_3726612_1 | SINK | L3J_3_CALEF_IMP 18
InPort_3727402_2 | SINK | L3J_3_CALEF_IMP 18
OutPort_3726691_0 | SOURCE | L3J_3_CALEF_IMP 18
InPort_3726691_1 | SINK | L3J_3_CALEF_IMP 18
OutPort_3758055_1 | SOURCE | L3J_3_CALEF_IMP 18
InPort_3758143_2 | SINK | L3J_3_CALEF_RET 14
OutPort_3726840_1 | SOURCE | L3J_3_CALEF_RET 14
InPort_3727221_1 | SINK | L3J_3_CALEF_IMP 16
OutPort_3726897_1 | SOURCE | L3J_3_CALEF_IMP 16
InPort_3727119_2 | SINK | L3J_3_CALEF_IMP 18
OutPort_3727026_0 | SOURCE | L3J_3_CALEF_IMP 18
InPort_3727026_1 | SINK | L3J_3_CALEF_IMP 18
OutPort_3727138_1 | SOURCE | L3J_3_CALEF_IMP 18
InPort_3727138_2 | SINK | L3J_3_CALEF_IMP 18
OutPort_3727130_0 | SOURCE | L3J_3_CALEF_IMP 18
InPort_3727130_1 | SINK | L3J_3_CALEF_IMP 18
OutPort_3727402_1 | SOURCE | L3J_3_CALEF_IMP 18
InPort_3727203_0 | SINK | L3J_3_CALEF_IMP 16
OutPort_3727221_2 | SOURCE | L3J_3_CALEF_IMP 16
InPort_3727366_1 | SINK | L3J_3_CALEF_RET 11
OutPort_3727203_1 | SOURCE | L3J_3_CALEF_RET 11
Port_3728324_0 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728336_2 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728324_1 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728591_1 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728354_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3728573_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
