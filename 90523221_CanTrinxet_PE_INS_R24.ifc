Properties of the parts of a building model (IFC2X3), part 2 of 10

# IfcDistributionPort (4427)
Name | FlowDirection | Group
OutPort_3020435_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
Port_3020542_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_3020588_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_3020542_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_3159077_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_3020577_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_3020588_3 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_3020577_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_3198730_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
InPort_3020589_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
OutPort_3020588_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
InPort_3020630_0 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
OutPort_3020633_2 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
OutPort_3020630_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
InPort_3020633_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
OutPort_3306791_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
InPort_3033649_1 | SINK | L3J_2_AFS 1
OutPort_4013359_1 | SOURCE | L3J_2_AFS 1
InPort_4013361_1 | SINK | L3J_2_ACS 1
OutPort_3033649_2 | SOURCE | L3J_2_ACS 1
Port_3033649_3 | SOURCEANDSINK
InPort_3033901_0 | SINK | L3J_2_AFS 1
OutPort_3769578_1 | SOURCE | L3J_2_AFS 1
InPort_4013359_2 | SINK | L3J_2_AFS 1
OutPort_3033901_1 | SOURCE | L3J_2_AFS 1
Port_3033922_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4013244_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_3033922_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012134_2 | SOURCEANDSINK | L3J_2_AFS 1
InPort_3033938_0 | SINK | L3J_2_ACS 1
OutPort_4013361_2 | SOURCE | L3J_2_ACS 1
InPort_3034244_1 | SINK | L3J_2_ACS 1
OutPort_3033938_1 | SOURCE | L3J_2_ACS 1
InPort_3034339_1 | SINK | L3J_2_ACS 1
OutPort_3034244_2 | SOURCE | L3J_2_ACS 1
InPort_3034343_2 | SINK | L3J_2_ACS 1
OutPort_3034339_0 | SOURCE | L3J_2_ACS 1
InPort_3034360_2 | SINK | L3J_2_ACS 1
OutPort_3034341_0 | SOURCE | L3J_2_ACS 1
InPort_3034341_1 | SINK | L3J_2_ACS 1
OutPort_3034343_1 | SOURCE | L3J_2_ACS 1
InPort_3034352_0 | SINK | L3J_2_ACS 1
OutPort_3034360_1 | SOURCE | L3J_2_ACS 1
InPort_4057562_1 | SINK | L3J_2_ACS 1
OutPort_3034352_1 | SOURCE | L3J_2_ACS 1
InPort_3034489_1 | SINK | L3J_2_AFS 1
OutPort_4060906_1 | SOURCE | L3J_2_AFS 1
InPort_4060908_1 | SINK | L3J_2_ACS 2
OutPort_3034489_2 | SOURCE | L3J_2_ACS 2
Port_3034489_3 | SOURCEANDSINK
InPort_3034724_2 | SINK | L3J_2_AFS 1
OutPort_3034712_0 | SOURCE | L3J_2_AFS 1
InPort_3034712_1 | SINK | L3J_2_AFS 1
OutPort_3035747_1 | SOURCE | L3J_2_AFS 1
InPort_4060906_2 | SINK | L3J_2_AFS 1
OutPort_3034722_0 | SOURCE | L3J_2_AFS 1
InPort_3034722_1 | SINK | L3J_2_AFS 1
OutPort_3034724_1 | SOURCE | L3J_2_AFS 1
InPort_3786085_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3035551_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3035551_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3786090_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3786090_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3035553_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3035553_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3061552_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3035747_2 | SINK | L3J_2_AFS 1
OutPort_3991857_1 | SOURCE | L3J_2_AFS 1
InPort_3035903_2 | SINK | L3J_2_ACS 2
OutPort_3035854_0 | SOURCE | L3J_2_ACS 2
InPort_3035854_1 | SINK | L3J_2_ACS 2
OutPort_4060908_2 | SOURCE | L3J_2_ACS 2
InPort_3035941_2 | SINK | L3J_2_ACS 2
OutPort_3035888_0 | SOURCE | L3J_2_ACS 2
InPort_3035888_1 | SINK | L3J_2_ACS 2
OutPort_3035903_1 | SOURCE | L3J_2_ACS 2
InPort_3035933_0 | SINK | L3J_2_ACS 2
OutPort_3035941_1 | SOURCE | L3J_2_ACS 2
InPort_3035951_2 | SINK | L3J_2_ACS 2
OutPort_3035933_1 | SOURCE | L3J_2_ACS 2
InPort_3035943_0 | SINK | L3J_2_ACS 2
OutPort_3035951_1 | SOURCE | L3J_2_ACS 2
InPort_3036013_1 | SINK | L3J_2_ACS 2
OutPort_3035943_1 | SOURCE | L3J_2_ACS 2
Port_3040357_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163533_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3040357_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3446257_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3043253_1 | SOURCEANDSINK
InPort_3715436_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 6
OutPort_3043253_10 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 6
InPort_3043253_11 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
OutPort_3714247_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
OutPort_3043253_14 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 3
InPort_3043253_15 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 4
Port_3043702_1 | SOURCEANDSINK
InPort_3528896_1 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3043702_10 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3043702_11 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
OutPort_3528506_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
OutPort_3043702_14 | SOURCE
InPort_3043702_15 | SINK
InPort_3058168_0 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5051642_2 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5051647_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_3058168_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
Port_3058241_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826293_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3058241_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826297_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
InPort_3824809_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3060849_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3060849_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3662617_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3060850_0 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3824807_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_4838804_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3060850_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
Port_3104647_1 | SOURCEANDSINK
Port_3104647_2 | SOURCEANDSINK
Port_3115733_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3870861_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3115733_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163923_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3115740_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163923_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3115740_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_4792836_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
InPort_3262604_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3117014_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
Port_3117096_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3164795_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3117096_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3445696_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3117182_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3865789_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3117182_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_5259540_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3117204_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3117204_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3865789_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3119261_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3143902_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3119261_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3482223_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3123296_1 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_4948561_1 | SOURCEANDSINK | L3J_3_CALEF_RET 15
Port_3123296_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_4948564_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 22
Port_3123296_3 | SOURCEANDSINK
InPort_3124397_1 | SINK | L3J_3_CALEF_RET 18
OutPort_4950124_1 | SOURCE | L3J_3_CALEF_RET 18
InPort_4950043_0 | SINK | L3J_3_CALEF_IMP 24
OutPort_3124397_2 | SOURCE | L3J_3_CALEF_IMP 24
Port_3124397_3 | SOURCEANDSINK
Port_3124397_4 | SOURCEANDSINK
Port_3125472_1 | SOURCEANDSINK | L3J_3_CALEF_RET 6
Port_3746539_1 | SOURCEANDSINK | L3J_3_CALEF_RET 6
Port_3125472_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3125472_3 | SOURCEANDSINK
Port_3125472_4 | SOURCEANDSINK
Port_3134601_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3143902_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3134601_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3143471_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3135138_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3143471_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3135138_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3147361_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3135200_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3147361_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3135200_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3135526_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3147281_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3135526_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3147327_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3135630_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3155820_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3135630_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3147327_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3135821_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3155820_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3135821_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
InPort_4957280_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 8
OutPort_3137599_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 8
InPort_3137599_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 8
OutPort_4957273_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 8
Port_3143893_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3479607_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3143893_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3143902_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3143914_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3479607_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3143914_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 4
Port_3144111_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466467_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3144111_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3146056_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
Port_3465680_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
Port_3146056_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
Port_3147281_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3484189_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3147281_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259574_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3147293_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259553_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3147293_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3148056_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3868194_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3148056_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3866887_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3148084_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3148084_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3866887_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3148689_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3256877_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3148689_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3154513_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466249_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3154513_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3154786_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3256877_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3154786_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3465869_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3157516_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_4968812_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_3159077_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_4968812_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_3163237_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163586_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163237_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5258032_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163330_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3876880_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163330_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5258030_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163330_3 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5258032_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163498_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3165194_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163498_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163533_3 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163499_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5258041_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163499_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5258035_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163533_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5258035_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163580_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163586_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3163580_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
InPort_3163606_0 | SINK | Mecánica L3J_3_VENT_RETORN_AIRE 1
OutPort_3876895_1 | SOURCE | Mecánica L3J_3_VENT_RETORN_AIRE 1
InPort_4792847_1 | SINK | Mecánica L3J_3_VENT_RETORN_AIRE 1
OutPort_3163606_1 | SOURCE | Mecánica L3J_3_VENT_RETORN_AIRE 1
Port_3163739_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163835_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163739_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3870863_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163755_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163755_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163835_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163829_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3870861_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163829_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3870947_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163829_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3870863_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163935_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_4792836_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3163935_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_4792841_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
InPort_3445611_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3163951_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3163951_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3445612_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3163959_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3445611_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3163972_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3163959_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3163967_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3876090_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3876057_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3163967_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3261788_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3163972_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
Port_3164766_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3865792_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3164766_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3164795_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3165190_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3165194_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3165190_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3167355_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3445696_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3167355_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3445698_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3169689_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_5259534_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_3169689_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_3864930_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_3169777_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_3169777_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_3864928_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_3181914_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466298_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3181914_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_5245029_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3181914_3 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_5245032_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3182808_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466344_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3182808_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466298_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3182808_3 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_5245037_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3183059_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466125_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3183059_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3465729_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3183059_3 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
InPort_3184136_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_5251241_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3184188_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3184136_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_5251149_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3184136_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_5251136_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3184188_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
Port_3184276_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3483491_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3184361_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3184276_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3184276_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3469819_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3204640_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3184361_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3184621_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_5251296_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3469922_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3184621_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3191315_1 | SOURCEANDSINK
Port_3191315_2 | SOURCEANDSINK
Port_3191315_3 | SOURCEANDSINK
Port_3191315_4 | SOURCEANDSINK
Port_3191432_1 | SOURCEANDSINK
Port_3191603_1 | SOURCEANDSINK
Port_3191632_1 | SOURCEANDSINK
Port_3192050_1 | SOURCEANDSINK
Port_3192050_2 | SOURCEANDSINK
Port_3192050_3 | SOURCEANDSINK
Port_3192050_4 | SOURCEANDSINK
Port_3192599_1 | SOURCEANDSINK
Port_3192599_2 | SOURCEANDSINK
Port_3192599_3 | SOURCEANDSINK
Port_3192599_4 | SOURCEANDSINK
Port_3192675_1 | SOURCEANDSINK
Port_3192675_2 | SOURCEANDSINK
Port_3192675_3 | SOURCEANDSINK
Port_3192675_4 | SOURCEANDSINK
Port_3193209_1 | SOURCEANDSINK
Port_3193320_1 | SOURCEANDSINK
Port_3193354_1 | SOURCEANDSINK
Port_3193448_1 | SOURCEANDSINK
Port_3193573_1 | SOURCEANDSINK
Port_3193678_1 | SOURCEANDSINK
Port_3193697_1 | SOURCEANDSINK
Port_3194036_1 | SOURCEANDSINK
Port_3194070_1 | SOURCEANDSINK
Port_3194142_1 | SOURCEANDSINK
Port_3194231_1 | SOURCEANDSINK
Port_3194585_1 | SOURCEANDSINK
Port_3194585_2 | SOURCEANDSINK
Port_3194585_3 | SOURCEANDSINK
Port_3194585_4 | SOURCEANDSINK
Port_3194616_1 | SOURCEANDSINK
Port_3194616_2 | SOURCEANDSINK
Port_3194616_3 | SOURCEANDSINK
Port_3194616_4 | SOURCEANDSINK
Port_3194718_1 | SOURCEANDSINK
Port_3194718_2 | SOURCEANDSINK
Port_3194718_3 | SOURCEANDSINK
Port_3194718_4 | SOURCEANDSINK
Port_3195241_1 | SOURCEANDSINK
Port_3195260_1 | SOURCEANDSINK
Port_3195289_1 | SOURCEANDSINK
Port_3195557_1 | SOURCEANDSINK
Port_3195563_1 | SOURCEANDSINK
Port_3195658_1 | SOURCEANDSINK
Port_3195658_2 | SOURCEANDSINK
Port_3195658_3 | SOURCEANDSINK
Port_3195658_4 | SOURCEANDSINK
InPort_3673698_2 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
OutPort_3196707_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
Port_3196718_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771446_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
InPort_3673663_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
OutPort_3197467_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
InPort_3197467_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
OutPort_3673698_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 4
Port_3198280_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_4968814_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_3198730_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
Port_4968814_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 6
InPort_3201107_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3469851_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3201224_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3469654_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3201230_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3469920_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3201393_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3484975_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3201401_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3478077_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3201411_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3472525_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_5251296_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3204640_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_5251299_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3204640_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3231367_1 | SOURCEANDSINK
Port_3231377_1 | SOURCEANDSINK
Port_3231427_1 | SOURCEANDSINK
Port_3231933_1 | SOURCEANDSINK
Port_3232108_1 | SOURCEANDSINK
Port_3235286_1 | SOURCEANDSINK
InPort_3235928_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3743013_1 | SOURCE | L3J_3_CALEF_RET 4
Port_3235928_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3743008_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3235928_3 | SOURCEANDSINK
InPort_3766900_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3235928_4 | SOURCE | L3J_4_SAN_FECAL 3
Port_3236739_1 | SOURCEANDSINK
Port_3239115_0 | SOURCEANDSINK
Port_3239115_1 | SOURCEANDSINK
Port_3239391_0 | SOURCEANDSINK
Port_3239399_1 | SOURCEANDSINK
Port_3239391_1 | SOURCEANDSINK
Port_3239399_2 | SOURCEANDSINK
Port_5167332_0 | SOURCEANDSINK
Port_3239923_0 | SOURCEANDSINK
Port_3239923_1 | SOURCEANDSINK
Port_3240639_0 | SOURCEANDSINK
Port_3246497_2 | SOURCEANDSINK
Port_3240639_1 | SOURCEANDSINK
Port_3246500_2 | SOURCEANDSINK
Port_3240889_0 | SOURCEANDSINK
Port_3246500_1 | SOURCEANDSINK
Port_3240889_1 | SOURCEANDSINK
Port_3240899_1 | SOURCEANDSINK
Port_3240899_2 | SOURCEANDSINK
Port_3241085_0 | SOURCEANDSINK
Port_3246464_2 | SOURCEANDSINK
Port_3241085_1 | SOURCEANDSINK
Port_3244965_0 | SOURCEANDSINK
Port_5167754_1 | SOURCEANDSINK
Port_3244965_1 | SOURCEANDSINK
Port_3245233_1 | SOURCEANDSINK
Port_3245233_2 | SOURCEANDSINK
Port_3246021_0 | SOURCEANDSINK
Port_3246497_1 | SOURCEANDSINK
Port_3246021_1 | SOURCEANDSINK
Port_3246470_2 | SOURCEANDSINK
Port_3246383_0 | SOURCEANDSINK
Port_3246470_1 | SOURCEANDSINK
Port_3246383_1 | SOURCEANDSINK
Port_3246464_1 | SOURCEANDSINK
Port_3254759_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3254771_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3254759_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3868688_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3254769_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3254771_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3254775_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3868677_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3254775_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3255333_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3255049_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3679883_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3255049_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3255333_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_3256502_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475231_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3256537_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475574_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3257107_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3474929_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475031_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3257107_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475134_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3257107_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
Port_3259459_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259553_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259459_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259570_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259563_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259570_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259563_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259618_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259574_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
Port_3259618_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 5
InPort_3261401_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3438839_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3261412_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3434427_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3261510_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3461798_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3261515_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3460715_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3261520_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3436605_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3261529_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3436626_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3261534_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3516932_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3261539_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3876508_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3261544_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3876479_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3261785_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3261788_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3876093_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3261785_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_5251337_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3261785_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3262361_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3876056_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3516932_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3262361_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3262619_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3262604_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3262612_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3262619_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_5251529_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3262612_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3262832_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_5251441_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_5251505_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3262832_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_5251590_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3262832_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
Port_3285533_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285547_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285533_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285840_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285840_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285939_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285937_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285941_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285937_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3286012_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285939_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3285941_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3286012_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3692655_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3286077_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691966_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3286077_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3287140_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3287140_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691931_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3290733_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056701_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_3290733_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
InPort_5052038_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_3291359_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_3293322_0 | SINK | L3J_2_AFS 1
OutPort_3993795_1 | SOURCE | L3J_2_AFS 1
InPort_3293868_1 | SINK | L3J_2_AFS 1
OutPort_3293322_1 | SOURCE | L3J_2_AFS 1
InPort_3293735_1 | SINK | L3J_2_AFS 1
OutPort_3991700_0 | SOURCE | L3J_2_AFS 1
InPort_3293820_0 | SINK | L3J_2_AFS 1
OutPort_3994324_1 | SOURCE | L3J_2_AFS 1
InPort_3993795_2 | SINK | L3J_2_AFS 1
OutPort_3293820_1 | SOURCE | L3J_2_AFS 1
InPort_3293860_0 | SINK | L3J_2_AFS 1
OutPort_3293868_2 | SOURCE | L3J_2_AFS 1
InPort_3293947_1 | SINK | L3J_2_AFS 1
OutPort_3293860_1 | SOURCE | L3J_2_AFS 1
Port_3294536_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3676970_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3294536_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_3303993_0 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3296902_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_5110152_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3297445_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3659877_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3303993_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3304809_0 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_5052026_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_5051645_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_3304809_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_3306803_2 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
OutPort_3306781_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
InPort_3306791_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
OutPort_3306803_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 7
InPort_4968915_2 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
OutPort_3306897_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
InPort_3306905_0 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
OutPort_4968915_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
InPort_4968917_2 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
OutPort_3306905_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 5
Port_3342064_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_3342266_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_3342064_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_3528455_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_3342073_0 | SOURCEANDSINK | Mechanical L3J_VENTILACIÓ_CTE_HS3 1
Port_3342073_1 | SOURCEANDSINK | Mechanical L3J_VENTILACIÓ_CTE_HS3 1
Port_3342404_1 | SOURCEANDSINK | Mechanical L3J_VENTILACIÓ_CTE_HS3 1
Port_3342266_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_5255558_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 8
Port_3342397_0 | SOURCEANDSINK | Mechanical L3J_VENTILACIÓ_CTE_HS3 1
Port_3342404_2 | SOURCEANDSINK | Mechanical L3J_VENTILACIÓ_CTE_HS3 1
Port_3342397_1 | SOURCEANDSINK | Mechanical L3J_VENTILACIÓ_CTE_HS3 1
InPort_4059531_2 | SINK | L3J_2_AFS 1
OutPort_3348809_0 | SOURCE | L3J_2_AFS 1
InPort_3348809_1 | SINK | L3J_2_AFS 1
OutPort_3349754_1 | SOURCE | L3J_2_AFS 1
InPort_3348820_0 | SINK | L3J_2_AFS 1
OutPort_3356069_2 | SOURCE | L3J_2_AFS 1
InPort_4059521_2 | SINK | L3J_2_AFS 1
OutPort_3348820_1 | SOURCE | L3J_2_AFS 1
InPort_3356061_2 | SINK | L3J_2_AFS 1
OutPort_3349062_0 | SOURCE | L3J_2_AFS 1
InPort_3349062_1 | SINK | L3J_2_AFS 1
OutPort_4059591_1 | SOURCE | L3J_2_AFS 1
InPort_4059591_3 | SINK | L3J_2_AFS 1
OutPort_3349132_0 | SOURCE | L3J_2_AFS 1
InPort_3349132_1 | SINK | L3J_2_AFS 1
OutPort_3985687_2 | SOURCE | L3J_2_AFS 1
InPort_3349171_0 | SINK | L3J_2_AFS 1
OutPort_3356059_2 | SOURCE | L3J_2_AFS 1
InPort_3356067_2 | SINK | L3J_2_AFS 1
OutPort_3349171_1 | SOURCE | L3J_2_AFS 1
InPort_3356059_1 | SINK | L3J_2_AFS 1
OutPort_3349211_1 | SOURCE | L3J_2_AFS 1
InPort_3349211_2 | SINK | L3J_2_AFS 1
OutPort_3356061_1 | SOURCE | L3J_2_AFS 1
InPort_3349221_1 | SINK | L3J_2_AFS 1
OutPort_3356067_1 | SOURCE | L3J_2_AFS 1
InPort_3356069_1 | SINK | L3J_2_AFS 1
OutPort_3349221_2 | SOURCE | L3J_2_AFS 1
InPort_3349732_0 | SINK | L3J_2_AFS 1
OutPort_4058888_1 | SOURCE | L3J_2_AFS 1
InPort_3349754_2 | SINK | L3J_2_AFS 1
OutPort_3349732_1 | SOURCE | L3J_2_AFS 1
Port_3350058_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771446_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3350058_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3770868_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
InPort_3363209_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
OutPort_4968983_2 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
InPort_4792889_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
OutPort_3363240_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
InPort_3686217_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3364200_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3364200_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3686193_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3686193_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3364202_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3364202_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3674452_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3364979_1 | SINK | L3J_2_AFS 1
OutPort_3364494_0 | SOURCE | L3J_2_AFS 1
InPort_3364494_1 | SINK | L3J_2_AFS 1
OutPort_3364981_1 | SOURCE | L3J_2_AFS 1
InPort_3364500_2 | SINK | L3J_2_AFS 1
OutPort_3364496_0 | SOURCE | L3J_2_AFS 1
InPort_3364496_1 | SINK | L3J_2_AFS 1
OutPort_3364979_2 | SOURCE | L3J_2_AFS 1
InPort_3365940_0 | SINK | L3J_2_AFS 1
OutPort_4059523_2 | SOURCE | L3J_2_AFS 1
InPort_4059525_1 | SINK | L3J_2_AFS 1
OutPort_3365940_1 | SOURCE | L3J_2_AFS 1
InPort_3365953_0 | SINK | L3J_2_AFS 1
OutPort_4059525_2 | SOURCE | L3J_2_AFS 1
InPort_3365976_1 | SINK | L3J_2_AFS 1
OutPort_3365953_1 | SOURCE | L3J_2_AFS 1
InPort_3366034_0 | SINK | L3J_2_AFS 1
OutPort_3365976_2 | SOURCE | L3J_2_AFS 1
InPort_3366018_0 | SINK | L3J_2_AFS 1
OutPort_3366201_2 | SOURCE | L3J_2_AFS 1
InPort_4060972_1 | SINK | L3J_2_AFS 1
OutPort_3366018_1 | SOURCE | L3J_2_AFS 1
InPort_3366201_1 | SINK | L3J_2_AFS 1
OutPort_3366034_1 | SOURCE | L3J_2_AFS 1
Port_3384852_1 | SOURCEANDSINK
InPort_3670547_1 | SINK | L3J_4_SAN_FECAL 1 (2)
OutPort_3384852_4 | SOURCE | L3J_4_SAN_FECAL 1 (2)
InPort_4950393_1 | SINK | L3J_3_CALEF_IMP 25
OutPort_3384852_5 | SOURCE | L3J_3_CALEF_IMP 25
InPort_3384852_6 | SINK | L3J_3_CALEF_RET 19
OutPort_4950331_0 | SOURCE | L3J_3_CALEF_RET 19
InPort_3643768_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3384852_7 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3384852_8 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_3639460_1 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
Port_3384852_9 | SOURCEANDSINK
InPort_3388084_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388339_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3391879_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388084_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3388181_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388189_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3393091_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388181_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3389824_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388181_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3389863_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388181_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3389940_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388181_4 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3390826_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388181_5 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3388189_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_5253343_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3388340_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388189_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3388208_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3391879_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3393094_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388208_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3391525_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388208_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3391582_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388208_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3391665_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388208_4 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3391888_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388208_5 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3388339_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388340_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3388382_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388339_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3393096_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388382_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3391279_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388382_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3391340_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388382_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3391450_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388382_4 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3392793_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3388382_5 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3391980_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 10
OutPort_3391879_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 10
InPort_3405142_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3645414_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3405384_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 9
OutPort_3645018_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 9
InPort_3405412_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 2
OutPort_3643336_2 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 2
InPort_3410323_0 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_5250135_2 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
InPort_3641914_2 | SINK | Mecánica L3J_3_VENT_APORT_AIRE 1
OutPort_3410323_1 | SOURCE | Mecánica L3J_3_VENT_APORT_AIRE 1
Port_3427762_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3428076_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3427762_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3428077_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3427776_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3428076_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3427776_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3439780_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3428077_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
InPort_3431691_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3429001_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3429001_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3431695_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3431635_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3431691_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3432065_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3431635_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3431695_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3434173_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3432065_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3432238_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3434292_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3434426_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3432238_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3432326_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3434172_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3438841_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3432326_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3433094_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_5249778_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3438370_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3433094_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
Port_3433205_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
Port_3433262_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
Port_3433262_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3433736_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3438370_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3438429_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3433736_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3434172_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3434173_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3434229_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3434172_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3434292_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3434229_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3434423_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3434426_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3434427_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3434423_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3438428_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3434968_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3434968_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3438429_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3435679_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_5249780_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3436625_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3435679_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3435690_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_5249778_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3435690_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_5249780_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3435690_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3436392_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3436625_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3436626_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3436392_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3436545_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3438526_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3438527_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3436545_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3436605_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3436602_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3436602_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3438527_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3438416_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3438414_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3438414_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3438428_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3438449_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3438416_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3438526_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 2
OutPort_3438449_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 2
InPort_3438839_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3438836_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
InPort_3438836_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 3
OutPort_3438841_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 3
Port_3439225_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_3864930_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_3439552_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447314_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3439552_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3439597_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447369_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3439597_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3439780_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3439665_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447322_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3439665_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_5259513_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3439780_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
InPort_3445612_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3445608_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
Port_3446257_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3446273_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3446257_3 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447552_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3446273_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3446432_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3446348_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
Port_3446348_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
Port_3446393_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
Port_3446382_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
Port_3446393_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
Port_3446382_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
Port_3446434_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
Port_3446432_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3446434_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
Port_3446747_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447369_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3446747_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447371_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447281_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447322_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447281_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447371_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447314_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_5259513_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 7
Port_3447552_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447715_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447642_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447955_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447642_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447715_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447843_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447846_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447843_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447844_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447956_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447844_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5244917_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447845_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447955_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447845_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447956_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3447846_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5244917_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3448600_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3460012_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3448600_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3455120_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455157_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455120_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455180_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455180_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455776_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455776_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455782_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455777_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455782_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3455777_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3691421_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3458732_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515028_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3458732_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3458845_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3515028_3 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3458845_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3459996_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3459989_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3459996_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3459989_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3460012_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
InPort_3460715_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_5251590_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3461629_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3461627_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3461627_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3461632_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3461632_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3461628_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3461628_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_5251505_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3461657_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3461629_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3461801_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3461657_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
InPort_3461798_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 4
OutPort_3461801_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 4
Port_3464076_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3716559_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3464076_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466344_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3464076_3 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466703_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3465660_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
Port_3465680_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
Port_3465660_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
Port_3465683_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
Port_3465683_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
Port_3465729_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3465870_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3465766_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3465869_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3465766_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3465870_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466125_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_5245029_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466212_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466249_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466212_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_5245032_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466444_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466467_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466444_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_5245037_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466703_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
Port_3466815_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 9
Port_3466816_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 9
Port_3466815_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 9
Port_3466816_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 9
InPort_3469654_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3469651_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3469651_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_5251299_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3469819_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3469851_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3469828_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3469828_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3469853_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3469853_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3469920_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3469909_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
InPort_3469909_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 1
OutPort_3469922_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 1
Port_3470287_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3868134_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3470287_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3872829_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3470433_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471431_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3470433_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3867993_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3470433_3 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3873626_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3470739_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3868134_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3470739_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3867996_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3470898_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3873626_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3470898_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471010_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471009_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471010_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471009_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471013_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471013_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3485574_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471222_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3714058_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471222_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471431_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471222_3 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471634_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471355_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471705_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471355_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471707_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471634_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471681_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471643_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471681_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471643_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471705_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3471707_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3482423_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
InPort_3472525_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3472515_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3472515_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_5251136_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3474929_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3867432_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475529_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475031_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475136_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475134_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475135_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475136_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475233_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475135_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475231_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475228_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475228_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475233_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475518_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475529_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475540_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475518_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475531_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475540_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475572_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475531_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475569_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475572_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3475574_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3475569_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3476860_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3485085_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3477801_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3476860_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_5251171_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3476860_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_5251243_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3477801_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3478051_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_5251149_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3478077_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
