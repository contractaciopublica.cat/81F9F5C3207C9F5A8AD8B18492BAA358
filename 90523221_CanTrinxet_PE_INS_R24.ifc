Properties of the parts of a building model (IFC2X3), part 9 of 10

# IfcFlowSegment: Pipe Types:L3J_TUBERIA_SANEJAMENT_PLUVIAL_PVC (26)
Name (Pipe Types:L3J_TUBERIA_SANEJAMENT_PLUVIAL_PVC:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
5110090 | PLANTA BAIXA | 0.267634 | 5.26992 | PLANTA BAIXA | Nau Lateral Sud | 90 mmø | 0.0756716 | 0.09 | L3J_4_SAN_PLUVIAL 6
5208988 | PLANTA BAIXA | 0.616831 | 2.83083 | PLANTA BAIXA | Nau Lateral Sud | 110 mmø | 0.213161 | 0.11 | L3J_4_SAN_PLUVIAL 6
5218852 | PLANTA BAIXA | 6.44436 | 0.203775 | PLANTA BAIXA | Nau Lateral Sud | 110 mmø | 2.22701 | 0.11 | L3J_4_SAN_PLUVIAL 6
5219367 | PLANTA BAIXA | 0.360873 | 6.82852 | PLANTA BAIXA | Nau Lateral Sud | 110 mmø | 0.124709 | 0.11 | L3J_4_SAN_PLUVIAL 6
5219393 | PLANTA BAIXA | 0.108773 | 7.337 | PLANTA BAIXA | Nau Lateral Sud | 110 mmø | 0.0375894 | 0.11 | L3J_4_SAN_PLUVIAL 6

# IfcFlowSegment: Pipe Types:L3J_TUBERIA_SANEJAMENT_PLUVIAL_PVC_SOTERRAT (30)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.10; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües pluvials; 109.AMB.CodiTipus: SAN-PVCS
Classification: 50.20.20.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:L3J_TUBERIA_SANEJAMENT_PLUVIAL_PVC_SOTERRAT; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TUBERIA_SANEJAMENT_PLUVIAL_PVC_SOTERRAT; 112.AMB.Servei: L3J_4_SAN_PLUVIAL; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:L3J_TUBERIA_SANEJAMENT_PLUVIAL_PVC_SOTERRAT:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
3058168 | PLANTA BAIXA | 5.62506 | -0.656147 | PLANTA BAIXA | 125 mmø | 2.20896 | 0.125 | L3J_4_SAN_PLUVIAL 3
3058241 | PLANTA BAIXA | 14.2006 | -0.606468 | PLANTA BAIXA | 125 mmø | 5.57656 | 0.125 | L3J_4_SAN_PLUVIAL 8
3060849 | PLANTA BAIXA | 2.45319 | -0.425438 | PLANTA BAIXA | 125 mmø | 0.963367 | 0.125 | L3J_4_SAN_PLUVIAL 6
3060850 | PLANTA BAIXA | 0.259037 | -0.640242 | PLANTA BAIXA | 160 mmø | 0.130206 | 0.16 | L3J_4_SAN_PLUVIAL 6
3658883 | PLANTA BAIXA | 5.39125 | 0.0620854 | PLANTA BAIXA | 125 mmø | 2.11714 | 0.125 | L3J_4_SAN_PLUVIAL 6 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau lateral
3658891 | PLANTA BAIXA | 5.69514 | -0.0222171 | PLANTA BAIXA | 125 mmø | 2.23648 | 0.125 | L3J_4_SAN_PLUVIAL 6 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau lateral
3661185 | PLANTA BAIXA | 2.01032 | -0.218101 | PLANTA BAIXA | 125 mmø | 0.789449 | 0.125 | L3J_4_SAN_PLUVIAL 6
3661291 | PLANTA BAIXA | 7.27952 | -0.371908 | PLANTA BAIXA | 125 mmø | 2.85866 | 0.125 | L3J_4_SAN_PLUVIAL 6
3788986 | PLANTA COBERTA | 1.73139 | -0.419469 | PLANTA COBERTA | 125 mmø | 0.679914 | 0.125 | L3J_4_SAN_PLUVIAL 3
3789228 | PLANTA COBERTA | 0.569192 | -0.314124 | PLANTA COBERTA | 125 mmø | 0.223521 | 0.125 | L3J_4_SAN_PLUVIAL 8
3789241 | PLANTA COBERTA | 0.148248 | -0.285749 | PLANTA COBERTA | 125 mmø | 0.058217 | 0.125 | L3J_4_SAN_PLUVIAL 8 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau Santa Eulalia
3802820 | PLANTA BAIXA | 2.28306 | -0.795556 | PLANTA BAIXA | 160 mmø | 1.14759 | 0.16 | L3J_4_SAN_PLUVIAL 3
3814360 | PLANTA COBERTA | 2.41701 | -0.630028 | PLANTA COBERTA | 125 mmø | 0.949158 | 0.125 | L3J_4_SAN_PLUVIAL 8
3824787 | PLANTA BAIXA | 0.692016 | -0.598455 | PLANTA BAIXA | 125 mmø | 0.271754 | 0.125 | L3J_4_SAN_PLUVIAL 6
3825602 | PLANTA COBERTA | 0.192848 | -0.614485 | PLANTA COBERTA | 160 mmø | 0.096936 | 0.16 | L3J_4_SAN_PLUVIAL 1
3825616 | PLANTA COBERTA | 4.97794 | -0.610915 | PLANTA COBERTA | 160 mmø | 2.50219 | 0.16 | L3J_4_SAN_PLUVIAL 1
3826022 | PLANTA COBERTA | 3.78421 | -0.73491 | PLANTA COBERTA | 160 mmø | 1.90215 | 0.16 | L3J_4_SAN_PLUVIAL 8
3826139 | PLANTA COBERTA | 0.295529 | -0.627053 | PLANTA COBERTA | 125 mmø | 0.116054 | 0.125 | L3J_4_SAN_PLUVIAL 8
3826156 | PLANTA COBERTA | 0.22748 | -0.616726 | PLANTA COBERTA | 125 mmø | 0.0893311 | 0.125 | L3J_4_SAN_PLUVIAL 8
5051464 | PLANTA BAIXA | 2.50425 | -0.71064 | PLANTA BAIXA | 125 mmø | 0.983416 | 0.125 | L3J_4_SAN_PLUVIAL 3
5052329 | PLANTA BAIXA | 1.24882 | -0.549554 | PLANTA BAIXA | 160 mmø | 0.627726 | 0.16 | L3J_4_SAN_PLUVIAL 3
5052338 | PLANTA BAIXA | 8.03191 | -0.730032 | PLANTA BAIXA | 160 mmø | 4.03728 | 0.16 | L3J_4_SAN_PLUVIAL 3
5052508 | PLANTA BAIXA | 6.35567 | -0.515331 | PLANTA BAIXA | 160 mmø | 3.19471 | 0.16 | L3J_4_SAN_PLUVIAL 3
5056644 | PLANTA BAIXA | 3.56427 | -0.49526 | PLANTA BAIXA | 125 mmø | 1.39969 | 0.125 | L3J_4_SAN_PLUVIAL 3
5056746 | PLANTA BAIXA | 4.79717 | -0.532677 | PLANTA BAIXA | 125 mmø | 1.88385 | 0.125 | L3J_4_SAN_PLUVIAL 3
5056880 | PLANTA BAIXA | 16.1042 | -0.432354 | PLANTA BAIXA | 125 mmø | 6.32409 | 0.125 | L3J_4_SAN_PLUVIAL 3
5218582 | PLANTA BAIXA | 0.410813 | -0.163335 | PLANTA BAIXA | 125 mmø | 0.161326 | 0.125 | L3J_4_SAN_PLUVIAL 6
5218591 | PLANTA BAIXA | 0.796177 | -0.185631 | PLANTA BAIXA | 125 mmø | 0.312658 | 0.125 | L3J_4_SAN_PLUVIAL 6
5218809 | PLANTA BAIXA | 7.0268 | -0.163427 | PLANTA BAIXA | 125 mmø | 2.75942 | 0.125 | L3J_4_SAN_PLUVIAL 6 | 1 AMB.Identificacio - 117.AMB.Localitzacio: Nau lateral
5218814 | PLANTA BAIXA | 0.68125 | -0.150629 | PLANTA BAIXA | 125 mmø | 0.267526 | 0.125 | L3J_4_SAN_PLUVIAL 6

# IfcFlowSegment: Pipe Types:L3J_TUBERIA_SANEJAMENT_RESIDUAL_PVC (25)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN-PVC
Classification: 50.20.20.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:L3J_TUBERIA_SANEJAMENT_RESIDUAL_PVC; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TUBERIA_SANEJAMENT_RESIDUAL_PVC; 112.AMB.Servei: L3J_4_SAN_FECAL; 117.AMB.Localitzacio: Nau Lateral Sud; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:L3J_TUBERIA_SANEJAMENT_RESIDUAL_PVC:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 115.AMB.Nivell | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
3663202 | PLANTA BAIXA | 0.104896 | 4.30661 | PLANTA BAIXA | 50 mmø | 0.0164771 | 0.05 | L3J_4_SAN_FECAL 1 (2); L3J_4_SAN_PLUVIAL 6
3663212 | PLANTA BAIXA | 0.0861133 | 4.45289 | PLANTA BAIXA | 50 mmø | 0.0135266 | 0.05 | L3J_4_SAN_FECAL 1 (2)
3663363 | PLANTA BAIXA | 0.424287 | 4.45486 | PLANTA BAIXA | 50 mmø | 0.0666469 | 0.05 | L3J_4_SAN_FECAL 1 (2)
3663701 | PLANTA COBERTA | 0.0755982 | 7.2926 | PLANTA COBERTA | 25 mmø | 0.00593747 | 0.025 | L3J_4_SAN_FECAL 1 (2)
3663954 | PLANTA COBERTA | 0.143698 | 7.11699 | PLANTA COBERTA | 25 mmø | 0.011286 | 0.025 | L3J_4_SAN_FECAL 1 (2)
3664465 | PLANTA BAIXA | 1.74553 | 5.25927 | PLANTA BAIXA | 25 mmø | 0.137093 | 0.025 | L3J_4_SAN_FECAL 1 (2)
3669816 | PLANTA BAIXA | 1.49221 | 5.18957 | PLANTA BAIXA | 25 mmø | 0.117198 | 0.025 | L3J_4_SAN_FECAL 1 (2)
3669824 | PLANTA BAIXA | 0.966527 | 4.85178 | PLANTA BAIXA | 25 mmø | 0.0759108 | 0.025 | L3J_4_SAN_FECAL 1 (2)
3669849 | PLANTA BAIXA | 0.241154 | 4.91623 | PLANTA BAIXA | 25 mmø | 0.0189402 | 0.025 | L3J_4_SAN_FECAL 1 (2)
3670152 | PLANTA BAIXA | 1.23305 | 4.8388 | PLANTA BAIXA | 25 mmø | 0.0968435 | 0.025 | L3J_4_SAN_FECAL 1 (2)
3670165 | PLANTA BAIXA | 1.96355 | 4.81808 | PLANTA BAIXA | 25 mmø | 0.154216 | 0.025 | L3J_4_SAN_FECAL 1 (2)
3670293 | PLANTA BAIXA | 0.307193 | 4.80436 | PLANTA BAIXA | 50 mmø | 0.0482537 | 0.05 | L3J_4_SAN_FECAL 1 (2)
3670526 | PLANTA BAIXA | 0.0367886 | 4.96563 | PLANTA BAIXA | 32 mmø | 0.00369839 | 0.032 | L3J_4_SAN_FECAL 1 (2)
3670560 | PLANTA BAIXA | 0.695516 | 4.9581 | PLANTA BAIXA | 32 mmø | 0.0699209 | 0.032 | L3J_4_SAN_FECAL 1 (2)
3670601 | PLANTA BAIXA | 1.30239 | 4.81206 | PLANTA BAIXA | 32 mmø | 0.13093 | 0.032 | L3J_4_SAN_FECAL 1 (2)
3670616 | PLANTA BAIXA | 0.016354 | 4.89768 | PLANTA BAIXA | 32 mmø | 0.00164408 | 0.032 | L3J_4_SAN_FECAL 1 (2)
3671176 | PLANTA BAIXA | 0.215034 | 4.54505 | PLANTA BAIXA | 50 mmø | 0.0337774 | 0.05 | L3J_4_SAN_FECAL 1 (2)
3671918 | PLANTA BAIXA | 0.0570231 | 4.81677 | PLANTA BAIXA | 25 mmø | 0.00447858 | 0.025 | L3J_4_SAN_FECAL 1 (2)
3671929 | PLANTA BAIXA | 0.133625 | 4.80133 | PLANTA BAIXA | 50 mmø | 0.0209897 | 0.05 | L3J_4_SAN_FECAL 1 (2)
4947764 | PLANTA BAIXA | 2.24874 | 7.03699 | PLANTA BAIXA | 25 mmø | 0.176615 | 0.025 | L3J_4_SAN_FECAL 1 (2)
4947964 | PLANTA BAIXA | 0.437959 | 7.04661 | PLANTA BAIXA | 25 mmø | 0.0343973 | 0.025 | L3J_4_SAN_FECAL 1 (2)
4947983 | PLANTA BAIXA | 1.0577 | 7.05164 | PLANTA BAIXA | 25 mmø | 0.0830712 | 0.025 | L3J_4_SAN_FECAL 1 (2)
5208902 | PLANTA BAIXA | 0.171761 | 3.78088 | PLANTA BAIXA | 25 mmø | 0.0134901 | 0.025 | L3J_4_SAN_FECAL 1
5208911 | PLANTA BAIXA | 0.485429 | 3.26634 | PLANTA BAIXA | 25 mmø | 0.0381255 | 0.025 | L3J_4_SAN_FECAL 1
5208931 | PLANTA BAIXA | 3.22704 | 3.14681 | PLANTA BAIXA | 25 mmø | 0.253451 | 0.025 | L3J_4_SAN_FECAL 1

# IfcFlowSegment: Pipe Types:L3J_TUBERIA_SANEJAMENT_RESIDUAL_PVC_SOTERRAT (180)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.20.20.20; 105.AMB.ClassificacioDescripcio: Canalitzacions d'aigües residuals; 109.AMB.CodiTipus: SAN-PVCS
Classification: 50.20.20.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:L3J_TUBERIA_SANEJAMENT_RESIDUAL_PVC_SOTERRAT; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_TUBERIA_SANEJAMENT_RESIDUAL_PVC_SOTERRAT; 112.AMB.Servei: L3J_4_SAN_FECAL; 119.AMB.FaseCreacio: Obra
Name (Pipe Types:L3J_TUBERIA_SANEJAMENT_RESIDUAL_PVC_SOTERRAT:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 507.AMB.Area (m2) | 505.AMB.Diametre (m) | Group
2969144 | PLANTA BAIXA | 0.50055 | 0.936711 | PLANTA BAIXA | Annex | 40 mmø | 0.0629009 | 0.04 | L3J_4_SAN_FECAL 3
2969387 | PLANTA BAIXA | 0.16222 | 1.48178 | PLANTA BAIXA | Annex | 40 mmø | 0.0203852 | 0.04 | L3J_4_SAN_FECAL 3
2974285 | PLANTA BAIXA | 1.86951 | -1.16925 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.293662 | 0.05 | L3J_4_SAN_FECAL 3
2974658 | PLANTA BAIXA | 0.0647126 | 0.741356 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.010165 | 0.05 | L3J_4_SAN_FECAL 3
3019469 | PLANTA BAIXA | 1.35291 | -0.711658 | PLANTA BAIXA | Nau Santa Eulalia | 40 mmø | 0.170011 | 0.04 | L3J_4_SAN_FECAL 3
3019471 | PLANTA BAIXA | 0.161957 | 0.6818 | PLANTA BAIXA | Nau Santa Eulalia | 40 mmø | 0.0203521 | 0.04 | L3J_4_SAN_FECAL 3
3035551 | PLANTA BAIXA | 1.08144 | -0.375733 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.169872 | 0.05 | L3J_4_SAN_FECAL 3
3035553 | PLANTA BAIXA | 0.0549896 | 0.7468 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.00863775 | 0.05 | L3J_4_SAN_FECAL 3
3254759 | PLANTA BAIXA | 0.0341196 | 5.29289 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00267975 | 0.025 | L3J_4_SAN_FECAL 3
3254769 | PLANTA BAIXA | 0.0534172 | 5.2923 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0042625 | 0.0254 | L3J_4_SAN_FECAL 3
3254775 | PLANTA BAIXA | 0.944049 | 5.07177 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0741455 | 0.025 | L3J_4_SAN_FECAL 3
3255049 | PLANTA BAIXA | 1.01469 | 4.81452 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0796933 | 0.025 | L3J_4_SAN_FECAL 3
3285533 | PLANTA BAIXA | 0.0138614 | 5.09374 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00108867 | 0.025 | L3J_4_SAN_FECAL 3
3285937 | PLANTA BAIXA | 1.23759 | 4.90084 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0972003 | 0.025 | L3J_4_SAN_FECAL 3
3285939 | PLANTA BAIXA | 0.0937773 | 4.968 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00736525 | 0.025 | L3J_4_SAN_FECAL 3
3286077 | PLANTA BAIXA | 0.312783 | 5.18051 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0245659 | 0.025 | L3J_4_SAN_FECAL 3
3294536 | PLANTA BAIXA | 1.37399 | -1.10399 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.474818 | 0.11 | L3J_4_SAN_FECAL 3
3364200 | PLANTA BAIXA | 1.50446 | -0.878612 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.236321 | 0.05 | L3J_4_SAN_FECAL 3
3364202 | PLANTA BAIXA | 0.0739532 | 0.666946 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.0116165 | 0.05 | L3J_4_SAN_FECAL 3
3455120 | PLANTA BAIXA | 0.0274544 | 5.15736 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00215626 | 0.025 | L3J_4_SAN_FECAL 3
3455776 | PLANTA BAIXA | 0.92123 | 5.14741 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0723532 | 0.025 | L3J_4_SAN_FECAL 3
3455777 | PLANTA BAIXA | 0.321308 | 4.79361 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0252355 | 0.025 | L3J_4_SAN_FECAL 3
3490198 | PLANTA BAIXA | 0.181337 | 4.88568 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0142422 | 0.025 | L3J_4_SAN_FECAL 3
3490870 | PLANTA BAIXA | 0.957846 | 4.87593 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.075229 | 0.025 | L3J_4_SAN_FECAL 3
3490871 | PLANTA BAIXA | 0.0579832 | 4.8755 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00455399 | 0.025 | L3J_4_SAN_FECAL 3
3491800 | PLANTA BAIXA | 0.00270277 | 4.88298 | PLANTA BAIXA | Nau Santa Eulalia | 32 mmø | 0.000271712 | 0.032 | L3J_4_SAN_FECAL 3
3491980 | PLANTA BAIXA | 0.0530412 | 4.80089 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00416585 | 0.025 | L3J_4_SAN_FECAL 3
3493074 | PLANTA BAIXA | 0.0382693 | 5.13601 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00300567 | 0.025 | L3J_4_SAN_FECAL 3
3675343 | PLANTA BAIXA | 1.49401 | -0.958304 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.516292 | 0.11 | L3J_4_SAN_FECAL 3
3675774 | PLANTA BAIXA | 1.04084 | -0.850849 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.35969 | 0.11 | L3J_4_SAN_FECAL 3
3676947 | PLANTA BAIXA | 0.573397 | -1.30994 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.225173 | 0.125 | L3J_4_SAN_FECAL 3
3677207 | PLANTA BAIXA | 0.782908 | -1.37623 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.307447 | 0.125 | L3J_4_SAN_FECAL 3
3677755 | PLANTA BAIXA | 1.05894 | -1.35534 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.415843 | 0.125 | L3J_4_SAN_FECAL 3
3678798 | PLANTA BAIXA | 0.350411 | 4.7206 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0275212 | 0.025 | L3J_4_SAN_FECAL 3
3678809 | PLANTA BAIXA | 2.54874 | 4.72063 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.200178 | 0.025 | L3J_4_SAN_FECAL 3
3678813 | PLANTA BAIXA | 0.593174 | 4.72978 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0465878 | 0.025 | L3J_4_SAN_FECAL 3
3679047 | PLANTA BAIXA | 0.054184 | 4.83166 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0042556 | 0.025 | L3J_4_SAN_FECAL 3
3679203 | PLANTA BAIXA | 7.70327 | 4.62951 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 1.21003 | 0.05 | L3J_4_SAN_FECAL 3
3679215 | PLANTA BAIXA | 0.144511 | 4.62698 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.0226998 | 0.05 | L3J_4_SAN_FECAL 3
3679566 | PLANTA BAIXA | 0.0321565 | 4.64018 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00252557 | 0.025 | L3J_4_SAN_FECAL 3
3679881 | PLANTA BAIXA | 0.0808374 | 4.69529 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00634895 | 0.025 | L3J_4_SAN_FECAL 3
3679893 | PLANTA BAIXA | 0.0766459 | 4.62701 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.0120395 | 0.05 | L3J_4_SAN_FECAL 3
3680079 | PLANTA BAIXA | 0.322559 | 4.62209 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.0506675 | 0.05 | L3J_4_SAN_FECAL 3
3680089 | PLANTA BAIXA | 1.38035 | -1.25864 | PLANTA BAIXA | Nau Santa Eulalia | 90 mmø | 0.390286 | 0.09 | L3J_4_SAN_FECAL 3
3680291 | PLANTA BAIXA | 5.57863 | -0.99792 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.876289 | 0.05 | L3J_4_SAN_FECAL 3
3680299 | PLANTA BAIXA | 2.25358 | -1.30527 | PLANTA BAIXA | Nau Santa Eulalia | 90 mmø | 0.637184 | 0.09 | L3J_4_SAN_FECAL 3
3682264 | PLANTA BAIXA | 0.137714 | 0.674321 | PLANTA BAIXA | Annex | 125 mmø | 0.0540803 | 0.125 | L3J_4_SAN_FECAL 3
3682454 | PLANTA BAIXA | 0.0486998 | 1.0023 | PLANTA BAIXA | Annex | 125 mmø | 0.0191244 | 0.125 | L3J_4_SAN_FECAL 3
3682806 | PLANTA BAIXA | 0.837894 | -0.310202 | PLANTA BAIXA | Capella | 125 mmø | 0.32904 | 0.125 | L3J_4_SAN_FECAL 3
3683138 | PLANTA BAIXA | 0.335053 | 0.85211 | PLANTA BAIXA | Annex | 40 mmø | 0.0421041 | 0.04 | L3J_4_SAN_FECAL 3
3683156 | PLANTA BAIXA | 1.0231 | -0.307039 | PLANTA BAIXA | Capella | 90 mmø | 0.289275 | 0.09 | L3J_4_SAN_FECAL 3
3683878 | PLANTA BAIXA | 0.394305 | -0.525106 | PLANTA BAIXA | Capella | 125 mmø | 0.154843 | 0.125 | L3J_4_SAN_FECAL 3
3683882 | PLANTA BAIXA | 0.928955 | -0.505891 | PLANTA BAIXA | Capella | 90 mmø | 0.262656 | 0.09 | L3J_4_SAN_FECAL 3
3683888 | PLANTA BAIXA | 0.131507 | -0.484452 | PLANTA BAIXA | Capella | 90 mmø | 0.0371826 | 0.09 | L3J_4_SAN_FECAL 3
3683898 | PLANTA BAIXA | 0.824823 | -0.478468 | PLANTA BAIXA | Capella | 90 mmø | 0.233213 | 0.09 | L3J_4_SAN_FECAL 3
3684008 | PLANTA BAIXA | 4.03527 | -0.612593 | PLANTA BAIXA |  | 125 mmø | 1.58465 | 0.125 | L3J_4_SAN_FECAL 3
3684912 | PLANTA BAIXA | 0.0749342 | -1.32706 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.0294266 | 0.125 | L3J_4_SAN_FECAL 3
3684923 | PLANTA BAIXA | 0.621822 | -1.32679 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.244189 | 0.125 | L3J_4_SAN_FECAL 3
3684926 | PLANTA BAIXA | 0.589538 | -1.32115 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.231511 | 0.125 | L3J_4_SAN_FECAL 3
3684936 | PLANTA BAIXA | 0.445939 | -1.30494 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.17512 | 0.125 | L3J_4_SAN_FECAL 3
3685855 | PLANTA BAIXA | 0.0564614 | -1.18322 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.0195117 | 0.11 | L3J_4_SAN_FECAL 3
3685967 | PLANTA BAIXA | 0.107513 | -1.20831 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.0422201 | 0.125 | L3J_4_SAN_FECAL 3
3685976 | PLANTA BAIXA | 0.314136 | -1.22197 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.123361 | 0.125 | L3J_4_SAN_FECAL 3
3685981 | PLANTA BAIXA | 0.517094 | -1.20174 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.203062 | 0.125 | L3J_4_SAN_FECAL 3
3686111 | PLANTA BAIXA | 0.168642 | -1.17652 | PLANTA BAIXA | Nau Santa Eulalia | 90 mmø | 0.0476824 | 0.09 | L3J_4_SAN_FECAL 3
3686120 | PLANTA BAIXA | 0.384065 | -1.20831 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.150822 | 0.125 | L3J_4_SAN_FECAL 3
3686125 | PLANTA BAIXA | 1.7798 | -1.16979 | PLANTA BAIXA | Nau Santa Eulalia | 90 mmø | 0.503228 | 0.09 | L3J_4_SAN_FECAL 3
3686135 | PLANTA BAIXA | 0.240279 | -1.13085 | PLANTA BAIXA | Nau Santa Eulalia | 90 mmø | 0.0679374 | 0.09 | L3J_4_SAN_FECAL 3
3686229 | PLANTA BAIXA | 0.234125 | -1.17812 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.0809079 | 0.11 | L3J_4_SAN_FECAL 3
3686241 | PLANTA BAIXA | 0.491123 | -1.16948 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.16972 | 0.11 | L3J_4_SAN_FECAL 3
3686251 | PLANTA BAIXA | 0.234998 | -1.15309 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.0812095 | 0.11 | L3J_4_SAN_FECAL 3
3686609 | PLANTA BAIXA | 0.0706952 | -1.14443 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.0244305 | 0.11 | L3J_4_SAN_FECAL 3
3687567 | PLANTA BAIXA | 0.199952 | -1.15309 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.0690983 | 0.11 | L3J_4_SAN_FECAL 3
3687592 | PLANTA BAIXA | 1.83455 | -0.96438 | PLANTA BAIXA | Nau Santa Eulalia | 110 mmø | 0.633975 | 0.11 | L3J_4_SAN_FECAL 3
3689322 | PLANTA BAIXA | 0.169372 | -0.86816 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.0665122 | 0.125 | L3J_4_SAN_FECAL 3
3689328 | PLANTA BAIXA | 0.473492 | -0.860349 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.18594 | 0.125 | L3J_4_SAN_FECAL 3
3689378 | PLANTA BAIXA | 0.911462 | -0.641493 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.35793 | 0.125 | L3J_4_SAN_FECAL 3
3690439 | PLANTA BAIXA | 0.0535858 | -0.846706 | PLANTA BAIXA | Nau Santa Eulalia | 90 mmø | 0.015151 | 0.09 | L3J_4_SAN_FECAL 3
3690529 | PLANTA BAIXA | 0.0293802 | -0.840074 | PLANTA BAIXA | Nau Santa Eulalia | 90 mmø | 0.00830705 | 0.09 | L3J_4_SAN_FECAL 3
3690551 | PLANTA BAIXA | 0.174613 | -0.836132 | PLANTA BAIXA | Nau Santa Eulalia | 90 mmø | 0.0493708 | 0.09 | L3J_4_SAN_FECAL 3
3690557 | PLANTA BAIXA | 0.427369 | -0.828199 | PLANTA BAIXA | Nau Santa Eulalia | 90 mmø | 0.120836 | 0.09 | L3J_4_SAN_FECAL 3
3691495 | PLANTA BAIXA | 0.35656 | 4.7154 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0280041 | 0.025 | L3J_4_SAN_FECAL 3
3691506 | PLANTA BAIXA | 2.37665 | 4.71517 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.186661 | 0.025 | L3J_4_SAN_FECAL 3
3691931 | PLANTA BAIXA | 0.0825619 | 5.06599 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0064844 | 0.025 | L3J_4_SAN_FECAL 3
3691932 | PLANTA BAIXA | 0.510224 | 4.74077 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0400729 | 0.025 | L3J_4_SAN_FECAL 3
3691933 | PLANTA BAIXA | 0.0858573 | 4.71971 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00674322 | 0.025 | L3J_4_SAN_FECAL 3
3692242 | PLANTA BAIXA | 6.28408 | 4.64784 | PLANTA BAIXA | Nau Santa Eulalia | 32 mmø | 0.631745 | 0.032 | L3J_4_SAN_FECAL 3
3692655 | PLANTA BAIXA | 0.278259 | 4.81769 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0218544 | 0.025 | L3J_4_SAN_FECAL 3
3692656 | PLANTA BAIXA | 0.26356 | 4.67509 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0206999 | 0.025 | L3J_4_SAN_FECAL 3
3692657 | PLANTA BAIXA | 0.490934 | 4.65088 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0385579 | 0.025 | L3J_4_SAN_FECAL 3
3693216 | PLANTA BAIXA | 10.2158 | 4.54442 | PLANTA BAIXA | Nau Santa Eulalia | 32 mmø | 1.02701 | 0.032 | L3J_4_SAN_FECAL 3
3694360 | PLANTA BAIXA | 5.06915 | -0.582991 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.796261 | 0.05 | L3J_4_SAN_FECAL 3
3694362 | PLANTA BAIXA | 0.281478 | 4.54072 | PLANTA BAIXA | Nau Santa Eulalia | 32 mmø | 0.0282972 | 0.032 | L3J_4_SAN_FECAL 3
3694364 | PLANTA BAIXA | 0.196298 | 4.52755 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.0308344 | 0.05 | L3J_4_SAN_FECAL 3
3694372 | PLANTA BAIXA | 0.0378668 | 4.54072 | PLANTA BAIXA | Nau Santa Eulalia | 32 mmø | 0.00380678 | 0.032 | L3J_4_SAN_FECAL 3
3694696 | PLANTA BAIXA | 0.190399 | 4.61356 | PLANTA BAIXA | Nau Santa Eulalia | 32 mmø | 0.019141 | 0.032 | L3J_4_SAN_FECAL 3
3695046 | PLANTA BAIXA | 0.153897 | 5.13404 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.012087 | 0.025 | L3J_4_SAN_FECAL 3
3695047 | PLANTA BAIXA | 0.139978 | 4.96188 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0109938 | 0.025 | L3J_4_SAN_FECAL 3
3695048 | PLANTA BAIXA | 1.10043 | 4.84802 | PLANTA BAIXA | Nau Santa Eulalia | 32 mmø | 0.110628 | 0.032 | L3J_4_SAN_FECAL 3
3764430 | PLANTA BAIXA | 0.0435001 | 5.21753 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00341649 | 0.025 | L3J_4_SAN_FECAL 3
3764518 | PLANTA BAIXA | 0.156623 | 5.02895 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0123011 | 0.025 | L3J_4_SAN_FECAL 3
3766562 | PLANTA COBERTA | 1.92072 | 4.95496 | PLANTA COBERTA | Nau Santa Eulalia | 25 mmø | 0.150853 | 0.025 | L3J_4_SAN_FECAL 3
3766563 | PLANTA COBERTA | 0.0327979 | 4.95434 | PLANTA COBERTA | Nau Santa Eulalia | 25 mmø | 0.00257594 | 0.025 | L3J_4_SAN_FECAL 3
3766564 | PLANTA COBERTA | 0.191132 | 4.87716 | PLANTA COBERTA | Nau Santa Eulalia | 25 mmø | 0.0150115 | 0.025 | L3J_4_SAN_FECAL 3
3766565 | PLANTA BAIXA | 0.0278117 | 4.86334 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00218432 | 0.025 | L3J_4_SAN_FECAL 3
3766900 | PLANTA BAIXA | 0.0569273 | 3.07001 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00447106 | 0.025 | L3J_4_SAN_FECAL 3
3767052 | PLANTA COBERTA | 0.0337332 | 3.07137 | PLANTA COBERTA | Nau Santa Eulalia | 25 mmø | 0.0026494 | 0.025 | L3J_4_SAN_FECAL 3
3767067 | PLANTA COBERTA | 0.232701 | 3.07101 | PLANTA COBERTA | Nau Santa Eulalia | 25 mmø | 0.0182763 | 0.025 | L3J_4_SAN_FECAL 3
3767219 | PLANTA COBERTA | 1.95264 | 3.03952 | PLANTA COBERTA | Nau Santa Eulalia | 25 mmø | 0.15336 | 0.025 | L3J_4_SAN_FECAL 3
3767227 | PLANTA COBERTA | 0.788291 | 3.03053 | PLANTA COBERTA | Nau Santa Eulalia | 25 mmø | 0.0619122 | 0.025 | L3J_4_SAN_FECAL 3
3767311 | PLANTA BAIXA | 2.19785 | 0.800496 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.172619 | 0.025 | L3J_4_SAN_FECAL 3
3785875 | PLANTA BAIXA | 0.780531 | -1.34014 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.306514 | 0.125 | L3J_4_SAN_FECAL 3
3821807 | PLANTA COBERTA | 20.2675 | -1.02919 | PLANTA COBERTA |  | 125 mmø | 7.95902 | 0.125 | L3J_4_SAN_FECAL 3
3823599 | PLANTA COBERTA | 0.394063 | -1.08207 | PLANTA COBERTA |  | 200 mmø | 0.247597 | 0.2 | L3J_4_SAN_FECAL 3
3823937 | PLANTA BAIXA | 1.30155 | -0.638385 | PLANTA BAIXA |  | 200 mmø | 0.81779 | 0.2 | L3J_4_SAN_FECAL 3
3824221 | PLANTA COBERTA | 0.816331 | -1.00969 | PLANTA COBERTA |  | 200 mmø | 0.512916 | 0.2 | L3J_4_SAN_FECAL 3
3824582 | PLANTA BAIXA | 0.0446113 | -0.614485 | PLANTA BAIXA |  | 160 mmø | 0.0224241 | 0.16 | L3J_4_SAN_FECAL 3
3866434 | PLANTA BAIXA | 0.13402 | 5.29063 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.0105259 | 0.025 | L3J_4_SAN_FECAL 3
3868675 | PLANTA BAIXA | 0.1224 | 5.13598 | PLANTA BAIXA | Nau Santa Eulalia | 25 mmø | 0.00961325 | 0.025 | L3J_4_SAN_FECAL 3
4560110 | PLANTA BAIXA | 4.43683 | -1.44982 | PLANTA BAIXA |  | 125 mmø | 1.74234 | 0.125 | L3J_4_SAN_FECAL 3
4560403 | PLANTA BAIXA | 5.50001 | -1.72715 | PLANTA BAIXA |  | 200 mmø | 3.45576 | 0.2 | L3J_4_SAN_FECAL 3
4560522 | PLANTA BAIXA | 1.22473 | -1.46516 | PLANTA BAIXA |  | 125 mmø | 0.480952 | 0.125 | L3J_4_SAN_FECAL 3
4560536 | PLANTA BAIXA | 1.85141 | -1.55394 | PLANTA BAIXA |  | 125 mmø | 0.727047 | 0.125 | L3J_4_SAN_FECAL 3
5057254 | PLANTA COBERTA | 1.57446 | -1.08388 | PLANTA COBERTA |  | 200 mmø | 0.989261 | 0.2 | L3J_4_SAN_FECAL 3
5058555 | PLANTA COBERTA | 2.47492 | -1.05307 | PLANTA COBERTA |  | 160 mmø | 1.24403 | 0.16 | L3J_4_SAN_FECAL 3
5059215 | PLANTA BAIXA | 1.59638 | -1.01271 | PLANTA BAIXA |  | 160 mmø | 0.802427 | 0.16 | L3J_4_SAN_FECAL 3
5059299 | PLANTA COBERTA | 0.247383 | -1.08357 | PLANTA COBERTA |  | 200 mmø | 0.155435 | 0.2 | L3J_4_SAN_FECAL 3
5059554 | PLANTA BAIXA | 0.194146 | -0.877178 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.076241 | 0.125 | L3J_4_SAN_FECAL 3
5060093 | PLANTA BAIXA | 5.05514 | -1.60575 | PLANTA BAIXA |  | 200 mmø | 3.17624 | 0.2 | L3J_4_SAN_FECAL 3
5060343 | PLANTA BAIXA | 19.7808 | -1.49309 | PLANTA BAIXA |  | 200 mmø | 12.4286 | 0.2 | L3J_4_SAN_FECAL 3
5060384 | PLANTA BAIXA | 0.133359 | -1.56102 | PLANTA BAIXA |  | 125 mmø | 0.0523699 | 0.125 | L3J_4_SAN_FECAL 3
5117657 | PLANTA BAIXA | 0.365725 | -1.35319 | PLANTA BAIXA | Nau Santa Eulalia | 125 mmø | 0.14362 | 0.125 | L3J_4_SAN_FECAL 3
5117944 | PLANTA COBERTA | 0.408456 | -0.47195 | PLANTA COBERTA | Nau Santa Eulalia | 50 mmø | 0.0641601 | 0.05 | L3J_4_SAN_FECAL 3
5117945 | PLANTA COBERTA | 0.482901 | -0.481278 | PLANTA COBERTA | Nau Santa Eulalia | 50 mmø | 0.075854 | 0.05 | L3J_4_SAN_FECAL 3
5117946 | PLANTA BAIXA | 0.492285 | -1.01511 | PLANTA BAIXA | Nau Santa Eulalia | 50 mmø | 0.0773279 | 0.05 | L3J_4_SAN_FECAL 3
5209032 | PLANTA BAIXA | 0.378143 | 2.85127 | PLANTA BAIXA | Nau Lateral Sud | 25 mmø | 0.0296993 | 0.025 | L3J_4_SAN_FECAL 1
5209408 | PLANTA BAIXA | 0.172191 | 3.14594 | PLANTA BAIXA | Nau Lateral Sud | 25 mmø | 0.0135238 | 0.025 | L3J_4_SAN_FECAL 1
5213347 | PLANTA BAIXA | 4.69344 | -0.840074 | PLANTA BAIXA | Nau Santa Eulalia | 90 mmø | 1.32704 | 0.09 | L3J_4_SAN_FECAL 3
5213428 | PLANTA BAIXA | 1.4675 | -1.43493 | PLANTA BAIXA |  | 125 mmø | 0.576287 | 0.125 | L3J_4_SAN_FECAL 3
5213439 | PLANTA BAIXA | 2.63304 | -1.4333 | PLANTA BAIXA |  | 125 mmø | 1.03399 | 0.125 | L3J_4_SAN_FECAL 3
5213442 | PLANTA BAIXA | 0.52247 | -1.40116 | PLANTA BAIXA |  | 125 mmø | 0.205173 | 0.125 | L3J_4_SAN_FECAL 3
5213504 | PLANTA BAIXA | 1.1657 | -1.1837 | PLANTA BAIXA |  | 125 mmø | 0.457768 | 0.125 | L3J_4_SAN_FECAL 3
5213690 | PLANTA BAIXA | 1.3451 | -1.46516 | PLANTA BAIXA |  | 125 mmø | 0.528221 | 0.125 | L3J_4_SAN_FECAL 3
5213727 | PLANTA BAIXA | 1.21324 | -1.23124 | PLANTA BAIXA |  | 125 mmø | 0.476439 | 0.125 | L3J_4_SAN_FECAL 3
5213751 | PLANTA BAIXA | 5.17093 | -1.51117 | PLANTA BAIXA |  | 125 mmø | 2.03062 | 0.125 | L3J_4_SAN_FECAL 3
5213764 | PLANTA BAIXA | 1.85064 | -1.50954 | PLANTA BAIXA |  | 125 mmø | 0.726743 | 0.125 | L3J_4_SAN_FECAL 3
5213830 | PLANTA BAIXA | 1.20076 | -1.20076 | PLANTA BAIXA |  | 125 mmø | 0.471535 | 0.125 | L3J_4_SAN_FECAL 3
5213895 | PLANTA BAIXA | 2.67098 | -1.35373 | PLANTA BAIXA |  | 125 mmø | 1.04889 | 0.125 | L3J_4_SAN_FECAL 3
5213904 | PLANTA BAIXA | 2.08477 | -1.35373 | PLANTA BAIXA |  | 125 mmø | 0.818688 | 0.125 | L3J_4_SAN_FECAL 3
5214016 | PLANTA BAIXA | 1.0753 | -1.0933 | PLANTA BAIXA |  | 125 mmø | 0.422268 | 0.125 | L3J_4_SAN_FECAL 3
5214082 | PLANTA BAIXA | 2.25934 | -1.30715 | PLANTA BAIXA |  | 125 mmø | 0.88724 | 0.125 | L3J_4_SAN_FECAL 3
5214093 | PLANTA BAIXA | 3.91476 | -1.30466 | PLANTA BAIXA |  | 125 mmø | 1.53732 | 0.125 | L3J_4_SAN_FECAL 3
5214096 | PLANTA BAIXA | 1.47121 | -1.25614 | PLANTA BAIXA |  | 125 mmø | 0.577741 | 0.125 | L3J_4_SAN_FECAL 3
5214150 | PLANTA BAIXA | 1.00967 | -1.01971 | PLANTA BAIXA |  | 125 mmø | 0.396498 | 0.125 | L3J_4_SAN_FECAL 3
5214418 | PLANTA BAIXA | 3.72694 | -1.25459 | PLANTA BAIXA |  | 125 mmø | 1.46357 | 0.125 | L3J_4_SAN_FECAL 3
5214442 | PLANTA BAIXA | 1.17335 | -1.17196 | PLANTA BAIXA |  | 125 mmø | 0.460772 | 0.125 | L3J_4_SAN_FECAL 3
5214478 | PLANTA BAIXA | 0.923478 | -0.941482 | PLANTA BAIXA |  | 125 mmø | 0.362649 | 0.125 | L3J_4_SAN_FECAL 3
5214511 | PLANTA BAIXA | 3.85804 | -1.17436 | PLANTA BAIXA |  | 125 mmø | 1.51505 | 0.125 | L3J_4_SAN_FECAL 3
5214529 | PLANTA BAIXA | 1.17284 | -1.09151 | PLANTA BAIXA |  | 125 mmø | 0.460575 | 0.125 | L3J_4_SAN_FECAL 3
5214602 | PLANTA BAIXA | 0.843032 | -0.861042 | PLANTA BAIXA |  | 125 mmø | 0.331058 | 0.125 | L3J_4_SAN_FECAL 3
5214748 | PLANTA BAIXA | 2.14306 | -0.973898 | PLANTA BAIXA |  | 160 mmø | 1.07722 | 0.16 | L3J_4_SAN_FECAL 3
5214765 | PLANTA BAIXA | 0.174279 | -0.973898 | PLANTA BAIXA |  | 160 mmø | 0.0876021 | 0.16 | L3J_4_SAN_FECAL 3
5214768 | PLANTA BAIXA | 4.12483 | -0.641495 | PLANTA BAIXA |  | 160 mmø | 2.07336 | 0.16 | L3J_4_SAN_FECAL 3
5214841 | PLANTA BAIXA | 0.550237 | -0.553537 | PLANTA BAIXA |  | 160 mmø | 0.276579 | 0.16 | L3J_4_SAN_FECAL 3
5214888 | PLANTA BAIXA | 0.264867 | -0.282871 | PLANTA BAIXA |  | 160 mmø | 0.133136 | 0.16 | L3J_4_SAN_FECAL 3
5214909 | PLANTA BAIXA | 0.373166 | -0.641495 | PLANTA BAIXA |  | 160 mmø | 0.187574 | 0.16 | L3J_4_SAN_FECAL 3
5214920 | PLANTA BAIXA | 3.74354 | -0.723712 | PLANTA BAIXA |  | 160 mmø | 1.88171 | 0.16 | L3J_4_SAN_FECAL 3
5215003 | PLANTA BAIXA | 0.356813 | -0.374817 | PLANTA BAIXA |  | 160 mmø | 0.179354 | 0.16 | L3J_4_SAN_FECAL 3
5215063 | PLANTA BAIXA | 0.356542 | -0.723712 | PLANTA BAIXA |  | 160 mmø | 0.179217 | 0.16 | L3J_4_SAN_FECAL 3
5215076 | PLANTA BAIXA | 4.0129 | -0.811315 | PLANTA BAIXA |  | 160 mmø | 2.0171 | 0.16 | L3J_4_SAN_FECAL 3
5215124 | PLANTA BAIXA | 0.439379 | -0.457382 | PLANTA BAIXA |  | 160 mmø | 0.220856 | 0.16 | L3J_4_SAN_FECAL 3
5215149 | PLANTA BAIXA | 0.336538 | -0.811315 | PLANTA BAIXA |  | 160 mmø | 0.169162 | 0.16 | L3J_4_SAN_FECAL 3
5215158 | PLANTA BAIXA | 4.19109 | -0.902481 | PLANTA BAIXA |  | 160 mmø | 2.10667 | 0.16 | L3J_4_SAN_FECAL 3
5215198 | PLANTA BAIXA | 0.527382 | -0.545385 | PLANTA BAIXA |  | 160 mmø | 0.265091 | 0.16 | L3J_4_SAN_FECAL 3
5215222 | PLANTA BAIXA | 0.389307 | -0.901878 | PLANTA BAIXA |  | 160 mmø | 0.195687 | 0.16 | L3J_4_SAN_FECAL 3
5215233 | PLANTA BAIXA | 0.691676 | -0.925563 | PLANTA BAIXA |  | 160 mmø | 0.347674 | 0.16 | L3J_4_SAN_FECAL 3
5215289 | PLANTA BAIXA | 0.616894 | -0.634896 | PLANTA BAIXA |  | 160 mmø | 0.310085 | 0.16 | L3J_4_SAN_FECAL 3
5215312 | PLANTA BAIXA | 1.99876 | -0.961162 | PLANTA BAIXA |  | 160 mmø | 1.00469 | 0.16 | L3J_4_SAN_FECAL 3
5215321 | PLANTA BAIXA | 3.19629 | -0.961162 | PLANTA BAIXA |  | 160 mmø | 1.60663 | 0.16 | L3J_4_SAN_FECAL 3
5215381 | PLANTA BAIXA | 0.65196 | -0.661995 | PLANTA BAIXA |  | 160 mmø | 0.327711 | 0.16 | L3J_4_SAN_FECAL 3

# IfcFlowSegment: Pipe Types:L3J_XARXA_BIES (9)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.50.10.50; 105.AMB.ClassificacioDescripcio: Canalitzacions d'extinció d'incendis; 109.AMB.CodiTipus: PCI-CBIE
Classification: 50.50.10.50 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Pipe Types:L3J_XARXA_BIES; sets with these values: 2
Pset_DuctConnection - ConnectionType: Generic; sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_XARXA_BIES; 112.AMB.Servei: L3J_6_PCI - HUMIDA; 119.AMB.FaseCreacio: Obra
2 AMB.Caracteristiques - 242.AMB.Mida: 40 mmø
5 AMB.Geometria - 505.AMB.Diametre: 0.04 m
Name (Pipe Types:L3J_XARXA_BIES:...) | In | Pset_FlowSegmentDuctSegment, Length (m) = Pset_FlowSegmentPipeSegment, Length (m) = 501.AMB.Longitud (m) | InvertElevation (m) | 115.AMB.Nivell | 117.AMB.Localitzacio | 507.AMB.Area (m2) | Group
3903444 | PLANTA BAIXA | 0.0384187 | 1.57767 | PLANTA BAIXA | Nau Santa Eulalia | 0.00482784 | L3J_6_PCI - HUMIDA 1
3903461 | PLANTA BAIXA | 3.12603 | 1.62586 | PLANTA BAIXA | Nau Santa Eulalia | 0.392828 | L3J_6_PCI - HUMIDA 1
3903710 | PLANTA BAIXA | 0.0730125 | 1.57767 | PLANTA BAIXA | Nau Santa Eulalia | 0.00917502 | L3J_6_PCI - HUMIDA 2
3903722 | PLANTA BAIXA | 3.33301 | 1.62586 | PLANTA BAIXA | Nau Santa Eulalia | 0.418839 | L3J_6_PCI - HUMIDA 2
3903944 | PLANTA BAIXA | 0.953012 | 4.75767 | PLANTA BAIXA | Nau Santa Eulalia | 0.119759 | L3J_6_PCI - HUMIDA 1
3904221 | P0_NL | 0.110468 | 2.94973 | P0_NL | Nau Lateral Sud | 0.0138819 | L3J_6_PCI - HUMIDA 3
3904445 | P0_NL | 2.26666 | 0.670928 | P0_NL | Nau Lateral Sud | 0.284837 | L3J_6_PCI - HUMIDA 3
3904555 | P0_NL | 4.933 | 3.00427 | P0_NL | Nau Lateral Sud | 0.619899 | L3J_6_PCI - HUMIDA 3
3904570 | P0_NL | 1.95301 | 7.94305 | P0_NL | Nau Lateral Sud | 0.245423 | L3J_6_PCI - HUMIDA 3

# IfcFlowSegment: Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_AP (50)
In: PLANTA BAIXA
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_AP; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_REC_CLIMA_FIBRA_AP; 112.AMB.Servei: L3J_3_VENT_APORT_AIRE; 115.AMB.Nivell: PLANTA BAIXA; 119.AMB.FaseCreacio: Obra
Name (Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_AP:...) | Length (m) = 501.AMB.Longitud (m) | 117.AMB.Localitzacio | 242.AMB.Mida | 502.AMB.Amplada (m) | 503.AMB.Altura (m) | 507.AMB.Area (m2) | Group
3410323 | 2.10427 | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 1.47299 | Mecánica L3J_3_VENT_APORT_AIRE 1
3448600 | 3.15464 | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 2.20825 | Mecánica L3J_3_VENT_APORT_AIRE 2
3458732 | 0.493603 | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 0.345522 | Mecánica L3J_3_VENT_APORT_AIRE 2
3458845 | 0.0324956 | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 0.0227469 | Mecánica L3J_3_VENT_APORT_AIRE 2
3459989 | 0.2461 | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 0.17227 | Mecánica L3J_3_VENT_APORT_AIRE 2
3470287 | 0.064265 | Nau Santa Eulalia | 150 mmx200 mm | 0.1 | 0.15 | 0.0321325 | Mecánica L3J_3_VENT_APORT_AIRE 3
3470739 | 9.39055 | Nau Santa Eulalia | 200 mmx150 mm | 0.15 | 0.1 | 4.69527 | Mecánica L3J_3_VENT_APORT_AIRE 3
3470898 | 0.290382 | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.290382 | Mecánica L3J_3_VENT_APORT_AIRE 3
3471009 | 0.50742 | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.50742 | Mecánica L3J_3_VENT_APORT_AIRE 3
3471355 | 0.507437 | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.507437 | Mecánica L3J_3_VENT_APORT_AIRE 3
3471431 | 6.1878 | Nau Santa Eulalia | 300 mmx250 mm | 0.25 | 0.2 | 5.56902 | Mecánica L3J_3_VENT_APORT_AIRE 3
3471634 | 0.021412 | Nau Santa Eulalia | 400 mmx250 mm | 0.35 | 0.2 | 0.0235532 | Mecánica L3J_3_VENT_APORT_AIRE 3
3471643 | 0.0586881 | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.0586881 | Mecánica L3J_3_VENT_APORT_AIRE 3
3482423 | 0.0110758 | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.0110758 | Mecánica L3J_3_VENT_APORT_AIRE 3
3482430 | 0.557718 | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.557718 | Mecánica L3J_3_VENT_APORT_AIRE 3
3485574 | 0.0553252 | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.0553252 | Mecánica L3J_3_VENT_APORT_AIRE 3
3485589 | 0.028065 | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.028065 | Mecánica L3J_3_VENT_APORT_AIRE 3
3485995 | 0.0471435 | Nau Santa Eulalia | 200 mmx150 mm | 0.15 | 0.1 | 0.0235718 | Mecánica L3J_3_VENT_APORT_AIRE 7
3486003 | 0.352218 | Nau Santa Eulalia | 200 mmx150 mm | 0.15 | 0.1 | 0.176109 | Mecánica L3J_3_VENT_APORT_AIRE 7
3513796 | 10.7239 | Nau Santa Eulalia | 300 mmx250 mm | 0.25 | 0.2 | 9.65152 | Mecánica L3J_3_VENT_APORT_AIRE 2
3513996 | 0.311015 | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.186609 | Mecánica L3J_3_VENT_APORT_AIRE 2
3514029 | 0.0320925 | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.0192555 | Mecánica L3J_3_VENT_APORT_AIRE 2
3514039 | 0.296411 | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.177847 | Mecánica L3J_3_VENT_APORT_AIRE 2
3514376 | 0.165749 | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 0.116024 | Mecánica L3J_3_VENT_APORT_AIRE 2
3515324 | 0.00898817 | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 0.00629172 | Mecánica L3J_3_VENT_APORT_AIRE 2
3515732 | 0.0704304 | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 0.0493013 | Mecánica L3J_3_VENT_APORT_AIRE 2
3515799 | 0.041033 | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 0.0287231 | Mecánica L3J_3_VENT_APORT_AIRE 2
3515800 | 0.279762 | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 0.195834 | Mecánica L3J_3_VENT_APORT_AIRE 2
3528863 | 1.06 | Nau Lateral Sud | 350 mmx350 mm | 0.3 | 0.3 | 1.272 | Mecánica L3J_3_VENT_APORT_AIRE 1
3638437 | 0.281592 | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 0.197114 | Mecánica L3J_3_VENT_APORT_AIRE 1
3638438 | 0.26677 | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 0.186739 | Mecánica L3J_3_VENT_APORT_AIRE 1
3638439 | 1.5186 | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 1.06302 | Mecánica L3J_3_VENT_APORT_AIRE 1
3639110 | 0.306247 | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 0.214373 | Mecánica L3J_3_VENT_APORT_AIRE 1
3639112 | 0.305382 | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 0.213768 | Mecánica L3J_3_VENT_APORT_AIRE 1
3641958 | 1.06286 | Nau Lateral Sud | 350 mmx350 mm | 0.3 | 0.3 | 1.27543 | Mecánica L3J_3_VENT_APORT_AIRE 1
3656906 | 0.902151 | Nau Lateral Sud | 350 mmx250 mm | 0.3 | 0.2 | 0.902151 | Mecánica L3J_3_VENT_APORT_AIRE 1
3656920 | 0.775017 | Nau Lateral Sud | 350 mmx350 mm | 0.3 | 0.3 | 0.93002 | Mecánica L3J_3_VENT_APORT_AIRE 1
3656933 | 0.612924 | Nau Lateral Sud | 350 mmx250 mm | 0.3 | 0.2 | 0.612924 | Mecánica L3J_3_VENT_APORT_AIRE 1
3657114 | 3.16526 | Nau Lateral Sud | 350 mmx250 mm | 0.3 | 0.2 | 3.16526 | Mecánica L3J_3_VENT_APORT_AIRE 1
3714058 | 3.53754 | Nau Santa Eulalia | 400 mmx250 mm | 0.35 | 0.2 | 3.89129 | Mecánica L3J_3_VENT_APORT_AIRE 3
3716613 | 0.130762 | Nau Santa Eulalia | 400 mmx250 mm | 0.35 | 0.2 | 0.143839 | Mecánica L3J_3_VENT_APORT_AIRE 3
3717195 | 0.397157 | Nau Santa Eulalia | 400 mmx250 mm | 0.35 | 0.2 | 0.436873 | Mecánica L3J_3_VENT_APORT_AIRE 3
3722746 | 0.306751 | Nau Santa Eulalia | 350 mmx350 mm | 0.3 | 0.3 | 0.368101 | Mecánica L3J_3_VENT_APORT_AIRE 2
3722780 | 0.284147 | Nau Santa Eulalia | 350 mmx350 mm | 0.3 | 0.3 | 0.340976 | Mecánica L3J_3_VENT_APORT_AIRE 2
3758750 | 4.23695 | Nau Santa Eulalia | 350 mmx350 mm | 0.3 | 0.3 | 5.08434 | Mecánica L3J_3_VENT_APORT_AIRE 2
3758836 | 0.103882 | Nau Santa Eulalia | 250 mmx300 mm | 0.2 | 0.25 | 0.0934934 | Mecánica L3J_3_VENT_APORT_AIRE 2
3763744 | 0.0805905 | Nau Santa Eulalia | 250 mmx300 mm | 0.2 | 0.25 | 0.0725315 | Mecánica L3J_3_VENT_APORT_AIRE 2
3763941 | 0.0676153 | Nau Santa Eulalia | 300 mmx600 mm | 0.25 | 0.55 | 0.108184 | Mecánica L3J_3_VENT_APORT_AIRE 2
3764228 | 0.777 | Nau Santa Eulalia | 350 mmx350 mm | 0.3 | 0.3 | 0.9324 | Mecánica L3J_3_VENT_APORT_AIRE 2
3867993 | 0.177353 | Nau Santa Eulalia | 300 mmx250 mm | 0.25 | 0.2 | 0.159617 | Mecánica L3J_3_VENT_APORT_AIRE 3

# IfcFlowSegment: Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_EXT (41)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.20; 105.AMB.ClassificacioDescripcio: Extracció de aire primari; 109.AMB.CodiTipus: CLI-RFI
Classification: 50.30.40.20 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_EXT; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_REC_CLIMA_FIBRA_EXT; 119.AMB.FaseCreacio: Obra
Name (Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_EXT:...) | In | Length (m) = 501.AMB.Longitud (m) | 112.AMB.Servei | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 502.AMB.Amplada (m) | 503.AMB.Altura (m) | 507.AMB.Area (m2) | Group
3040357 | PLANTA BAIXA | 0.447664 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx150 mm | 0.3 | 0.1 | 0.358131 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3144111 | PLANTA BAIXA | 5.08712 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 3.56098 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3146056 | PLANTA BAIXA | 5.08712 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 3.56098 | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
3148689 | PLANTA BAIXA | 5.08712 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx150 mm | 0.15 | 0.1 | 2.54356 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3154513 | PLANTA BAIXA | 5.08712 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 3.56098 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3154786 | PLANTA BAIXA | 0.41091 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx150 mm | 0.15 | 0.1 | 0.205455 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3163237 | PLANTA BAIXA | 0.112732 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm | 0.35 | 0.1 | 0.101459 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3163498 | PLANTA BAIXA | 0.213696 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx150 mm | 0.3 | 0.1 | 0.170957 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3163499 | PLANTA BAIXA | 5.62946 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 5.62946 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3163580 | PLANTA BAIXA | 4.92708 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm | 0.35 | 0.1 | 4.43437 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3163606 | PLANTA BAIXA | 3.97959 | L3J_3_VENT_RETORN_AIRE | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm | 0.35 | 0.1 | 3.58163 | Mecánica L3J_3_VENT_RETORN_AIRE 1
3165190 | PLANTA BAIXA | 4.92708 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx150 mm | 0.3 | 0.1 | 3.94166 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3342073 | PLANTA BAIXA | 6.06768 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Lateral Sud | 350 mmx250 mm | 0.3 | 0.2 | 6.06768 | Mechanical L3J_VENTILACIÓ_CTE_HS3 1
3342397 | PLANTA BAIXA | 6.78484 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Lateral Sud | 350 mmx250 mm | 0.3 | 0.2 | 6.78484 | Mechanical L3J_VENTILACIÓ_CTE_HS3 1
3446273 | PLANTA BAIXA | 2.71484 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx150 mm | 0.3 | 0.1 | 2.17187 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3446348 | PLANTA BAIXA | 4.99 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm | 0.35 | 0.1 | 4.491 | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
3446382 | PLANTA BAIXA | 0.0707785 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm | 0.35 | 0.1 | 0.0637006 | Mecánica L3J_VENTILACIÓ_CTE_HS3 10
3447552 | PLANTA BAIXA | 1.12875 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx150 mm | 0.3 | 0.1 | 0.903001 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3447642 | PLANTA BAIXA | 2.60043 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx150 mm | 0.3 | 0.1 | 2.08034 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3447843 | PLANTA BAIXA | 4.5007 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm | 0.35 | 0.1 | 4.05063 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3447844 | PLANTA BAIXA | 0.144944 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx150 mm | 0.3 | 0.1 | 0.115955 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3447845 | PLANTA BAIXA | 0.677633 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx150 mm | 0.3 | 0.1 | 0.542106 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3465660 | PLANTA BAIXA | 0.194878 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 0.136414 | Mecánica L3J_VENTILACIÓ_CTE_HS3 7
3465729 | PLANTA BAIXA | 0.0158905 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.00953431 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3465766 | PLANTA BAIXA | 4.14745 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx150 mm | 0.15 | 0.1 | 2.07372 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3466125 | PLANTA BAIXA | 2.52312 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 1.76619 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3466212 | PLANTA BAIXA | 0.0732652 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 0.0512856 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3466298 | PLANTA BAIXA | 7.80429 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx250 mm | 0.25 | 0.2 | 7.02386 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3466344 | PLANTA BAIXA | 3.87601 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 3.87601 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3466444 | PLANTA BAIXA | 0.0353363 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 0.0247354 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3466815 | PLANTA BAIXA | 5.08712 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 3.56098 | Mecánica L3J_VENTILACIÓ_CTE_HS3 9
3716559 | PLANTA BAIXA | 0.128473 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx250 mm | 0.35 | 0.2 | 0.14132 | Mecánica L3J_VENTILACIÓ_CTE_HS3 4
3721345 | PLANTA BAIXA | 6.60597 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx350 mm | 0.3 | 0.3 | 7.92717 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
3876777 | PLANTA BAIXA | 0.194144 | L3J_3_VENT_RETORN_AIRE | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm | 0.35 | 0.1 | 0.174729 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9; Mecánica L3J_VENTILACIÓ_CTE_HS3 14
3876880 | PLANTA BAIXA | 4.48754 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 4.48754 | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
4542066 | P0_NL | 0.427339 | L3J_3_VENTILACIÓ_CTE_HS3 | P0_NL | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 0.299137 | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
4542067 | PLANTA COBERTA | 2.58488 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA COBERTA | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 1.80942 | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
4542483 | PLANTA COBERTA | 0.305295 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA COBERTA | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 0.213706 | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
4542698 | PLANTA COBERTA | 3.23528 | L3J_3_VENTILACIÓ_CTE_HS3 | PLANTA COBERTA | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 2.26469 | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
4792846 | PLANTA BAIXA | 0.710051 | L3J_3_VENT_RETORN_AIRE | PLANTA BAIXA | Nau Santa Eulalia | 150 mmx400 mm | 0.1 | 0.35 | 0.639045 | Mecánica L3J_3_VENT_RETORN_AIRE 1
4792850 | PLANTA BAIXA | 0.162932 | L3J_3_VENT_RETORN_AIRE | PLANTA BAIXA | Nau Santa Eulalia | 400 mmx150 mm | 0.35 | 0.1 | 0.146639 | Mecánica L3J_3_VENT_RETORN_AIRE 1

# IfcFlowSegment: Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_IMP (63)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.10; 105.AMB.ClassificacioDescripcio: Aportació de aire primari; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.10 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_IMP; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_REC_CLIMA_FIBRA_IMP; 112.AMB.Servei: L3J_3_CLIMA_IMP_AIRE; 119.AMB.FaseCreacio: Obra
Name (Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_IMP:...) | In | Length (m) = 501.AMB.Longitud (m) | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 502.AMB.Amplada (m) | 503.AMB.Altura (m) | 507.AMB.Area (m2) | Group
3137599 | PLANTA BAIXA | 0.0186018 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.0186018 | Mecánica L3J_3_CLIMA_IMP_AIRE 8
3163951 | PLANTA BAIXA | 0.0677642 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.0677642 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3163959 | PLANTA BAIXA | 0.0947343 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.0947343 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3163967 | PLANTA BAIXA | 0.0749754 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.0749754 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3184188 | PLANTA BAIXA | 2.24242 | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 1.56969 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3184361 | PLANTA BAIXA | 1.87606 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 1.87606 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3184621 | PLANTA BAIXA | 2.27843 | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 1.5949 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3261788 | PLANTA BAIXA | 0.503213 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.503213 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3262604 | PLANTA BAIXA | 0.025117 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx200 mm | 0.3 | 0.15 | 0.0226053 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3262612 | PLANTA BAIXA | 0.0945685 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx200 mm | 0.3 | 0.15 | 0.0851117 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3429001 | PLANTA BAIXA | 0.344756 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.275805 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3431635 | PLANTA BAIXA | 0.111853 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.0894828 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3432238 | PLANTA BAIXA | 0.552943 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.331766 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3432326 | PLANTA BAIXA | 0.0249573 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.0149744 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3433094 | PLANTA BAIXA | 0.00929793 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 0.00650855 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3433205 | PLANTA BAIXA | 0.0505526 | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm | 0.85 | 0.27 | 0.113238 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3433736 | PLANTA BAIXA | 0.251477 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 0.176034 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3434173 | PLANTA BAIXA | 0.0131148 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.0104918 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3434229 | PLANTA BAIXA | 0.245195 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.196156 | Mecánica L3J_3_CLIMA_IMP_AIRE 3
3434968 | PLANTA BAIXA | 0.846669 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 0.592668 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3435679 | PLANTA BAIXA | 0.0483022 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.0289813 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3436545 | PLANTA BAIXA | 0.24636 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 0.172452 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3438414 | PLANTA BAIXA | 0.252391 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 0.176674 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3438449 | PLANTA BAIXA | 0.0153266 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx150 mm | 0.25 | 0.1 | 0.0107286 | Mecánica L3J_3_CLIMA_IMP_AIRE 2
3445608 | PLANTA BAIXA | 0.0421254 | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm | 0.85 | 0.27 | 0.094361 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3461627 | PLANTA BAIXA | 0.243558 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.146135 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3461628 | PLANTA BAIXA | 0.293454 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.176072 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3461657 | PLANTA BAIXA | 0.616828 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.370097 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
3474929 | PLANTA BAIXA | 0.108317 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.0866532 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3475031 | PLANTA BAIXA | 0.482448 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.289469 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3475134 | PLANTA BAIXA | 0.0921474 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.0552884 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3475135 | PLANTA BAIXA | 0.0376627 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.0225976 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3475518 | PLANTA BAIXA | 0.407672 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.244603 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3475531 | PLANTA BAIXA | 0.727379 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx200 mm | 0.15 | 0.15 | 0.436428 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3477801 | PLANTA BAIXA | 1.62821 | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx300 mm | 0.2 | 0.25 | 1.46539 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3483491 | PLANTA BAIXA | 0.103908 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.103908 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3483527 | PLANTA BAIXA | 0.516855 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.516855 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3483673 | PLANTA BAIXA | 0.187273 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.187273 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3483901 | PLANTA BAIXA | 0.120977 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.120977 | Mecánica L3J_3_CLIMA_IMP_AIRE 1
3485085 | PLANTA BAIXA | 0.834353 | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx350 mm | 0.2 | 0.3 | 0.834353 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3643768 | PLANTA BAIXA | 0.0576567 | PLANTA BAIXA | Nau Lateral Sud | 950 mmx320 mm | 0.9 | 0.269974 | 0.134914 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3644805 | PLANTA BAIXA | 0.249332 | PLANTA BAIXA | Nau Lateral Sud | 350 mmx250 mm | 0.3 | 0.2 | 0.249332 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3644850 | PLANTA BAIXA | 0.143523 | PLANTA BAIXA | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 0.100466 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3644902 | PLANTA BAIXA | 0.83461 | PLANTA BAIXA | Nau Lateral Sud | 250 mmx200 mm | 0.2 | 0.15 | 0.584227 | Mecánica L3J_3_CLIMA_IMP_AIRE 9
3646924 | PLANTA COBERTA | 0.0834269 | PLANTA COBERTA | Nau Lateral Sud | 1300 mmx410 mm | 1.25 | 0.36 | 0.268635 | Mecánica L3J_3_CLIMA_IMP_AIRE 10
3647502 | PLANTA COBERTA | 0.85863 | PLANTA COBERTA | Nau Lateral Sud | 550 mmx350 mm | 0.5 | 0.3 | 1.37381 | Mecánica L3J_3_CLIMA_IMP_AIRE 10
3647874 | PLANTA COBERTA | 0.19461 | PLANTA COBERTA | Nau Lateral Sud | 550 mmx350 mm | 0.5 | 0.3 | 0.311376 | Mecánica L3J_3_CLIMA_IMP_AIRE 10
3647954 | PLANTA COBERTA | 0.180616 | PLANTA COBERTA | Nau Lateral Sud | 550 mmx350 mm | 0.5 | 0.3 | 0.288985 | Mecánica L3J_3_CLIMA_IMP_AIRE 10
3867042 | PLANTA BAIXA | 0.18614 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.148912 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3867051 | PLANTA BAIXA | 0.0337578 | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm | 0.85 | 0.27 | 0.0756175 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3867702 | PLANTA BAIXA | 0.242534 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.194027 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3867703 | PLANTA BAIXA | 0.0395568 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.0316455 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3867704 | PLANTA BAIXA | 0.242534 | PLANTA BAIXA | Nau Santa Eulalia | 300 mmx200 mm | 0.25 | 0.15 | 0.194027 | Mecánica L3J_3_CLIMA_IMP_AIRE 7
3869734 | PLANTA BAIXA | 0.0404564 | PLANTA BAIXA | Nau Santa Eulalia | 900 mmx320 mm | 0.85 | 0.27 | 0.0906224 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3869810 | PLANTA BAIXA | 0.64917 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.64917 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
3875995 | PLANTA BAIXA | 2.27876 | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx200 mm | 0.2 | 0.15 | 1.59513 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
3876093 | PLANTA BAIXA | 2.60343 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 2.60343 | Mecánica L3J_3_CLIMA_IMP_AIRE 5
4954960 | PLANTA BAIXA | 0.840845 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx200 mm | 0.4 | 0.15 | 0.92493 | Mecánica L3J_3_CLIMA_IMP_AIRE 11
4957056 | PLANTA BAIXA | 0.520939 | PLANTA BAIXA | Nau Santa Eulalia | 200 mmx450 mm | 0.15 | 0.4 | 0.573033 | Mecánica L3J_3_CLIMA_IMP_AIRE 11
4957219 | PLANTA BAIXA | 0.0211017 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.0211017 | Mecánica L3J_3_CLIMA_IMP_AIRE 8
5251241 | PLANTA BAIXA | 0.37893 | PLANTA BAIXA | Nau Santa Eulalia | 250 mmx300 mm | 0.2 | 0.25 | 0.341037 | Mecánica L3J_3_CLIMA_IMP_AIRE 6
5251441 | PLANTA BAIXA | 0.224818 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx200 mm | 0.3 | 0.15 | 0.202336 | Mecánica L3J_3_CLIMA_IMP_AIRE 4
5257724 | PLANTA BAIXA | 0.260428 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx250 mm | 0.3 | 0.2 | 0.260428 | Mecánica L3J_3_CLIMA_IMP_AIRE 6

# IfcFlowSegment: Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_RET (74)
Type - 1 AMB.Identificacio - 104.AMB.ClassificacioCodi: 50.30.40.40; 105.AMB.ClassificacioDescripcio: Retorn de aire tractat; 109.AMB.CodiTipus: CLI-CRG
Classification: 50.30.40.40 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_RET; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
1 AMB.Identificacio - 107.AMB.NomTipus: L3J_COND_REC_CLIMA_FIBRA_RET; 112.AMB.Servei: L3J_3_CLIMA_RET_AIRE; 119.AMB.FaseCreacio: Obra
Name (Rectangular Duct:L3J_COND_REC_CLIMA_FIBRA_RET:...) | In | Length (m) = 501.AMB.Longitud (m) | 115.AMB.Nivell | 117.AMB.Localitzacio | 242.AMB.Mida | 502.AMB.Amplada (m) | 503.AMB.Altura (m) | 507.AMB.Area (m2) | Group
3115733 | PLANTA BAIXA | 5.07256 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 5.07256 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3115740 | PLANTA BAIXA | 0.75345 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.75345 | Mecánica L3J_3_CLIMA_RET_AIRE 3
3117096 | PLANTA BAIXA | 0.227799 | PLANTA BAIXA | Nau Santa Eulalia | 350 mmx200 mm | 0.3 | 0.15 | 0.205019 | Mecánica L3J_3_CLIMA_RET_AIRE 10
3117182 | PLANTA BAIXA | 0.787605 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.787605 | Mecánica L3J_3_CLIMA_RET_AIRE 10
3117204 | PLANTA BAIXA | 4.28109 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 4.28109 | Mecánica L3J_3_CLIMA_RET_AIRE 10
3119261 | PLANTA BAIXA | 0.192197 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 0.192197 | Mecánica L3J_3_CLIMA_RET_AIRE 4
3134601 | PLANTA BAIXA | 3.89096 | PLANTA BAIXA | Nau Santa Eulalia | 450 mmx150 mm | 0.4 | 0.1 | 3.89096 | Mecánica L3J_3_CLIMA_RET_AIRE 4
