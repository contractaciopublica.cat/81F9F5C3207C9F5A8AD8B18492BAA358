Properties of the parts of a building model (IFC2X3), part 4 of 10

# IfcDistributionPort (4427)
Name | FlowDirection | Group
Port_3728354_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3728581_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3728454_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3728456_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3728454_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3728603_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 19
Port_3728486_0 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728488_2 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728486_1 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728595_1 | SOURCEANDSINK | L3J_3_CALEF_RET 16
Port_3728533_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3728535_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3728533_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
Port_3728586_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 17
InPort_3733912_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3728900_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3729678_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3730712_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3729704_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3735611_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3729706_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3731081_0 | SOURCE | L3J_3_CALEF_RET 2
Port_3730123_1 | SOURCEANDSINK | L3J_3_CALEF_RET 2
Port_3730236_1 | SOURCEANDSINK | L3J_3_CALEF_RET 2
InPort_3730714_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3730224_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3730224_1 | SINK | L3J_3_CALEF_RET 2
Port_3730234_0 | SOURCEANDSINK | L3J_3_CALEF_RET 2
Port_3730236_2 | SOURCEANDSINK | L3J_3_CALEF_RET 2
Port_3730234_1 | SOURCEANDSINK | L3J_3_CALEF_RET 2
Port_3730407_2 | SOURCEANDSINK | L3J_3_CALEF_RET 2
Port_3730407_1 | SOURCEANDSINK | L3J_3_CALEF_RET 2
InPort_3734660_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3730587_0 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3730587_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3733912_2 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3730712_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3730710_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3730710_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3730714_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3731081_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3731317_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3731300_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3731171_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3731319_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3731289_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3731289_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3731323_2 | SOURCE | L3J_3_CALEF_RET 2
InPort_3731298_0 | SINK | L3J_3_CALEF_RET 2
OutPort_3731300_2 | SOURCE | L3J_3_CALEF_RET 2
InPort_3731323_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3731298_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3731317_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3731315_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3731315_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3731319_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3734014_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3734645_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3734634_0 | SINK | L3J_3_CALEF_IMP 2
OutPort_3734660_2 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3734666_2 | SINK | L3J_3_CALEF_IMP 2
OutPort_3734634_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3734645_2 | SINK | L3J_3_CALEF_IMP 2
OutPort_3734643_0 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3734643_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3734666_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735094_0 | SINK | L3J_3_CALEF_IMP 2
OutPort_3734703_2 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735236_0 | SINK | L3J_3_CALEF_IMP 2
OutPort_3734705_2 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735409_0 | SINK | L3J_3_CALEF_IMP 2
OutPort_3734707_2 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735195_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735094_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735135_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735178_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735145_0 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735197_2 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735201_2 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735145_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735178_2 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735176_0 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735176_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735201_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735193_0 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735195_2 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735197_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735193_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735291_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735236_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735377_2 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735246_0 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735246_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735381_2 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735289_0 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735291_2 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735381_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735289_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735354_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735375_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735375_2 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735373_0 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735373_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735377_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3737658_2 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735409_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735421_0 | SINK | L3J_3_CALEF_IMP 2
OutPort_3737658_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3737663_2 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735421_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735501_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735524_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735524_2 | SINK | L3J_3_CALEF_IMP 2
OutPort_3735522_0 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735522_1 | SINK | L3J_3_CALEF_IMP 2
OutPort_3737663_1 | SOURCE | L3J_3_CALEF_IMP 2
InPort_3735611_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3735692_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3735692_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3735690_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3735690_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3737031_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3735742_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3735721_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3735740_0 | SINK | L3J_3_CALEF_RET 2
OutPort_3735742_2 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737090_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3735740_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737086_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3735834_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3735834_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3737090_2 | SOURCE | L3J_3_CALEF_RET 2
InPort_3735859_0 | SINK | L3J_3_CALEF_RET 2
OutPort_3737084_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737031_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3735859_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3736717_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3736820_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3736820_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3736818_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3736818_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3737383_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737084_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3737082_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737082_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3737086_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737383_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3737424_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737424_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3737446_2 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737446_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3737438_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737438_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3737513_1 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737515_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3737479_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737513_2 | SINK | L3J_3_CALEF_RET 2
OutPort_3737511_0 | SOURCE | L3J_3_CALEF_RET 2
InPort_3737511_1 | SINK | L3J_3_CALEF_RET 2
OutPort_3737515_1 | SOURCE | L3J_3_CALEF_RET 2
Port_3738266_0 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3740641_2 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3738301_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3740646_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739384_0 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739400_2 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739384_1 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739467_1 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739394_0 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3740641_1 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739394_1 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739400_1 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739404_0 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739469_2 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739404_1 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739465_0 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739467_2 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739465_1 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739469_1 | SOURCEANDSINK | L3J_3_CALEF_RET 5
Port_3739492_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739508_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739492_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739565_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739502_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3740646_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739502_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739508_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739512_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739567_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739512_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739563_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739565_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739563_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
Port_3739567_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 3
InPort_3740678_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3740670_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3740670_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3740688_1 | SOURCE | L3J_3_CALEF_RET 4
InPort_3740688_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3740680_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3740680_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3741096_1 | SOURCE | L3J_3_CALEF_RET 4
Port_3740771_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740779_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740771_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740787_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740781_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740787_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3740781_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741133_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
InPort_3741096_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3741088_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3741088_1 | SINK | L3J_3_CALEF_RET 4
OutPort_3741663_1 | SOURCE | L3J_3_CALEF_RET 4
Port_3741125_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741133_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741125_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741162_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741162_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741166_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3741166_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
InPort_3741663_2 | SINK | L3J_3_CALEF_RET 4
OutPort_3741198_0 | SOURCE | L3J_3_CALEF_RET 4
InPort_3741198_1 | SINK | L3J_3_CALEF_IMP 20
InPort_3746581_2 | SINK | L3J_3_CALEF_IMP 9
OutPort_3741567_0 | SOURCE | L3J_3_CALEF_IMP 9
InPort_3741567_1 | SINK | L3J_3_CALEF_IMP 9
OutPort_3746587_2 | SOURCE | L3J_3_CALEF_IMP 9
Port_3741602_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746506_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3741602_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746512_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3742772_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3742899_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3742772_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3742901_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 4
Port_3743660_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3743860_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3743660_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
InPort_3743891_2 | SINK | L3J_3_CALEF_IMP 9
OutPort_3743695_0 | SOURCE | L3J_3_CALEF_IMP 9
InPort_3743695_1 | SINK | L3J_3_CALEF_IMP 9
InPort_3743964_2 | SINK | L3J_3_CALEF_IMP 21
OutPort_3743718_0 | SOURCE | L3J_3_CALEF_IMP 21
InPort_3743718_1 | SINK | L3J_3_CALEF_IMP 21
InPort_3743930_2 | SINK | L3J_3_CALEF_IMP 6
OutPort_3743749_0 | SOURCE | L3J_3_CALEF_IMP 6
InPort_3743749_1 | SINK | L3J_3_CALEF_IMP 6
Port_3743854_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746512_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3743854_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3743860_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
InPort_3746587_1 | SINK | L3J_3_CALEF_IMP 9
OutPort_3743885_0 | SOURCE | L3J_3_CALEF_IMP 9
InPort_3743885_1 | SINK | L3J_3_CALEF_IMP 9
OutPort_3743891_1 | SOURCE | L3J_3_CALEF_IMP 9
InPort_3751074_1 | SINK | L3J_3_CALEF_IMP 6
OutPort_3743922_0 | SOURCE | L3J_3_CALEF_IMP 6
InPort_3743922_1 | SINK | L3J_3_CALEF_IMP 6
OutPort_3743930_1 | SOURCE | L3J_3_CALEF_IMP 6
InPort_3749947_1 | SINK | L3J_3_CALEF_IMP 21
OutPort_3743956_0 | SOURCE | L3J_3_CALEF_IMP 21
InPort_3743956_1 | SINK | L3J_3_CALEF_IMP 21
OutPort_3743964_1 | SOURCE | L3J_3_CALEF_IMP 21
Port_3746459_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746467_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746459_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746477_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746467_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746469_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746477_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746469_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746500_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746496_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746500_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746496_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746502_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746497_0 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746502_2 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746497_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746506_1 | SOURCEANDSINK | L3J_3_CALEF_IMP 5
Port_3746539_2 | SOURCEANDSINK | L3J_3_CALEF_RET 6
InPort_3746550_1 | SINK | L3J_3_CALEF_RET 10
OutPort_3746542_0 | SOURCE | L3J_3_CALEF_RET 10
InPort_3746542_1 | SINK | L3J_3_CALEF_RET 10
OutPort_3746560_2 | SOURCE | L3J_3_CALEF_RET 10
OutPort_3746550_2 | SOURCE | L3J_3_CALEF_RET 10
InPort_3746560_1 | SINK | L3J_3_CALEF_RET 10
OutPort_3746552_0 | SOURCE | L3J_3_CALEF_RET 10
InPort_3746552_1 | SINK | L3J_3_CALEF_RET 10
OutPort_3746579_1 | SOURCE | L3J_3_CALEF_RET 10
InPort_3746579_2 | SINK | L3J_3_CALEF_IMP 9
OutPort_3746577_0 | SOURCE | L3J_3_CALEF_IMP 9
InPort_3746577_1 | SINK | L3J_3_CALEF_IMP 9
OutPort_3746581_1 | SOURCE | L3J_3_CALEF_IMP 9
InPort_3746639_1 | SINK | L3J_3_CALEF_IMP 21
OutPort_3749924_1 | SOURCE | L3J_3_CALEF_IMP 21
InPort_3750821_0 | SINK | L3J_3_CALEF_RET 7
OutPort_3746639_2 | SOURCE | L3J_3_CALEF_RET 7
InPort_3749943_2 | SINK | L3J_3_CALEF_IMP 21
OutPort_3748718_0 | SOURCE | L3J_3_CALEF_IMP 21
InPort_3748718_1 | SINK | L3J_3_CALEF_IMP 21
OutPort_3749947_2 | SOURCE | L3J_3_CALEF_IMP 21
InPort_3748729_0 | SINK | L3J_3_CALEF_IMP 21
OutPort_3749943_1 | SOURCE | L3J_3_CALEF_IMP 21
InPort_3750729_1 | SINK | L3J_3_CALEF_IMP 21
OutPort_3748729_1 | SOURCE | L3J_3_CALEF_IMP 21
InPort_3751068_2 | SINK | L3J_3_CALEF_IMP 6
OutPort_3748767_0 | SOURCE | L3J_3_CALEF_IMP 6
InPort_3748767_1 | SINK | L3J_3_CALEF_IMP 6
OutPort_3751074_2 | SOURCE | L3J_3_CALEF_IMP 6
InPort_3749924_0 | SINK | L3J_3_CALEF_IMP 21
OutPort_3750733_2 | SOURCE | L3J_3_CALEF_IMP 21
InPort_3750727_0 | SINK | L3J_3_CALEF_IMP 21
OutPort_3750729_2 | SOURCE | L3J_3_CALEF_IMP 21
InPort_3750733_1 | SINK | L3J_3_CALEF_IMP 21
OutPort_3750727_1 | SOURCE | L3J_3_CALEF_IMP 21
InPort_3750844_2 | SINK | L3J_3_CALEF_RET 7
OutPort_3750821_1 | SOURCE | L3J_3_CALEF_RET 7
InPort_3750832_0 | SINK | L3J_3_CALEF_RET 7
OutPort_3750844_1 | SOURCE | L3J_3_CALEF_RET 7
InPort_3750832_1 | SINK | L3J_3_CALEF_RET 7
OutPort_3751066_1 | SOURCE | L3J_3_CALEF_RET 7
InPort_3751066_2 | SINK | L3J_3_CALEF_IMP 6
OutPort_3751064_0 | SOURCE | L3J_3_CALEF_IMP 6
InPort_3751064_1 | SINK | L3J_3_CALEF_IMP 6
OutPort_3751068_1 | SOURCE | L3J_3_CALEF_IMP 6
InPort_3756865_2 | SINK | L3J_3_CALEF_RET 1
OutPort_3755418_0 | SOURCE | L3J_3_CALEF_RET 1
InPort_3755418_1 | SINK | L3J_3_CALEF_RET 1
OutPort_3756825_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3755464_0 | SINK | L3J_3_CALEF_IMP 1
OutPort_3755665_2 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756813_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3755464_1 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3755510_0 | SINK | L3J_3_CALEF_RET 1
OutPort_3756724_2 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756869_2 | SINK | L3J_3_CALEF_RET 1
OutPort_3755510_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756709_2 | SINK | L3J_3_CALEF_IMP 1
OutPort_3755552_0 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3755596_0 | SINK | L3J_3_CALEF_RET 1
OutPort_3756502_2 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756867_2 | SINK | L3J_3_CALEF_RET 1
OutPort_3755596_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3755639_0 | SINK | L3J_3_CALEF_IMP 1
OutPort_3755669_2 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756045_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3755639_1 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3755735_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3755870_1 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3755748_0 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756047_2 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756051_2 | SINK | L3J_3_CALEF_IMP 1
OutPort_3755748_1 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3755870_2 | SINK | L3J_3_CALEF_IMP 1
OutPort_3755868_0 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3755868_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756051_1 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756043_0 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756045_2 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756047_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756043_1 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756392_1 | SINK | L3J_3_CALEF_RET 1
OutPort_3756193_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756380_0 | SINK | L3J_3_CALEF_RET 1
OutPort_3756397_2 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756497_1 | SINK | L3J_3_CALEF_RET 1
OutPort_3756380_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756390_0 | SINK | L3J_3_CALEF_RET 1
OutPort_3756392_2 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756397_1 | SINK | L3J_3_CALEF_RET 1
OutPort_3756390_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756495_0 | SINK | L3J_3_CALEF_RET 1
OutPort_3756497_2 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756502_1 | SINK | L3J_3_CALEF_RET 1
OutPort_3756495_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756652_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756707_1 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756720_1 | SINK | L3J_3_CALEF_RET 1
OutPort_3756678_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756707_2 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756705_0 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756705_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756709_1 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756718_0 | SINK | L3J_3_CALEF_RET 1
OutPort_3756720_2 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756724_1 | SINK | L3J_3_CALEF_RET 1
OutPort_3756718_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756757_0 | SINK | L3J_3_CALEF_IMP 1
OutPort_3868730_2 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3868742_2 | SINK | L3J_3_CALEF_RET 1
OutPort_3756785_0 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756811_0 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756813_2 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3868730_1 | SINK | L3J_3_CALEF_IMP 1
OutPort_3756811_1 | SOURCE | L3J_3_CALEF_IMP 1
InPort_3756825_2 | SINK | L3J_3_CALEF_RET 1
OutPort_3756823_0 | SOURCE | L3J_3_CALEF_RET 1
InPort_3756823_1 | SINK | L3J_3_CALEF_RET 1
OutPort_3868742_1 | SOURCE | L3J_3_CALEF_RET 1
InPort_3757162_0 | SINK | L3J_3_CALEF_RET 11
OutPort_3758064_2 | SOURCE | L3J_3_CALEF_RET 11
OutPort_3757162_1 | SOURCE | L3J_3_CALEF_RET 11
InPort_3757200_0 | SINK | L3J_3_CALEF_IMP 15
InPort_3757217_2 | SINK | L3J_3_CALEF_IMP 15
OutPort_3757200_1 | SOURCE | L3J_3_CALEF_IMP 15
InPort_3757211_0 | SINK | L3J_3_CALEF_IMP 15
OutPort_3757217_1 | SOURCE | L3J_3_CALEF_IMP 15
InPort_3758133_1 | SINK | L3J_3_CALEF_RET 14
OutPort_3757211_1 | SOURCE | L3J_3_CALEF_RET 14
InPort_3758133_2 | SINK | L3J_3_CALEF_RET 14
OutPort_3758131_0 | SOURCE | L3J_3_CALEF_RET 14
InPort_3758131_1 | SINK | L3J_3_CALEF_RET 14
OutPort_3758143_1 | SOURCE | L3J_3_CALEF_RET 14
Port_3758383_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3758750_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3758749_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3758750_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3758749_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3764228_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3758749_3 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_5257968_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3758836_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3764050_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3758836_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_5257968_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3759127_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3761287_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3759127_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760804_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760103_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760801_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760103_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760804_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760178_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760775_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760178_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760801_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760673_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3760775_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3761287_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3870947_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3761287_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_3763744_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3764050_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3763744_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3764053_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3763941_0 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3764053_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3763941_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3764228_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
Port_3764278_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 2
InPort_3764430_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3765939_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3765923_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3764430_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3765918_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3764518_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3764518_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3765923_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3766562_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3765918_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3766006_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3766594_1 | SOURCE | L3J_4_SAN_FECAL 3
Port_3766006_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3766596_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_3766570_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3766562_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3766563_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3766570_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3766575_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3766563_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3766564_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3766575_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3766578_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3766564_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3766565_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3766578_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3766594_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3766565_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767063_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3766900_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767052_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767063_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767073_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767052_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767067_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767073_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767173_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767067_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767219_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767173_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767233_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767219_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767227_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767233_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767510_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767227_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767289_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767512_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767311_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767510_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3767512_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3767311_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3772358_2 | SINK | L3J_2_AFS 1
OutPort_3767778_0 | SOURCE | L3J_2_AFS 1
InPort_3767778_1 | SINK | L3J_2_AFS 1
OutPort_3772390_1 | SOURCE | L3J_2_AFS 1
InPort_3769578_2 | SINK | L3J_2_AFS 1
OutPort_3769570_0 | SOURCE | L3J_2_AFS 1
InPort_3769570_1 | SINK | L3J_2_AFS 1
OutPort_3769793_3 | SOURCE | L3J_2_AFS 1
Port_3769793_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012707_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769793_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769823_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769803_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769825_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769803_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769967_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769823_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769825_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769965_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769967_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_3769965_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_3770154_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3905394_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3770154_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3770335_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771608_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
InPort_3770835_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
OutPort_3770598_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
InPort_3770879_0 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
OutPort_3770835_2 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3770868_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3770878_3 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3770878_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771566_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
InPort_3770878_2 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
OutPort_3770879_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
InPort_3771288_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
OutPort_3771315_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
InPort_3771315_2 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
OutPort_3771298_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
InPort_3771298_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
OutPort_3771683_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
InPort_3771810_2 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
OutPort_3771339_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
InPort_3771339_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
Port_3771566_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771582_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771574_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771582_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771574_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771601_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771601_0 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
Port_3771608_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 2
InPort_3771669_0 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
OutPort_3771810_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
InPort_3771683_2 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
OutPort_3771669_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 3
InPort_3772390_2 | SINK | L3J_2_AFS 1
OutPort_3771976_0 | SOURCE | L3J_2_AFS 1
InPort_3771976_1 | SINK | L3J_2_AFS 1
OutPort_3772392_2 | SOURCE | L3J_2_AFS 1
Port_3785875_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5117656_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3785875_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5117557_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_5117944_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3786085_1 | SOURCE | L3J_4_SAN_FECAL 3
Port_3788986_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056703_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_3788986_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_5056706_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 3
Port_3789228_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826293_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3789228_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3789247_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3789241_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3789247_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3789241_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3789288_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3789286_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3789288_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
InPort_5241976_2 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_3802820_0 | SOURCE | L3J_4_SAN_PLUVIAL 3
InPort_3802820_1 | SINK | L3J_4_SAN_PLUVIAL 3
OutPort_3803254_1 | SOURCE | L3J_4_SAN_PLUVIAL 3
Port_3814360_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3905392_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3814360_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3905397_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3821437_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060343_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_3821437_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3823599_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_5057254_0 | SINK | L3J_4_SAN_FECAL 3
OutPort_3821437_3 | SOURCE | L3J_4_SAN_FECAL 3
Port_3821437_4 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5059299_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_3823604_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3821807_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3821807_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_5059961_2 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3823599_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3823604_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3824631_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3823937_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3823937_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_4559378_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_4559378_2 | SINK | L3J_4_SAN_FECAL 3
OutPort_3824221_0 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3824221_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_5061834_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3824582_1 | SINK | L3J_4_SAN_FECAL 3
OutPort_3824631_1 | SOURCE | L3J_4_SAN_FECAL 3
InPort_3824805_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3824787_0 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3824787_1 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3824809_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3824807_2 | SINK | L3J_4_SAN_PLUVIAL 6
OutPort_3824805_1 | SOURCE | L3J_4_SAN_PLUVIAL 6
InPort_3825602_1 | SINK | L3J_4_SAN_PLUVIAL 1
OutPort_3825624_1 | SOURCE | L3J_4_SAN_PLUVIAL 1
InPort_3825624_2 | SINK | L3J_4_SAN_PLUVIAL 1
OutPort_3825616_0 | SOURCE | L3J_4_SAN_PLUVIAL 1
InPort_3825616_1 | SINK | L3J_4_SAN_PLUVIAL 1
OutPort_3825672_1 | SOURCE | L3J_4_SAN_PLUVIAL 1
InPort_3825992_1 | SINK | L3J_4_SAN_PLUVIAL 8
OutPort_3826022_0 | SOURCE | L3J_4_SAN_PLUVIAL 8
Port_3825992_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3825992_3 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3905392_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
InPort_3826022_1 | SINK | L3J_4_SAN_PLUVIAL 8
OutPort_3826326_1 | SOURCE | L3J_4_SAN_PLUVIAL 8
Port_3826139_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826329_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826139_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826168_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826156_0 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826168_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826156_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826297_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3826329_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3860927_1 | SOURCEANDSINK
Port_3860927_2 | SOURCEANDSINK
Port_3860927_3 | SOURCEANDSINK
Port_3860927_4 | SOURCEANDSINK
Port_3864485_1 | SOURCEANDSINK
Port_3864485_2 | SOURCEANDSINK
Port_3864485_3 | SOURCEANDSINK
Port_3864485_4 | SOURCEANDSINK
Port_3864928_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_5259534_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 11
Port_3865792_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_5259540_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 10
Port_3866434_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3868688_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3866434_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3868690_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3866773_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3866906_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3866773_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3868194_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
InPort_3867520_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3867042_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3867042_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3867521_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3867521_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3867051_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3867432_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3867702_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3867704_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3867520_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3867702_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3867705_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3867705_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3867703_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3867703_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3867708_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
InPort_3867708_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 7
OutPort_3867704_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 7
Port_3867993_1 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3867996_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3868135_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 7
Port_3868194_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3868282_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3868282_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 6
Port_3868675_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3868677_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3868675_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_3868690_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
InPort_3870422_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3869734_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3869810_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3870422_2 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_5257811_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 6
OutPort_3869810_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 6
InPort_3871686_2 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
OutPort_3871630_0 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 12
InPort_3871630_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
OutPort_3871739_3 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_3871716_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_3871830_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_3871716_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_3871739_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
InPort_3871739_1 | SINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
OutPort_3871808_1 | SOURCE | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_3871830_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_4956042_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 12
Port_3872829_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_5258648_2 | SOURCEANDSINK | Mecánica L3J_3_VENT_APORT_AIRE 3
Port_3874266_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 13
Port_3874266_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 13
InPort_3874440_2 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
OutPort_3874447_0 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
InPort_3874447_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
OutPort_3874504_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
InPort_3874504_2 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
OutPort_3874449_0 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
InPort_3874449_1 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
OutPort_3874526_1 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 5
InPort_3876056_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3875995_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3875995_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3876057_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3876090_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3876093_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_5251342_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3876090_3 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3876508_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3876372_0 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3876372_1 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_5251342_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3876474_0 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_5251337_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3876479_2 | SINK | Mecánica L3J_3_CLIMA_IMP_AIRE 5
OutPort_3876474_1 | SOURCE | Mecánica L3J_3_CLIMA_IMP_AIRE 5
InPort_3876895_2 | SINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 14
OutPort_3876777_0 | SOURCE | Mecánica L3J_VENTILACIÓ_CTE_HS3 14
InPort_3876879_3 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
OutPort_3876777_1 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3876879_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5258041_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3876879_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5258043_2 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3876880_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_5258043_1 | SOURCEANDSINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 9
Port_3877390_1 | SOURCEANDSINK
Port_3877390_2 | SOURCEANDSINK
Port_3877390_3 | SOURCEANDSINK
Port_3877390_4 | SOURCEANDSINK
Port_3877469_1 | SOURCEANDSINK
Port_3877469_2 | SOURCEANDSINK
Port_3877469_3 | SOURCEANDSINK
Port_3877469_4 | SOURCEANDSINK
Port_3877481_1 | SOURCEANDSINK
Port_3877481_2 | SOURCEANDSINK
Port_3877481_3 | SOURCEANDSINK
Port_3877481_4 | SOURCEANDSINK
Port_3877880_1 | SOURCEANDSINK
Port_3877880_2 | SOURCEANDSINK
Port_3877880_3 | SOURCEANDSINK
Port_3877880_4 | SOURCEANDSINK
Port_3877889_1 | SOURCEANDSINK
Port_3877889_2 | SOURCEANDSINK
Port_3877889_3 | SOURCEANDSINK
Port_3877889_4 | SOURCEANDSINK
Port_3878006_1 | SOURCEANDSINK
Port_3878006_2 | SOURCEANDSINK
Port_3878006_3 | SOURCEANDSINK
Port_3878006_4 | SOURCEANDSINK
Port_3878026_1 | SOURCEANDSINK
Port_3878026_2 | SOURCEANDSINK
Port_3878026_3 | SOURCEANDSINK
Port_3878026_4 | SOURCEANDSINK
Port_3887843_1 | SOURCEANDSINK
Port_3887919_1 | SOURCEANDSINK
Port_3890861_1 | SOURCEANDSINK
Port_3890883_1 | SOURCEANDSINK
Port_3891043_1 | SOURCEANDSINK
Port_3891056_1 | SOURCEANDSINK
Port_3891221_1 | SOURCEANDSINK
Port_3891255_1 | SOURCEANDSINK
Port_3899319_1 | SOURCEANDSINK
Port_3899328_1 | SOURCEANDSINK
Port_3899480_1 | SOURCEANDSINK
Port_3899480_2 | SOURCEANDSINK
Port_3899480_3 | SOURCEANDSINK
Port_3899480_4 | SOURCEANDSINK
Port_3899749_1 | SOURCEANDSINK
Port_3899749_2 | SOURCEANDSINK
Port_3899749_3 | SOURCEANDSINK
Port_3899749_4 | SOURCEANDSINK
Port_3899806_1 | SOURCEANDSINK
Port_3899806_2 | SOURCEANDSINK
Port_3899806_3 | SOURCEANDSINK
Port_3899806_4 | SOURCEANDSINK
Port_3899827_1 | SOURCEANDSINK
Port_3899827_2 | SOURCEANDSINK
Port_3899827_3 | SOURCEANDSINK
Port_3899827_4 | SOURCEANDSINK
Port_3900040_1 | SOURCEANDSINK
Port_3900047_1 | SOURCEANDSINK
Port_3900728_1 | SOURCEANDSINK
Port_3900763_1 | SOURCEANDSINK
Port_3901184_1 | SOURCEANDSINK
Port_3901184_2 | SOURCEANDSINK
Port_3901184_3 | SOURCEANDSINK
Port_3901184_4 | SOURCEANDSINK
Port_3901196_1 | SOURCEANDSINK
Port_3901196_2 | SOURCEANDSINK
Port_3901196_3 | SOURCEANDSINK
Port_3901196_4 | SOURCEANDSINK
Port_3901479_1 | SOURCEANDSINK
Port_3901479_2 | SOURCEANDSINK
Port_3901479_3 | SOURCEANDSINK
Port_3901479_4 | SOURCEANDSINK
Port_3901489_1 | SOURCEANDSINK
Port_3901489_2 | SOURCEANDSINK
Port_3901489_3 | SOURCEANDSINK
Port_3901489_4 | SOURCEANDSINK
Port_3901791_1 | SOURCEANDSINK
Port_3901791_2 | SOURCEANDSINK
Port_3901791_3 | SOURCEANDSINK
Port_3901791_4 | SOURCEANDSINK
Port_3901959_1 | SOURCEANDSINK
Port_3901959_2 | SOURCEANDSINK
Port_3901959_3 | SOURCEANDSINK
Port_3901959_4 | SOURCEANDSINK
InPort_3903273_1 | SINK | L3J_6_PCI - HUMIDA 1
OutPort_3903444_0 | SOURCE | L3J_6_PCI - HUMIDA 1
Port_3903444_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 1
Port_3903474_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 1
Port_3903461_0 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 1
Port_3903474_2 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 1
Port_3903461_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 1
Port_3903591_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 1
Port_3903591_2 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 1
Port_3903944_0 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 1
InPort_3903627_1 | SINK | L3J_6_PCI - HUMIDA 2
OutPort_3903710_0 | SOURCE | L3J_6_PCI - HUMIDA 2
Port_3903710_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 2
Port_3903730_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 2
Port_3903722_0 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 2
Port_3903730_2 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 2
Port_3903722_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 2
Port_3903944_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 1
InPort_3904188_1 | SINK | L3J_6_PCI - HUMIDA 3
OutPort_3904221_0 | SOURCE | L3J_6_PCI - HUMIDA 3
Port_3904221_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904548_3 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904445_0 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904548_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904445_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904548_2 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904555_0 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904555_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904576_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904570_0 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904576_2 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3904570_1 | SOURCEANDSINK | L3J_6_PCI - HUMIDA 3
Port_3905394_2 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
Port_3905397_1 | SOURCEANDSINK | L3J_4_SAN_PLUVIAL 8
InPort_3921190_2 | SINK | L3J_2_AFS 1
OutPort_3921391_0 | SOURCE | L3J_2_AFS 1
InPort_3921413_2 | SINK | L3J_2_AFS 1
OutPort_3921378_0 | SOURCE | L3J_2_AFS 1
InPort_3921378_1 | SINK | L3J_2_AFS 1
OutPort_3921395_2 | SOURCE | L3J_2_AFS 1
InPort_3921391_1 | SINK | L3J_2_AFS 1
OutPort_3921413_1 | SOURCE | L3J_2_AFS 1
InPort_3991213_0 | SINK | L3J_2_AFS 1
OutPort_3991555_2 | SOURCE | L3J_2_AFS 1
InPort_3991342_1 | SINK | L3J_2_AFS 1
OutPort_3991213_1 | SOURCE | L3J_2_AFS 1
InPort_3991553_2 | SINK | L3J_2_AFS 1
OutPort_3991422_0 | SOURCE | L3J_2_AFS 1
InPort_3991422_1 | SINK | L3J_2_AFS 1
OutPort_3991555_3 | SOURCE | L3J_2_AFS 1
InPort_3991555_1 | SINK | L3J_2_AFS 1
OutPort_3991556_0 | SOURCE | L3J_2_AFS 1
InPort_3991556_1 | SINK | L3J_2_AFS 1
OutPort_4060639_2 | SOURCE | L3J_2_AFS 1
InPort_3991700_1 | SINK | L3J_2_AFS 1
OutPort_3991753_3 | SOURCE | L3J_2_AFS 1
Port_3991753_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_3993845_0 | SOURCEANDSINK | L3J_2_AFS 1
InPort_3991857_0 | SINK | L3J_2_AFS 1
OutPort_5117439_1 | SOURCE | L3J_2_AFS 1
InPort_3992817_0 | SINK | L3J_2_AFS 1
OutPort_3993844_3 | SOURCE | L3J_2_AFS 1
InPort_3994332_1 | SINK | L3J_2_AFS 1
OutPort_3992817_1 | SOURCE | L3J_2_AFS 1
Port_3993844_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058111_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_3993844_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_3993845_1 | SOURCEANDSINK | L3J_2_AFS 1
InPort_3994007_0 | SINK | L3J_2_AFS 1
OutPort_3994332_2 | SOURCE | L3J_2_AFS 1
InPort_3994336_2 | SINK | L3J_2_AFS 1
OutPort_3994007_1 | SOURCE | L3J_2_AFS 1
InPort_3994324_2 | SINK | L3J_2_AFS 1
OutPort_3994322_0 | SOURCE | L3J_2_AFS 1
InPort_3994322_1 | SINK | L3J_2_AFS 1
OutPort_3994336_1 | SOURCE | L3J_2_AFS 1
Port_4009147_0 | SOURCEANDSINK | AFS 3
Port_4009147_1 | SOURCEANDSINK | AFS 3
Port_4009153_1 | SOURCEANDSINK | AFS 3
Port_4009149_0 | SOURCEANDSINK | AFS 3
Port_4009153_2 | SOURCEANDSINK | AFS 3
Port_4009149_1 | SOURCEANDSINK | AFS 3
Port_4009512_1 | SOURCEANDSINK | AFS 3
Port_4009183_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009624_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009183_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009639_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009186_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009639_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009186_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009641_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009188_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009641_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009188_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009196_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009190_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009196_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009190_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009202_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009726_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009202_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009728_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009205_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009728_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009205_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009702_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009207_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009702_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009207_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009215_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009209_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009215_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009209_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009417_0 | SOURCEANDSINK | AFS 3
Port_4009888_1 | SOURCEANDSINK | AFS 3
Port_4009417_1 | SOURCEANDSINK | AFS 3
Port_4009512_2 | SOURCEANDSINK | AFS 3
Port_4009685_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064514_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4009888_2 | SOURCEANDSINK | AFS 3
Port_4569213_0 | SOURCEANDSINK | AFS 3
Port_4010934_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012134_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4010934_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4011830_2 | SOURCEANDSINK | L3J_2_AFS 1
InPort_4011279_0 | SINK | L3J_2_AFS 1
OutPort_4011830_3 | SOURCE | L3J_2_AFS 1
InPort_4011307_1 | SINK | L3J_2_AFS 1
OutPort_4011279_1 | SOURCE | L3J_2_AFS 1
InPort_4011299_0 | SINK | L3J_2_AFS 1
OutPort_4011307_2 | SOURCE | L3J_2_AFS 1
InPort_4011315_1 | SINK | L3J_2_AFS 1
OutPort_4011299_1 | SOURCE | L3J_2_AFS 1
InPort_4011309_0 | SINK | L3J_2_AFS 1
OutPort_4011315_2 | SOURCE | L3J_2_AFS 1
InPort_4011782_1 | SINK | L3J_2_AFS 1
OutPort_4011309_1 | SOURCE | L3J_2_AFS 1
InPort_4012114_1 | SINK | L3J_2_AFS 1
OutPort_4011319_0 | SOURCE | L3J_2_AFS 1
InPort_4011319_1 | SINK | L3J_2_AFS 1
OutPort_4013397_2 | SOURCE | L3J_2_AFS 1
InPort_4013397_1 | SINK | L3J_2_AFS 1
OutPort_4011457_1 | SOURCE | L3J_2_AFS 1
InPort_4011457_2 | SINK | L3J_2_AFS 1
OutPort_4012179_1 | SOURCE | L3J_2_AFS 1
InPort_4011739_0 | SINK | L3J_2_AFS 1
OutPort_4011782_2 | SOURCE | L3J_2_AFS 1
InPort_4012179_2 | SINK | L3J_2_AFS 1
OutPort_4011739_1 | SOURCE | L3J_2_AFS 1
InPort_4012112_2 | SINK | L3J_2_AFS 1
OutPort_4012051_0 | SOURCE | L3J_2_AFS 1
InPort_4012051_1 | SINK | L3J_2_AFS 1
OutPort_4012114_2 | SOURCE | L3J_2_AFS 1
InPort_4012053_1 | SINK | L3J_2_AFS 1
OutPort_4012112_1 | SOURCE | L3J_2_AFS 1
Port_4012707_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012746_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012738_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012746_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012738_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012759_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012751_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4013151_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012751_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012770_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012759_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012856_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012762_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012770_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012762_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012811_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012811_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4013182_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012854_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4013363_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012854_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4013151_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4012856_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4013363_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4013182_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4013244_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058032_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4059679_3 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058032_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058539_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058042_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058560_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058042_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058562_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058052_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058560_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058052_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058073_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058062_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058073_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058062_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058081_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058075_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058081_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058075_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058107_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058107_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058109_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058109_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058616_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058111_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058616_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058213_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058562_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058213_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058894_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058215_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058539_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058215_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4058894_2 | SOURCEANDSINK | L3J_2_AFS 1
InPort_4058888_2 | SINK | L3J_2_AFS 1
OutPort_4060369_0 | SOURCE | L3J_2_AFS 1
InPort_4059479_0 | SINK | L3J_2_AFS 1
OutPort_4059557_2 | SOURCE | L3J_2_AFS 1
InPort_4059643_2 | SINK | L3J_2_AFS 1
OutPort_4059479_1 | SOURCE | L3J_2_AFS 1
InPort_4059488_0 | SINK | L3J_2_AFS 1
OutPort_4059531_1 | SOURCE | L3J_2_AFS 1
InPort_4059557_1 | SINK | L3J_2_AFS 1
OutPort_4059488_1 | SOURCE | L3J_2_AFS 1
InPort_4059523_1 | SINK | L3J_2_AFS 1
OutPort_4059521_1 | SOURCE | L3J_2_AFS 1
InPort_4059603_0 | SINK | L3J_2_AFS 1
OutPort_4059591_2 | SOURCE | L3J_2_AFS 1
InPort_4059635_1 | SINK | L3J_2_AFS 1
OutPort_4059603_1 | SOURCE | L3J_2_AFS 1
InPort_4059631_2 | SINK | L3J_2_AFS 1
OutPort_4059614_0 | SOURCE | L3J_2_AFS 1
InPort_4059614_1 | SINK | L3J_2_AFS 1
OutPort_4059635_2 | SOURCE | L3J_2_AFS 1
InPort_4060266_1 | SINK | L3J_2_AFS 1
OutPort_4059679_2 | SOURCE | L3J_2_AFS 1
InPort_4059745_0 | SINK | L3J_2_AFS 1
OutPort_4061062_2 | SOURCE | L3J_2_AFS 1
InPort_4061064_2 | SINK | L3J_2_AFS 1
OutPort_4059745_1 | SOURCE | L3J_2_AFS 1
InPort_4059813_0 | SINK | L3J_2_AFS 1
OutPort_4061064_1 | SOURCE | L3J_2_AFS 1
InPort_4059835_1 | SINK | L3J_2_AFS 1
OutPort_4059813_1 | SOURCE | L3J_2_AFS 1
InPort_4059984_0 | SINK | L3J_2_AFS 1
OutPort_4059835_2 | SOURCE | L3J_2_AFS 1
InPort_4061062_1 | SINK | L3J_2_AFS 1
OutPort_4059889_1 | SOURCE | L3J_2_AFS 1
InPort_4059889_2 | SINK | L3J_2_AFS 1
OutPort_4061469_2 | SOURCE | L3J_2_AFS 1
InPort_4060635_1 | SINK | L3J_2_AFS 1
OutPort_4059984_1 | SOURCE | L3J_2_AFS 1
InPort_4060368_1 | SINK | L3J_2_AFS 1
OutPort_4060266_0 | SOURCE | L3J_2_AFS 1
InPort_4060285_0 | SINK | L3J_2_AFS 1
OutPort_4061465_2 | SOURCE | L3J_2_AFS 1
InPort_4061469_1 | SINK | L3J_2_AFS 1
OutPort_4060285_1 | SOURCE | L3J_2_AFS 1
InPort_4060287_0 | SINK | L3J_2_AFS 1
OutPort_4060368_3 | SOURCE | L3J_2_AFS 1
InPort_4061465_1 | SINK | L3J_2_AFS 1
OutPort_4060287_1 | SOURCE | L3J_2_AFS 1
InPort_4060369_1 | SINK | L3J_2_AFS 1
OutPort_4060368_2 | SOURCE | L3J_2_AFS 1
InPort_4060391_0 | SINK | L3J_2_AFS 1
OutPort_4060635_2 | SOURCE | L3J_2_AFS 1
InPort_4060639_1 | SINK | L3J_2_AFS 1
OutPort_4060391_1 | SOURCE | L3J_2_AFS 1
Port_4064514_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064588_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064575_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064588_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064575_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064601_1 | SOURCEANDSINK | L3J_2_AFS 1
InPort_4064698_0 | SINK | L3J_2_AFS 1
OutPort_4066096_2 | SOURCE | L3J_2_AFS 1
InPort_4065742_1 | SINK | L3J_2_AFS 1
OutPort_4064698_1 | SOURCE | L3J_2_AFS 1
Port_4064706_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4064707_1 | SOURCEANDSINK | L3J_2_AFS 1
InPort_4066096_1 | SINK | L3J_2_AFS 1
OutPort_4064706_3 | SOURCE | L3J_2_AFS 1
Port_4064707_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4066094_2 | SOURCEANDSINK | L3J_2_AFS 1
InPort_4065810_2 | SINK | L3J_2_AFS 1
OutPort_4064713_0 | SOURCE | L3J_2_AFS 1
InPort_4064713_1 | SINK | L3J_2_AFS 1
OutPort_4065815_1 | SOURCE | L3J_2_AFS 1
InPort_4064726_0 | SINK | L3J_2_AFS 1
OutPort_4065810_1 | SOURCE | L3J_2_AFS 1
InPort_4065290_2 | SINK | L3J_2_AFS 1
OutPort_4064726_1 | SOURCE | L3J_2_AFS 1
InPort_4065024_0 | SINK | L3J_2_AFS 1
OutPort_4065742_2 | SOURCE | L3J_2_AFS 1
InPort_4065747_1 | SINK | L3J_2_AFS 1
OutPort_4065024_1 | SOURCE | L3J_2_AFS 1
InPort_4065302_3 | SINK | L3J_2_AFS 1
OutPort_4065263_0 | SOURCE | L3J_2_AFS 1
InPort_4065263_1 | SINK | L3J_2_AFS 1
OutPort_4065290_1 | SOURCE | L3J_2_AFS 1
InPort_4065265_1 | SINK | L3J_2_AFS 1
OutPort_4065304_2 | SOURCE | L3J_2_AFS 1
InPort_4065304_1 | SINK | L3J_2_AFS 1
OutPort_4065302_1 | SOURCE | L3J_2_AFS 1
InPort_4065353_2 | SINK | L3J_2_AFS 1
OutPort_4065302_2 | SOURCE | L3J_2_AFS 1
Port_4065363_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065371_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065363_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065513_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065502_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065513_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065502_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065522_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065516_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065522_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065516_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065578_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065565_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065580_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065565_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065576_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4066100_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065576_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065580_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065578_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065603_0 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065601_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4066098_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065601_2 | SOURCEANDSINK | L3J_2_AFS 1
Port_4066100_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4065603_1 | SOURCEANDSINK | L3J_2_AFS 1
Port_4066098_2 | SOURCEANDSINK | L3J_2_AFS 1
InPort_4065668_1 | SINK | L3J_2_AFS 1
OutPort_4065747_2 | SOURCE | L3J_2_AFS 1
InPort_4065815_2 | SINK | L3J_2_AFS 1
OutPort_4065668_2 | SOURCE | L3J_2_AFS 1
Port_4537319_1 | SOURCEANDSINK
Port_4537354_1 | SOURCEANDSINK
Port_4537939_1 | SOURCEANDSINK
Port_4541589_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541606_3 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541589_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541623_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541606_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541607_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541613_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541623_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541613_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541690_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541679_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541690_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541679_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541818_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541811_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541818_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541811_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541900_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541899_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541900_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4541899_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 1
Port_4542012_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_5258177_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542012_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542066_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_5258177_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542066_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542128_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542067_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542128_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542067_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542481_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542481_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542483_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542483_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542700_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542698_0 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542700_2 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4542698_1 | SOURCEANDSINK | Mecánica L3J_VENTILACIÓ_CTE_HS3 6
Port_4560110_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213903_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560110_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060351_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560403_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560635_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560403_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560522_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213438_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560522_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213525_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560530_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213439_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560536_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5213763_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560536_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060431_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560635_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060093_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560635_3 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560736_1 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4560736_2 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_5060384_0 | SOURCEANDSINK | L3J_4_SAN_FECAL 3
Port_4569213_1 | SOURCEANDSINK | AFS 3
Port_4792839_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_4792841_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_4792839_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_4792844_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_4792840_0 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_4792844_2 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
Port_4792840_1 | SOURCEANDSINK | Mecánica L3J_3_CLIMA_RET_AIRE 3
InPort_4792846_0 | SINK | Mecánica L3J_3_VENT_RETORN_AIRE 1
OutPort_4792847_2 | SOURCE | Mecánica L3J_3_VENT_RETORN_AIRE 1
InPort_4792851_1 | SINK | Mecánica L3J_3_VENT_RETORN_AIRE 1
OutPort_4792846_1 | SOURCE | Mecánica L3J_3_VENT_RETORN_AIRE 1
InPort_4792850_0 | SINK | Mecánica L3J_3_VENT_RETORN_AIRE 1
OutPort_4792851_2 | SOURCE | Mecánica L3J_3_VENT_RETORN_AIRE 1
OutPort_4792850_1 | SOURCE | Mecánica L3J_3_VENT_RETORN_AIRE 1
InPort_4968983_1 | SINK | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
OutPort_4792889_0 | SOURCE | Mecánica L3J_3_VENTILACIÓ_CTE_HS3 8
Port_4836964_1 | SOURCEANDSINK
Port_4837461_1 | SOURCEANDSINK
Port_4838352_1 | SOURCEANDSINK
